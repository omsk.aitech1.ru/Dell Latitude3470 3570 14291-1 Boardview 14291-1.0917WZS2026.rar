# Allegro board 14291-1.0917WZS2026.brd (continued)
## Nets (continued)
5V_S0: C2605.1 C2611.1 C4005.1 C6001.1 C6002.1 D5401.3 EC9718.1 EC9719.1 EC9720.1 EC9721.1 EC9722.1 FAN261.2 PR8223.1 Q5403.G R2702.1 R2703.2 R2704.1 R5409.1 R5413.1 R5527.1 R6006.1 R6504.1 R6512.2 R6705.1 R9202.2 U4001.13 U4001.14 U6002.1 U6002.2 U6002.5 U6002.6 U8301.4 VGABD1.1
5V_S5: C3504.1 C3510.1 C3511.1 C4031.1 C4032.1 DB2.1 EC9732.1 EC9733.1 EC9734.1 PC4518.1 PC4707.1 PC4807.1 PC5001.1 PC5101.1 PC5401.1 PG4532.1 PL4501.2 PR4303.1 PR4603.1 PR4657.1 PR4702.2 PR4803.2 PT4501.1 PU4701.7 PU4701.36 PU4801.3 PU4801.7 PU4801.36 PU5001.4 PU5101.12 PU5203.3 PU5401.6 Q6401.E Q6403.E Q6404.E Q6405.E Q6502.E R9201.1 U3501.5 U3502.5 U3503.5 U4001.1 U4001.2 U4001.4 U4002.4 U4006.4
+3V_1D5V_AVDD: C2715.1 C2721.1 HDA27.40 R2705.2 R2710.2 R2713.2
+3V_AVDD: C2716.1 C2717.1 C2719.1 HDA27.1 HDA27.9 R2722.1 R2724.1 R2731.2
+3VLP: KBC24.120 R2454.1 R2467.2
+5V_AVDD: C2710.1 C2711.1 HDA27.26 R2703.1
+5V_KB_BL: AFTP6248.1 C6501.1 KBLIT1.1 R6504.2
+5V_PVDD: C2706.1 C2707.1 C2708.1 C2709.1 HDA27.41 HDA27.46 R2702.2 R2704.2
+V1.00A_SIP: CPU1.AB17 CPU1.Y18 R1105.1 R1112.1 R1114.1 R1117.2 R1120.1 R1121.1 R1122.1 R1125.1 R1130.1 R1131.1 R1132.1 R1133.1 R1134.1
+V1.00U_CPU: C720.1 C721.1 C4012.1 CPU1.K20 CPU1.K21 R2492.1 R4025.2 R4036.1
+V1.00U_CPU_LS: R4025.1 U4006.5 U4006.6 U4006.7 U4006.8
+V1.8A: C4020.1 Q4003.D R1139.2 R4037.2
+V1.8A_SIP: C2108.1 CPU1.AA1 R1111.1 R1118.1 R1129.1 R1136.1 R1138.2 R1139.1
+V3.3A_SIP: R1108.1 R1109.1 R1110.2 R1115.1 R1116.1 R1123.1 R1124.1 R1126.1 R1127.1 R1128.1 R1135.1 R1712.1
+VCC19P2_1P0: CPU1.A14 R1131.2
+VCC24TBT_1P0: C2116.1 CPU1.A10 R1122.2
+VCCAMPHYPLL_1P0: C1184.1 CPU1.K15 CPU1.L15 R1119.2
+VCCAMPHYPLL_1P0_L: C1172.1 C1181.1 R1102.2 R1119.1
+VCCAPLL_1P0: CPU1.V15 R1120.2
+VCCAPLLEBB_1P0: C1173.1 C1180.1 CPU1.N18 R1101.2
+VCCDSW_1P0: C2103.1 CPU1.AL1
+VCCDTS_1P0: CPU1.T1 R1130.2
+VCCF24NS_1P0_L: C2115.1 CPU1.L19 R1125.2 R1803.2
+VCCF100_1P0_L: C2113.1 CPU1.K19 R1114.2
+VCCF100OC_1P0_L: C2114.1 CPU1.N20 R1132.2
+VCCF135_1P0: CPU1.L21 R1121.2
+VCCFHV: CPU1.AK20 R1133.2
+VCCGT: C1136.1 C1138.1 C1147.1 C1148.1 C1149.1 C1150.1 CPU1.A48 CPU1.A53 CPU1.A58 CPU1.A62 CPU1.A66 CPU1.AA63 CPU1.AA64 CPU1.AA66 CPU1.AA67 CPU1.AA69 CPU1.AA70 CPU1.AA71 CPU1.AC64 CPU1.AC65 CPU1.AC66 CPU1.AC67 CPU1.AC68 CPU1.AC69 CPU1.AC70 CPU1.AC71 CPU1.J43 CPU1.J45 CPU1.J46 CPU1.J48 CPU1.J50 CPU1.J52 CPU1.J53 CPU1.J55 CPU1.J56 CPU1.J58 CPU1.J60 CPU1.K48 CPU1.K50 CPU1.K52 CPU1.K53 CPU1.K55 CPU1.K56 CPU1.K58 CPU1.K60 CPU1.L62 CPU1.L63 CPU1.L64 CPU1.L65 CPU1.L66 CPU1.L67 CPU1.L68 CPU1.L69 CPU1.L70 CPU1.L71 CPU1.M62 CPU1.N63 CPU1.N64 CPU1.N66 CPU1.N67 CPU1.N69 CPU1.N70 CPU1.N71 CPU1.R63 CPU1.R64 CPU1.R65 CPU1.R66 CPU1.R67 CPU1.R68 CPU1.R69 CPU1.R70 CPU1.R71 CPU1.T62 CPU1.U65 CPU1.U68 CPU1.U71 CPU1.W63 CPU1.W64 CPU1.W65 CPU1.W66 CPU1.W67 CPU1.W68 CPU1.W69 CPU1.W70 CPU1.W71 CPU1.Y62 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PG4809.2 PL4801.2 PT4801.1 R721.1
+VCCIO: C1151.1 C1152.1 C1153.1 C1154.1 C4007.1 CPU1.AK28 CPU1.AK30 CPU1.AL30 CPU1.AL42 CPU1.AM28 CPU1.AM30 CPU1.AM42 PC1035.1 PC1036.1 PC1037.1 PU5203.6 PU5203.7 PU5203.8 R733.1 R801.1 R1107.2 R4048.1 U4002.5 U4002.6 U4002.7 U4002.8
+VCCMPHYAON_1P0: C2104.1 CPU1.K17 CPU1.L1 R1134.2
+VCCMPHYGTAON_1P0_LS_SIP: C1174.1 C1182.1 C1704.1 CPU1.N15 CPU1.N16 CPU1.N17 CPU1.P15 CPU1.P16 R1101.1 R1102.1 R1106.1 R1724.2 R1735.2
+VCCPAZIO: CPU1.AJ19 R1118.2 R1135.2
+VCCPDSW_3P3: CPU1.AD17 CPU1.AD18 CPU1.AJ17 R1703.1 R1707.1 R1711.2 R1712.2 R1723.1
+VCCPGPPA: CPU1.AK15 R1109.2 R1111.2
+VCCPGPPB: CPU1.AG15 R1116.2
+VCCPGPPC: C2106.1 CPU1.Y16 R1123.2
+VCCPGPPD: CPU1.Y15 R1113.2
+VCCPGPPD_TCH: C1183.1 R1108.2 R1113.1 R1129.2
+VCCPGPPE: C2107.1 CPU1.T16 R1124.2
+VCCPGPPF: CPU1.AF16 R1138.1
+VCCPGPPG: CPU1.AD15 R1128.2 R1136.2
+VCCPRIM_1P0: C2101.1 CPU1.AB19 CPU1.AB20 CPU1.P18 R1112.2
+VCCPRIM_3P3: C2105.1 CPU1.AJ21 CPU1.V19 R1127.2 R1701.1
+VCCPRIM_CORE: C2102.1 C2120.1 CPU1.AF18 CPU1.AF19 CPU1.V20 CPU1.V21 PC1038.1 PC1039.1 R1103.2 R1104.2 R1105.2 R1107.1
+VCCPRTC_3P3: CPU1.AK19 CPU1.BB14 R2106.2
+VCCPRTCPRIM_3P3: C2109.1 C2110.1 C2111.1 CPU1.AK17 R1115.2
+VCCPSPI: CPU1.AJ16 R1126.2
+VCCSA: CPU1.AK23 CPU1.AK25 CPU1.G23 CPU1.G25 CPU1.G27 CPU1.G28 CPU1.J22 CPU1.J23 CPU1.J27 CPU1.K23 CPU1.K25 CPU1.K27 CPU1.K28 CPU1.K30 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1097.1 PC1098.1 PG5025.1 PG5026.1 PG5027.1 PG5028.1 PG5029.1 PG5030.1 PG5031.1 R735.1 R1104.1
+VCCSRAM_1P0: C1175.1 C1176.1 CPU1.AF20 CPU1.AF21 CPU1.T19 CPU1.T20 R1106.2
+VCCST_CPU: C716.1 CPU1.A18 PC4610.1 PR4621.1 PR4622.1 PR4623.1 PR4624.1 R419.1 R603.2 R723.1 R726.1 R727.1 R4036.2 R4045.2
+VCCSTG: C717.1 CPU1.A22 CPU1.G20 PR4669.1 R401.1 R408.2 R409.2 R416.2 R417.2 R421.2 R422.2 R423.2 R1722.1 R2440.1 R4045.1 R4048.2
+VDDQ_CPU_CLK: C715.1 C722.1 CPU1.AM40 R705.2
DVSS: HDA27.4 R2732.1
GND: AFTP2501.1 AFTP2803.1 AFTP3803.1 AFTP3806.1 AFTP3906.1 AFTP3909.1 AFTP3910.1 AFTP6102.1 AFTP6201.1 AFTP6217.1 AFTP6235.1 AFTP6244.1 AFTP6245.1 AFTP6314.1 BATT1.6 BATT1.7 BATT1.8 BATT1.9 BATT1.10 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C1101.2 C1102.2 C1103.2 C1116.2 C1117.2 C1136.2 C1138.2 C1147.2 C1148.2 C1149.2 C1150.2 C1151.2 C1152.2 C1153.2 C1154.2 C1172.2 C1173.2 C1174.2 C1175.2 C1176.2 C1180.2 C1181.2 C1182.2 C1183.2 C1184.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1220.2 C1221.2 C1222.2 C1301.2 C1302.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.2 C1310.2 C1311.2 C1312.2 C1313.2 C1314.2 C1315.2 C1316.2 C1317.2 C1318.2 C1321.2 C1322.2 C1323.2 C1701.2 C1702.2 C1703.2 C1704.2 C1801.1 C1802.1 C1803.2 C1804.2 C1901.2 C1902.2 C2101.2 C2102.2 C2103.2 C2104.2 C2105.2 C2106.2 C2107.2 C2108.2 C2109.2 C2110.2 C2111.2 C2112.2 C2113.2 C2114.2 C2115.2 C2116.2 C2117.2 C2118.2 C2119.2 C2120.2 C2402.1 C2403.2 C2405.2 C2406.2 C2409.2 C2410.2 C2411.2 C2412.2 C2413.2 C2414.2 C2417.2 C2418.2 C2420.2 C2423.2 C2424.1 C2425.1 C2426.2 C2428.2 C2429.2 C2501.2 C2502.2 C2503.2 C2504.2 C2505.2 C2601.2 C2602.2 C2603.2 C2604.2 C2605.2 C2608.2 C2609.2 C2610.2 C2611.2 C2701.2 C2704.1 C2706.2 C2707.2 C2708.2 C2709.2 C2714.2 C2716.2 C2717.2 C2718.2 C2719.2 C2723.1 C3101.2 C3102.2 C3103.2 C3104.2 C3105.2 C3106.2 C3107.2 C3108.2 C3112.2 C3113.2 C3114.2 C3115.2 C3116.2 C3117.2 C3118.2 C3119.2 C3201.2 C3406.2 C3504.2 C3507.2 C3508.2 C3509.2 C3510.2 C3511.2 C3512.2 C3513.2 C3514.2 C3515.2 C3516.2 C3517.2 C3518.2 C3519.2 C3603.2 C3618.2 C4001.2 C4002.2 C4003.2 C4004.2 C4005.2 C4006.2 C4007.2 C4008.2 C4009.2 C4012.2 C4013.2 C4014.2 C4016.2 C4017.2 C4019.2 C4020.2 C4021.2 C4029.2 C4030.2 C4031.2 C4032.2 C4101.2 C4102.2 C5401.2 C5505.2 C5515.2 C5516.2 C5535.1 C5536.1 C5538.2 C5539.2 C5540.2 C5541.2 C5542.1 C6001.2 C6002.2 C6007.2 C6008.2 C6009.2 C6107.2 C6108.2 C6109.2 C6110.2 C6111.2 C6112.2 C6113.2 C6401.2 C6501.2 C6502.2 C6504.2 C6701.2 C6702.2 C6703.2 C7310.2 C7312.2 C7315.2 C7316.2 C7317.2 C7318.2 C7319.2 C7323.2 C7324.2 C7326.2 C7501.2 C7502.2 C7505.2 C7506.2 C7507.2 C7513.2 C7514.2 C7517.2 C7518.2 C7520.2 C7525.2 C7601.2 C7602.2 C7603.2 C7604.2 C7605.2 C7606.2 C7607.1 C7608.1 C7609.2 C7610.2 C7701.2 C7702.2 C7703.2 C7704.2 C7708.2 C7709.2 C7710.2 C7711.2 C7712.2 C7713.2 C7714.2 C7717.2 C7719.2 C7720.2 C7721.2 C7722.2 C7723.2 C7724.2 C7725.2 C7726.2 C7728.2 C7729.2 C7730.2 C7731.2 C7732.2 C7734.2 C7735.2 C7736.2 C7803.2 C7804.2 C7805.2 C7810.2 C7811.2 C7812.2 C7813.2 C7814.2 C7815.2 C7816.2 C7817.2 C7820.2 C7821.2 C7822.2 C7827.2 C7829.2 C7830.2 C7831.2 C7832.2 C7833.2 C7834.2 C7835.2 C7836.2 C7902.2 C7906.2 C7909.2 C7910.2 C7911.2 C7912.2 C7913.2 C7915.2 C7916.2 C7917.2 C7919.2 C7921.2 C7922.2 C7923.2 C7924.2 C7925.2 C7926.2 C7927.2 C7928.2 C7929.2 C7930.2 C8301.2 C8302.2 C8303.1 C8304.2 C8305.2 C8306.2 C8307.2 C9101.2 C9102.2 C9103.2 C9104.2 C9105.2 C9106.2 C9201.2 C9202.2 CPU1.A67 CPU1.AA2 CPU1.AA4 CPU1.AA65 CPU1.AA68 CPU1.AB8 CPU1.AB15 CPU1.AB16 CPU1.AB18 CPU1.AB21 CPU1.AD8 CPU1.AD13 CPU1.AD16 CPU1.AD19 CPU1.AD20 CPU1.AD21 CPU1.AD62 CPU1.AE64 CPU1.AE65 CPU1.AE66 CPU1.AE67 CPU1.AE68 CPU1.AE69 CPU1.AF1 CPU1.AF2 CPU1.AF4 CPU1.AF10 CPU1.AF15 CPU1.AF17 CPU1.AF63 CPU1.AG16 CPU1.AG17 CPU1.AG18 CPU1.AG19 CPU1.AG20 CPU1.AG21 CPU1.AG71 CPU1.AH6 CPU1.AH13 CPU1.AH63 CPU1.AH64 CPU1.AH67 CPU1.AJ4 CPU1.AJ15 CPU1.AJ18 CPU1.AJ20 CPU1.AK8 CPU1.AK11 CPU1.AK16 CPU1.AK18 CPU1.AK21 CPU1.AK22 CPU1.AK27 CPU1.AK63 CPU1.AK68 CPU1.AK69 CPU1.AL2 CPU1.AL4 CPU1.AL28 CPU1.AL32 CPU1.AL35 CPU1.AL38 CPU1.AL45 CPU1.AL48 CPU1.AL52 CPU1.AL55 CPU1.AL58 CPU1.AL64 CPU1.AL65 CPU1.AL66 CPU1.AM8 CPU1.AM13 CPU1.AM21 CPU1.AM25 CPU1.AM27 CPU1.AM43 CPU1.AM45 CPU1.AM46 CPU1.AM55 CPU1.AM60 CPU1.AM61 CPU1.AM68 CPU1.AM71 CPU1.AN20 CPU1.AN23 CPU1.AN28 CPU1.AN30 CPU1.AN32 CPU1.AN33 CPU1.AN35 CPU1.AN37 CPU1.AN38 CPU1.AN40 CPU1.AN42 CPU1.AN43 CPU1.AN58 CPU1.AN63 CPU1.AP10 CPU1.AP18 CPU1.AP20 CPU1.AP23 CPU1.AP28 CPU1.AP32 CPU1.AP35 CPU1.AP38 CPU1.AP42 CPU1.AP58 CPU1.AP63 CPU1.AP68 CPU1.AP70 CPU1.AR5 CPU1.AR8 CPU1.AR11 CPU1.AR15 CPU1.AR16 CPU1.AR20 CPU1.AR23 CPU1.AR28 CPU1.AR35 CPU1.AR42 CPU1.AR43 CPU1.AR45 CPU1.AR46 CPU1.AR48 CPU1.AR50 CPU1.AR52 CPU1.AR53 CPU1.AR55 CPU1.AR58 CPU1.AR63 CPU1.AT2 CPU1.AT4 CPU1.AT20 CPU1.AT23 CPU1.AT28 CPU1.AT35 CPU1.AT42 CPU1.AT56 CPU1.AT58 CPU1.AT63 CPU1.AT68 CPU1.AT71 CPU1.AU10 CPU1.AU15 CPU1.AU20 CPU1.AU32 CPU1.AU38 CPU1.AV1 CPU1.AV68 CPU1.AV69 CPU1.AV70 CPU1.AV71 CPU1.AW6 CPU1.AW8 CPU1.AW10 CPU1.AW12 CPU1.AW14 CPU1.AW16 CPU1.AW18 CPU1.AW21 CPU1.AW23 CPU1.AW26 CPU1.AW28 CPU1.AW30 CPU1.AW32 CPU1.AW34 CPU1.AW36 CPU1.AW38 CPU1.AW41 CPU1.AW43 CPU1.AW45 CPU1.AW47 CPU1.AW49 CPU1.AW50 CPU1.AW51 CPU1.AW53 CPU1.AW55 CPU1.AW57 CPU1.AW60 CPU1.AW62 CPU1.AW64 CPU1.AW66 CPU1.AY66 CPU1.B10 CPU1.B14 CPU1.B18 CPU1.B22 CPU1.B30 CPU1.B34 CPU1.B39 CPU1.B44 CPU1.B48 CPU1.B53 CPU1.B58 CPU1.B62 CPU1.B66 CPU1.BA6 CPU1.BA10 CPU1.BA14 CPU1.BA18 CPU1.BA23 CPU1.BA28 CPU1.BA32 CPU1.BA36 CPU1.BA41 CPU1.BA45 CPU1.BA49 CPU1.BA53 CPU1.BA57 CPU1.BA62 CPU1.BA66 CPU1.BB6 CPU1.BB18 CPU1.BB26 CPU1.BB30 CPU1.BB34 CPU1.BB38 CPU1.BB43 CPU1.BB55 CPU1.BB60 CPU1.BB64 CPU1.BB67 CPU1.C5 CPU1.C25 CPU1.D6 CPU1.D10 CPU1.D11 CPU1.D14 CPU1.D18 CPU1.D22 CPU1.D25 CPU1.D26 CPU1.D30 CPU1.D34 CPU1.D39 CPU1.D44 CPU1.D45 CPU1.D47 CPU1.D48 CPU1.D53 CPU1.D58 CPU1.D62 CPU1.D66 CPU1.D69 CPU1.E6 CPU1.E11 CPU1.E15 CPU1.E18 CPU1.E21 CPU1.E46 CPU1.E50 CPU1.E53 CPU1.E56 CPU1.E65 CPU1.E71 CPU1.F1 CPU1.F2 CPU1.F4 CPU1.F8 CPU1.F13 CPU1.F22 CPU1.F23 CPU1.F27 CPU1.F28 CPU1.F32 CPU1.F33 CPU1.F35 CPU1.F37 CPU1.F38 CPU1.F40 CPU1.F42 CPU1.F68 CPU1.G5 CPU1.G6 CPU1.G10 CPU1.G22 CPU1.G43 CPU1.G45 CPU1.G48 CPU1.G52 CPU1.G55 CPU1.G58 CPU1.G60 CPU1.G63 CPU1.G66 CPU1.H15 CPU1.H18 CPU1.H71 CPU1.J8 CPU1.J11 CPU1.J13 CPU1.J25 CPU1.J28 CPU1.J32 CPU1.J35 CPU1.J38 CPU1.J42 CPU1.K16 CPU1.K18 CPU1.K22 CPU1.K61 CPU1.K63 CPU1.K64 CPU1.K65 CPU1.K66 CPU1.K67 CPU1.K68 CPU1.K70 CPU1.K71 CPU1.L2 CPU1.L4 CPU1.L8 CPU1.L11 CPU1.L16 CPU1.L17 CPU1.L18 CPU1.L20 CPU1.N6 CPU1.N10 CPU1.N13 CPU1.N19 CPU1.N21 CPU1.N65 CPU1.N68 CPU1.P17 CPU1.P19 CPU1.P20 CPU1.P21 CPU1.R6 CPU1.R13 CPU1.T2 CPU1.T4 CPU1.T15 CPU1.T17 CPU1.T18 CPU1.T21 CPU1.U10 CPU1.U63 CPU1.U64 CPU1.U66 CPU1.U67 CPU1.U69 CPU1.U70 CPU1.V16 CPU1.V17 CPU1.V18 CPU1.W6 CPU1.W9 CPU1.W13 CPU1.Y17 CPU1.Y19 CPU1.Y20 CPU1.Y21 D502.1 D1217.1 D1319.1 D2601.A D4304.1 D4305.1 D4306.1 DB1.8 DB1.10 DB1.11 DB1.12 DB2.4 DB2.5 DB2.6 DB3.4 DB3.7 DB3.8 DCIN1.5 DCIN1.6 DCIN1.7 DCIN1.8 DM1.2 DM1.3 DM1.8 DM1.9 DM1.11 DM1.13 DM1.14 DM1.19 DM1.20 DM1.25 DM1.26 DM1.28 DM1.31 DM1.32 DM1.37 DM1.38 DM1.43 DM1.44 DM1.46 DM1.48 DM1.49 DM1.54 DM1.55 DM1.60 DM1.61 DM1.63 DM1.65 DM1.66 DM1.71 DM1.72 DM1.127 DM1.128 DM1.133 DM1.134 DM1.136 DM1.138 DM1.139 DM1.144 DM1.145 DM1.150 DM1.151 DM1.153 DM1.155 DM1.156 DM1.161 DM1.162 DM1.167 DM1.168 DM1.170 DM1.172 DM1.173 DM1.178 DM1.179 DM1.184 DM1.185 DM1.187 DM1.189 DM1.190 DM1.195 DM1.196 DM1.205 DM1.206 DM2.2 DM2.3 DM2.8 DM2.9 DM2.11 DM2.13 DM2.14 DM2.19 DM2.20 DM2.25 DM2.26 DM2.28 DM2.31 DM2.32 DM2.37 DM2.38 DM2.43 DM2.44 DM2.46 DM2.48 DM2.49 DM2.54 DM2.55 DM2.60 DM2.61 DM2.63 DM2.65 DM2.66 DM2.71 DM2.72 DM2.127 DM2.128 DM2.133 DM2.134 DM2.136 DM2.138 DM2.139 DM2.144 DM2.145 DM2.150 DM2.151 DM2.153 DM2.155 DM2.156 DM2.161 DM2.162 DM2.167 DM2.168 DM2.170 DM2.172 DM2.173 DM2.178 DM2.179 DM2.184 DM2.185 DM2.187 DM2.189 DM2.190 DM2.195 DM2.196 DM2.205 DM2.206 EC1001.2 EC1002.2 EC1003.2 EC1004.2 EC1005.2 EC1702.2 EC1703.2 EC1704.2 EC1706.2 EC1707.2 EC1708.2 EC1709.2 EC1710.1 EC1711.2 EC1712.2 EC1713.1 EC1801.2 EC1802.2 EC1803.1 EC1805.2 EC1806.2 EC1807.2 EC1808.2 EC1901.1 EC1902.2 EC1903.2 EC2002.2 EC2401.2 EC2501.2 EC2502.2 EC2503.2 EC2504.2 EC2505.2 EC2506.2 EC2601.2 EC2602.2 EC2701.2 EC2703.2 EC2704.2 EC2705.2 EC2706.2 EC2707.2 EC2708.2 EC2709.2 EC2901.1 EC2902.1 EC2903.1 EC2904.1 EC3101.1 EC3102.1 EC3103.1 EC3104.1 EC3105.1 EC3106.1 EC3107.1 EC3108.1 EC4001.2 EC4301.2 EC4302.2 EC4303.2 EC4304.2 EC4306.1 EC4307.2 EC4308.2 EC4309.2 EC4310.2 EC4311.2 EC4312.2 EC4313.2 EC4314.2 EC5101.2 EC5102.2 EC5103.2 EC5301.2 EC5501.2 EC5502.2 EC5503.2 EC5504.2 EC5505.2 EC6001.2 EC6102.2 EC6103.2 EC6401.2 EC6402.2 EC6403.2 EC6405.2 EC6406.2 EC6407.2 EC6501.2 EC6502.2 EC6503.2 EC6504.2 EC6505.2 EC6506.2 EC6507.2 EC9201.1 EC9202.1 EC9701.2 EC9702.2 EC9703.2 EC9704.2 EC9705.2 EC9706.2 EC9707.2 EC9708.2 EC9709.2 EC9710.2 EC9711.2 EC9712.2 EC9713.2 EC9714.2 EC9715.2 EC9716.2 EC9717.2 EC9718.2 EC9719.2 EC9720.2 EC9721.2 EC9722.2 EC9723.2 EC9724.2 EC9725.2 EC9726.2 EC9727.2 EC9728.2 EC9732.2 EC9733.2 EC9734.2 EC9735.2 EC9736.2 EC9737.2 EC9738.2 EC9739.2 EC9743.2 EC9744.2 EC9745.2 ED301.2 ED302.2 ED303.2 ED304.2 ED305.2 ED306.2 ED6401.2 EU3404.2 EU3601.2 EU3602.2 EU5701.3 EU5701.8 EU5702.3 EU5702.8 EU5703.3 EU5703.8 FAN1.3 FAN1.5 FAN1.6 FAN261.5 FAN261.6 FAN261.7 FAN261.8 FPR1.1 FPR1.7 FPR1.8 G1901.1 G6401.1 G6402.1 GPU1.A2 GPU1.A26 GPU1.AA7 GPU1.AB7 GPU1.AB11 GPU1.AB14 GPU1.AB17 GPU1.AB20 GPU1.AB24 GPU1.AC2 GPU1.AC5 GPU1.AC8 GPU1.AC22 GPU1.AC26 GPU1.AD12 GPU1.AD13 GPU1.AD15 GPU1.AD16 GPU1.AD18 GPU1.AD19 GPU1.AD21 GPU1.AD22 GPU1.AE11 GPU1.AE14 GPU1.AE17 GPU1.AE20 GPU1.AF1 GPU1.AF5 GPU1.AF8 GPU1.AF11 GPU1.AF14 GPU1.AF17 GPU1.AF20 GPU1.AF23 GPU1.AG2 GPU1.AG26 GPU1.B1 GPU1.B5 GPU1.B8 GPU1.B11 GPU1.B14 GPU1.B17 GPU1.B20 GPU1.B23 GPU1.B27 GPU1.E2 GPU1.E5 GPU1.E8 GPU1.E11 GPU1.E14 GPU1.E17 GPU1.E20 GPU1.E22 GPU1.E25 GPU1.H2 GPU1.H5 GPU1.H23 GPU1.H25 GPU1.K11 GPU1.K13 GPU1.K15 GPU1.K17 GPU1.L2 GPU1.L5 GPU1.L10 GPU1.L12 GPU1.L14 GPU1.L16 GPU1.L18 GPU1.L23 GPU1.L25 GPU1.M11 GPU1.M13 GPU1.M15 GPU1.M17 GPU1.N10 GPU1.N12 GPU1.N14 GPU1.N16 GPU1.N18 GPU1.P2 GPU1.P5 GPU1.P11 GPU1.P13 GPU1.P15 GPU1.P17 GPU1.P23 GPU1.P26 GPU1.R10 GPU1.R12 GPU1.R14 GPU1.R16 GPU1.R18 GPU1.T11 GPU1.T13 GPU1.T15 GPU1.T17 GPU1.U2 GPU1.U5 GPU1.U10 GPU1.U12 GPU1.U14 GPU1.U16 GPU1.U18 GPU1.U23 GPU1.U26 GPU1.V11 GPU1.V13 GPU1.V15 GPU1.V17 GPU1.Y2 GPU1.Y5 GPU1.Y23 GPU1.Y26 H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 H7.1 HCPU1.1 HCPU2.1 HCPU3.1 HDA27.49 HDD1.1 HDD1.4 HDD1.7 HDD1.8 HDD1.9 HDD1.18 HDD1.19 HDD1.21 HDD1.22 HDD1.23 HDD1.24 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI1.23 HGPU1.1 HGPU2.1 HGPU3.1 IOBD1.1 IOBD1.2 IOBD1.5 IOBD1.8 IOBD1.18 IOBD1.19 IOBD1.20 IRCCD1.5 IRCCD1.6 IRCCD1.7 IRCCD1.8 KB1.1 KB1.31 KB1.32 KBC24.17 KBC24.51 KBC24.64 KBC24.84 KBC24.100 KBC24.124 KBLIT1.5 KBLIT1.6 LCD1.13 LCD1.16 LCD1.19 LCD1.24 LCD1.25 LCD1.29 LCD1.36 LCD1.41 LCD1.42 LEDBD1.5 LEDBD1.6 LEDBD1.7 LEDBD1.8 LOM31.33 MESW1.1 MESW1.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC4302.2 PC4303.2 PC4304.2 PC4305.2 PC4306.2 PC4309.2 PC4401.1 PC4405.2 PC4406.2 PC4407.2 PC4408.2 PC4409.2 PC4410.2 PC4411.2 PC4413.2 PC4415.2 PC4416.2 PC4417.2 PC4418.2 PC4419.2 PC4509.2 PC4517.2 PC4518.2 PC4519.2 PC4520.2 PC4524.2 PC4525.2 PC4526.2 PC4527.2 PC4528.2 PC4529.2 PC4530.2 PC4531.2 PC4536.2 PC4610.2 PC4701.2 PC4702.2 PC4703.2 PC4704.2 PC4705.2 PC4707.2 PC4708.2 PC4709.2 PC4710.2 PC4802.2 PC4803.2 PC4804.2 PC4805.2 PC4806.2 PC4807.2 PC4808.2 PC4810.2 PC4811.2 PC5001.2 PC5002.2 PC5027.2 PC5029.2 PC5031.2 PC5101.2 PC5102.2 PC5103.2 PC5104.2 PC5106.2 PC5109.2 PC5111.2 PC5112.2 PC5113.1 PC5114.2 PC5115.2 PC5116.2 PC5117.2 PC5118.2 PC5120.2 PC5121.2 PC5122.2 PC5123.2 PC5124.2 PC5125.2 PC5126.2 PC5127.2 PC5128.2 PC5227.2 PC5301.2 PC5302.2 PC5303.2 PC5304.2 PC5307.2 PC5308.2 PC5309.2 PC5310.2 PC5311.2 PC5401.2 PC5402.2 PC5403.2 PC5404.2 PC5406.2 PC5407.2 PC5408.2 PC5409.2 PC8202.1 PC8203.1 PC8205.2 PC8206.2 PC8207.2 PC8208.2 PC8209.2 PC8210.2 PC8212.2 PC8213.2 PC8214.2 PC8215.2 PC8217.2 PC8218.2 PC8220.1 PC8221.1 PC8222.2 PC8224.2 PC8225.1 PC8226.1 PC8301.2 PC8302.2 PC8303.2 PC8304.2 PC8306.2 PC8307.2 PC8308.2 PC8309.2 PC8310.2 PD4301.A PD4302.1 PD4303.3 PD4304.A PG4411.2 PG4601.2 PQ4302.E PQ4303.1 PQ4303.4 PQ4304.E PQ4306.1 PQ4306.4 PQ4308.S PQ4402.1 PQ4402.4 PQ4403.S PQ4405.1 PQ4405.4 PQ8301.1 PQ8301.4 PQ8302.S PQ8303.1 PQ8303.4 PQ8305.1 PQ8305.4 PQ8306.1 PQ8306.4 PQ8307.1 PQ8307.4 PR4302.2 PR4308.2 PR4313.2 PR4316.2 PR4318.2 PR4409.2 PR4413.1 PR4430.2 PR4432.2 PR4433.2 PR4451.2 PR4517.2 PR4523.2 PR4526.2 PR4530.2 PR4531.2 PR4652.2 PR4653.1 PR4656.1 PR4661.2 PR5102.2 PR5106.2 PR5108.2 PR5305.2 PR5307.2 PR5308.1 PR5401.2 PR5404.2 PR8213.2 PR8224.2 PR8259.2 PR8302.2 PT4501.2 PT4502.2 PT4701.2 PT4702.2 PT4703.2 PT4801.2 PT8206.2 PT8207.2 PT8208.2 PU4401.22 PU4405.1 PU4405.2 PU4405.3 PU4502.1 PU4502.2 PU4502.3 PU4503.21 PU4505.1 PU4505.2 PU4505.3 PU4701.3 PU4701.5 PU4701.19 PU4701.20 PU4701.21 PU4701.22 PU4701.23 PU4701.24 PU4701.31 PU4701.37 PU4801.5 PU4801.19 PU4801.20 PU4801.21 PU4801.22 PU4801.23 PU4801.24 PU4801.31 PU4801.37 PU5001.6 PU5001.9 PU5003.1 PU5003.2 PU5003.3 PU5101.4 PU5101.7 PU5101.10 PU5101.21 PU5103.1 PU5103.2 PU5103.3 PU5203.5 PU5301.9 PU5401.1 PU5402.2 PU8201.21 PU8202.5 PU8202.6 PU8202.7 PU8204.5 PU8204.6 PU8204.7 PU8206.5 PU8206.6 PU8206.7 PU8208.5 PU8208.6 PU8208.7 PU8301.11 PWR1.4 PWR1.5 PWR1.6 PWSW2.1 PWSW2.2 PWSW2.5 PWSW2.6 Q1701.1 Q1701.4 Q1702.1 Q1702.4 Q1901.S Q2408.S Q2505.S Q3101.S Q4001.1 Q4001.4 Q4004.S Q4009.S Q5403.S Q6001.1 Q6001.4 Q6101.1 Q6101.4 Q6501.S Q6505.S Q6701.1 Q6701.4 Q9102.S R402.2 R405.2 R406.2 R407.2 R412.2 R413.2 R501.2 R502.2 R503.2 R601.2 R602.2 R604.2 R605.2 R720.2 R722.2 R730.2 R734.2 R806.2 R1201.2 R1202.2 R1301.2 R1501.2 R1502.2 R1603.2 R1715.2 R1717.2 R1719.2 R1725.1 R1732.1 R1733.1 R1823.2 R1825.2 R1836.2 R1901.2 R1902.2 R1904.1 R2008.2 R2016.2 R2018.2 R2019.2 R2024.2 R2026.2 R2034.2 R2417.2 R2436.2 R2445.1 R2448.2 R2449.1 R2454.2 R2504.2 R2510.2 R2605.1 R2611.2 R2706.2 R2717.2 R2727.2 R2730.2 R2732.2 R3107.2 R3111.2 R3112.1 R4003.2 R4006.2 R4019.2 R4203.2 R4207.2 R4209.2 R4211.2 R4214.2 R4215.2 R5410.2 R5412.2 R5413.2 R5418.1 R5506.1 R5526.2 R5528.2 R5531.2 R6005.2 R6101.2 R6505.2 R6507.2 R6513.2 R6707.2 R7301.2 R7302.2 R7306.2 R7506.2 R7507.1 R7508.2 R7509.2 R7510.2 R7511.2 R7512.2 R7518.2 R7601.2 R7602.2 R7607.1 R7609.2 R7610.2 R7614.2 R7618.2 R7619.2 R7620.2 R7621.2 R7622.2 R7627.2 R7628.1 R7632.2 R7637.2 R7642.2 R7647.2 R7650.2 R7654.2 R7655.2 R7807.2 R7808.1 R7809.1 R7904.2 R7912.1 R7913.1 R8304.2 R9102.2 R9118.2 R9804.2 RJ45.9 RJ45.10 RN2009.1(A) RN2009.2(A) RN5502.1(A) RN5502.2(A) RN5502.3(A) RN7401.1(A) RN7401.2(A) RN7402.1(A) RN7402.2(A) RN7403.1(A) RN7403.2(A) RN7404.1(A) RN7404.2(A) RN7602.1(A) RN7602.2(A) RTC1.2 RTC1.3 RTC1.4 SKT25.4 SKT26.4 SPI25.4 SPI252.4 SPK1.5 SPK1.6 SPR1.1 SPR2.1 SPR3.1 TC1201.2 TC3501.2 TC3502.2 THM26.5 TPAD1.5 TPAD1.9 TPAD1.10 U1701.3 U1702.3 U2401.2 U3201.3 U3201.8 U3202.3 U3202.8 U3501.2 U3502.2 U3503.2 U3601.3 U3601.8 U3602.3 U3602.8 U4001.11 U4001.15 U4002.3 U4003.3 U4005.3 U4006.3 U4101.1 U5501.2 U6001.3 U6001.8 U6701.5 U6701.6 U6701.7 U6701.8 U7301.3 U8301.11 U8301.15 U9101.9 U9101.16 U9101.23 U9101.32 U9101.33 USB1.4 USB1.7 USB1.10 USB1.11 USB1.12 USB1.13 USB2.4 USB2.7 USB2.10 USB2.11 USB2.12 USB2.13 VGABD1.4 VGABD1.7 VGABD1.10 VGABD1.13 VGABD1.17 VGABD1.18 VRAM1.A9 VRAM1.B1 VRAM1.B3 VRAM1.B9 VRAM1.D1 VRAM1.D8 VRAM1.E1 VRAM1.E2 VRAM1.E8 VRAM1.F9 VRAM1.G1 VRAM1.G8 VRAM1.G9 VRAM1.J2 VRAM1.J8 VRAM1.M1 VRAM1.M9 VRAM1.P1 VRAM1.P9 VRAM1.T1 VRAM1.T9 VRAM2.A9 VRAM2.B1 VRAM2.B3 VRAM2.B9 VRAM2.D1 VRAM2.D8 VRAM2.E1 VRAM2.E2 VRAM2.E8 VRAM2.F9 VRAM2.G1 VRAM2.G8 VRAM2.G9 VRAM2.J2 VRAM2.J8 VRAM2.M1 VRAM2.M9 VRAM2.P1 VRAM2.P9 VRAM2.T1 VRAM2.T9 VRAM3.A9 VRAM3.B1 VRAM3.B3 VRAM3.B9 VRAM3.D1 VRAM3.D8 VRAM3.E1 VRAM3.E2 VRAM3.E8 VRAM3.F9 VRAM3.G1 VRAM3.G8 VRAM3.G9 VRAM3.J2 VRAM3.J8 VRAM3.M1 VRAM3.M9 VRAM3.P1 VRAM3.P9 VRAM3.T1 VRAM3.T9 VRAM4.A9 VRAM4.B1 VRAM4.B3 VRAM4.B9 VRAM4.D1 VRAM4.D8 VRAM4.E1 VRAM4.E2 VRAM4.E8 VRAM4.F9 VRAM4.G1 VRAM4.G8 VRAM4.G9 VRAM4.J2 VRAM4.J8 VRAM4.M1 VRAM4.M9 VRAM4.P1 VRAM4.P9 VRAM4.T1 VRAM4.T9 WLAN1.1 WLAN1.7 WLAN1.18 WLAN1.23 WLAN1.24 WLAN1.29 WLAN1.30 WLAN1.33 WLAN1.36 WLAN1.39 WLAN1.45 WLAN1.51 WLAN1.57 WLAN1.63 WLAN1.69 WLAN1.75 WLAN1.76 WLAN1.77 X7601.2 X7601.4
V0.85A_VID0: CPU1.AN11 TP2101.1
V0.85A_VID1: CPU1.AN13 TP2102.1
V3D3_STB: HDA27.20 R2712.1
VCC1R05VIDEO_PEX_PLLVDD: C7317.1 C7318.1 C7319.1 GPU1.AA14 GPU1.AA15 L7301.1
VCC_CORE: C1101.1 C1102.1 C1103.1 C1116.1 C1117.1 CPU1.A30 CPU1.A34 CPU1.A39 CPU1.A44 CPU1.AK33 CPU1.AK35 CPU1.AK37 CPU1.AK38 CPU1.AK40 CPU1.AL33 CPU1.AL37 CPU1.AL40 CPU1.AM32 CPU1.AM33 CPU1.AM35 CPU1.AM37 CPU1.AM38 CPU1.G30 CPU1.G32 CPU1.G33 CPU1.G35 CPU1.G37 CPU1.G38 CPU1.G40 CPU1.G42 CPU1.J30 CPU1.J33 CPU1.J37 CPU1.J40 CPU1.K33 CPU1.K35 CPU1.K37 CPU1.K38 CPU1.K40 CPU1.K42 CPU1.K43 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PG4708.2 PL4701.2 PT4701.1 R719.1
VCC_OPC_1P8_H63: CPU1.G61 CPU1.H63 TP704.1 TP708.1
VCC_SENSE: CPU1.E32 PR4648.1 R719.2
VCCGT_SENSE: CPU1.J70 PR4617.1 R721.2
VCCIO_VR_FB: CPU1.AM23 R733.2
VCCPRIM_CORE: PG5211.1 PG5212.1 PG5213.1 PG5214.1 R1103.1
VCCRTCEXT: C2112.1 CPU1.BB10
VCCSA_SENSE: CPU1.H20 PR4607.1 R735.2
VCCSTG_EN: R4008.2 R4012.1 R4019.1 R4022.2 U4003.4
VCCSTG_EN_D: D4004.A R4008.1
VCCSTG_EN_R: R4012.2 U4002.2
VCCSTU_EN: EC4001.1 R4023.2 R4024.1 R4026.2 U4005.4
VCCSTU_EN_D: D4005.A R4013.1
VCCSTU_EN_R: R4013.2 R4024.2 U4006.2
VDD10: C3113.1 C3114.1 C3115.1 C3116.1 C3117.1 C3118.1 LOM31.3 LOM31.8 LOM31.22 LOM31.30 R3101.2
VDDREG: LOM31.23 R3105.2
VSS_AY71: CPU1.AY71 R602.1
VSS_SENSE: CPU1.E33 PR4645.1 R720.1
VSSGT_SENSE: CPU1.J69 PR4618.1 R722.1
VSSIO_VR_FB: CPU1.AM22 R730.1
VSSSA_SENSE: CPU1.H21 PR4604.1 R734.1
0D675V_S0: C1214.1 C1215.1 C1216.1 C1303.1 C1304.1 C1307.1 DM1.203 DM1.204 DM2.203 DM2.204 PG5101.1 PG5102.1
1D0V_PWR: PC5302.1 PC5303.1 PC5306.1 PC5307.1 PC5308.1 PG5211.2 PG5212.2 PG5213.2 PG5214.2 PG5301.2 PG5302.2 PG5303.2 PG5305.2 PG5306.2 PG5307.2 PL5301.2 PR5301.1 PU5203.1 PU5203.2 PU5203.9
1D0V_S5: C4013.1 C4016.1 PG5301.1 PG5302.1 PG5303.1 PG5305.1 PG5306.1 PG5307.1 R1117.1 R1724.1 R1735.1 R2402.1 U4002.9 U4006.9
1D0V_S5_PWRGD: PR5310.1 R4029.1
1D5V_PWR: PC5409.1 PG5404.1 PU5402.5
1D05V_PWR: PC8303.1 PC8304.1 PC8305.1 PG8304.2 PG8305.2 PG8306.2 PG8307.2 PL8301.2 PR8303.1
1D5V_S0: PG5404.2 R2705.1
1D05V_VGA_EN: C8303.2 PQ8301.2 PR8305.1 PR8308.2 R8302.2
1D05V_VGA_EN#: PQ8301.5 PQ8301.6 PR8307.2
1D05V_VGA_S0: C7310.1 C7312.1 C7323.1 C7326.1 GPU1.AA10 GPU1.AA12 GPU1.AA13 GPU1.AA16 GPU1.AA18 GPU1.AA19 GPU1.AA20 GPU1.AA21 GPU1.AA22 GPU1.AB22 GPU1.AB23 GPU1.AC23 GPU1.AC24 GPU1.AD24 GPU1.AD25 GPU1.AE25 GPU1.AE26 GPU1.AE27 GPU1.AF26 GPU1.AF27 L7301.2 L7501.2 L7601.1 L7602.1 PG8304.1 PG8305.1 PG8306.1 PG8307.1 PR8306.1
1D05V_VGA_S0_DISCHG: PQ8301.3 PR8306.2
1D05V_VGA_S0_PWRGD: D8301.2 PR8320.2 R8303.1
1D8A_EN#: Q4004.D R4039.2 R4040.1
1D8A_EN_R#: C4018.2 Q4003.G R4040.2
1D8V_EN#: Q4009.D R4046.2 R4047.1
1D8V_EN_R#: C4028.2 Q4008.G R4047.2
1D8V_PWR: PC5402.1 PC5404.1 PC5405.1 PG5405.1 PG5406.1 PG5407.1 PR5403.1 PU5401.3 PU5401.4
1D8V_S0: C4030.1 Q4008.D R2713.1 R2726.1
1D8V_S5: C4017.1 C4018.1 C4019.1 C4021.1 C4028.1 C4029.1 PG5405.2 PG5406.2 PG5407.2 Q4003.S Q4008.S R4037.1 R4039.1 R4046.1
1D8V_S5_PWROK: PR5408.1 R4030.1
1D35V_ENABLE: PQ8303.3 PR8310.1 PR8312.1 R8305.2
1D35V_ENABLE_RC: PC8308.1 PQ8304.4 R8305.1
1D35V_ENABLE_TP: PR8310.2 TP8301.1
1D35V_S3: C718.1 C719.1 C1207.1 C1208.1 C1209.1 C1210.1 C1211.1 C1212.1 C1213.1 C1220.1 C1221.1 C1222.1 C1312.1 C1313.1 C1314.1 C1315.1 C1316.1 C1317.1 C1318.1 C1321.1 C1322.1 C1323.1 CPU1.AL23 CPU1.AU23 CPU1.AU28 CPU1.AU35 CPU1.AU42 CPU1.BB23 CPU1.BB32 CPU1.BB41 CPU1.BB47 CPU1.BB51 DM1.75 DM1.76 DM1.81 DM1.82 DM1.87 DM1.88 DM1.93 DM1.94 DM1.99 DM1.100 DM1.105 DM1.106 DM1.111 DM1.112 DM1.117 DM1.118 DM1.123 DM1.124 DM2.75 DM2.76 DM2.81 DM2.82 DM2.87 DM2.88 DM2.93 DM2.94 DM2.99 DM2.100 DM2.105 DM2.106 DM2.111 DM2.112 DM2.117 DM2.118 DM2.123 DM2.124 EC1001.1 EC1002.1 EC1003.1 EC1004.1 EC1005.1 EC5101.1 EC5102.1 EC5103.1 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC5104.1 PC5120.1 PC5121.1 PC5123.1 PC5124.1 PC5125.1 PC5126.1 PC5127.1 PC5128.1 PC8309.1 PG5107.2 PL5101.2 PQ8304.5 PQ8304.6 PQ8304.7 PQ8304.8 PU5101.2 R505.1 R705.1 R4201.1 R4206.1 R4216.1 TC1201.1
1D35V_VGA_EN: D8301.3 PQ8303.2 R8303.2 R8304.1
1D35V_VGA_EN#: PQ8302.G PQ8303.5 PQ8303.6 PR8311.2 PR8314.2
1D35V_VGA_S0: C7501.1 C7502.1 C7507.1 C7513.1 C7514.1 C7517.1 C7520.1 C7525.1 C7804.1 C7805.1 C7810.1 C7811.1 C7812.1 C7813.1 C7814.1 C7815.1 C7816.1 C7817.1 C7820.1 C7821.1 C7822.1 C7827.1 C7829.1 C7830.1 C7831.1 C7832.1 C7833.1 C7834.1 C7835.1 C7836.1 C7906.1 C7909.1 C7910.1 C7911.1 C7912.1 C7913.1 C7915.1 C7916.1 C7917.1 C7919.1 C7921.1 C7922.1 C7923.1 C7924.1 C7925.1 C7926.1 C7927.1 C7928.1 C7929.1 C7930.1 EC9725.1 GPU1.B26 GPU1.C25 GPU1.E23 GPU1.E26 GPU1.F14 GPU1.F21 GPU1.G13 GPU1.G14 GPU1.G15 GPU1.G16 GPU1.G18 GPU1.G19 GPU1.G20 GPU1.G21 GPU1.H24 GPU1.H26 GPU1.J21 GPU1.K21 GPU1.L22 GPU1.L24 GPU1.L26 GPU1.M21 GPU1.N21 GPU1.R21 GPU1.T21 GPU1.V21 GPU1.W21 PC8310.1 PQ8304.1 PQ8304.2 PQ8304.3 PR8313.1 R7501.2 R7503.2 R7505.2 R7806.1 R7903.1 VRAM1.A1 VRAM1.A8 VRAM1.B2 VRAM1.C1 VRAM1.C9 VRAM1.D2 VRAM1.D9 VRAM1.E9 VRAM1.F1 VRAM1.G7 VRAM1.H2 VRAM1.H9 VRAM1.K2 VRAM1.K8 VRAM1.N1 VRAM1.N9 VRAM1.R1 VRAM1.R9 VRAM2.A1 VRAM2.A8 VRAM2.B2 VRAM2.C1 VRAM2.C9 VRAM2.D2 VRAM2.D9 VRAM2.E9 VRAM2.F1 VRAM2.G7 VRAM2.H2 VRAM2.H9 VRAM2.K2 VRAM2.K8 VRAM2.N1 VRAM2.N9 VRAM2.R1 VRAM2.R9 VRAM3.A1 VRAM3.A8 VRAM3.B2 VRAM3.C1 VRAM3.C9 VRAM3.D2 VRAM3.D9 VRAM3.E9 VRAM3.F1 VRAM3.G7 VRAM3.H2 VRAM3.H9 VRAM3.K2 VRAM3.K8 VRAM3.N1 VRAM3.N9 VRAM3.R1 VRAM3.R9 VRAM4.A1 VRAM4.A8 VRAM4.B2 VRAM4.C1 VRAM4.C9 VRAM4.D2 VRAM4.D9 VRAM4.E9 VRAM4.F1 VRAM4.G7 VRAM4.H2 VRAM4.H9 VRAM4.K2 VRAM4.K8 VRAM4.N1 VRAM4.N9 VRAM4.R1 VRAM4.R9
1D35V_VTT_PWRGD: PR5104.2 PU5101.20 R4011.1
3D3V_AUX_KBC_33: C2423.1 KBC24.54 R2462.1
3D3V_AUX_KBC_R: DB3.1 R2476.1
3D3V_AUX_S5: D2501.1 PR4420.1 PR4421.1 PR4501.1 PR4532.2 PR8307.1 PR8311.1 PR8315.2 PR8317.2 PR8319.2 R1726.2 R1727.1 R1737.1 R2467.1 R2472.2 R2609.1 R4004.1 R6003.1 R6102.1
3D3V_CAMERA_S0: C5539.1 EC5503.1 LCD1.32 R5532.2
3D3V_LAN_S5: C3103.1 C3104.1 C3105.1 C3106.1 C3112.1 LOM31.11 LOM31.32 Q3104.D R3102.1 R3103.1 R3105.1 RN3101.1(A) RN3101.2(A)
3D3V_PWR_2: PC4526.1 PR4532.1 PU4503.3
3D3V_RUN_FFS: C6701.1 C6702.1 C6703.1 R6701.2 U6701.2 U6701.3 U6701.9 U6701.10
3D3V_S0: C1203.1 C1311.1 C2601.1 C2602.1 C4004.1 C5505.1 C8305.1 C8307.1 DB1.1 DM1.199 DM2.199 EC9735.1 EC9736.1 EC9737.1 EC9738.1 IOBD1.16 PR4614.1 PR5104.1 Q1801.2 Q1801.5 Q2601.2 Q2601.5 Q5401.C Q5402.2 Q5402.5 Q6408.2 R802.2 R803.1 R804.1 R1302.1 R1503.1 R1606.1 R1607.2 R1608.1 R1609.1 R1817.1 R1818.2 R1829.1 R1830.1 R1831.1 R1832.1 R1833.1 R2002.1 R2005.1 R2006.1 R2009.2 R2015.1 R2017.1 R2021.1 R2023.1 R2025.1 R2032.1 R2033.1 R2043.1 R2044.1 R2046.2 R2047.1 R2048.2 R2049.2 R2050.1 R2051.1 R2429.2 R2430.2 R2603.1 R2604.1 R2710.1 R2725.1 R2729.1 R2731.1 R3106.1 R4005.1 R4020.1 R5521.1 R5522.1 R5529.2 R5532.1 R6517.1 R6520.2 R6701.1 R6702.1 R6703.1 R6704.1 R7648.2 R9108.2 R9114.2 R9119.2 R9120.2 RN801.1(A) RN801.2(A) RN1810.1(A) RN1810.2(A) RN2007.3(B) RN2007.4(B) RN2008.3(B) RN2008.4(B) RN2602.1(A) RN2602.2(A) THM26.1 U4001.8 U4001.9 U5501.4 U5501.5 U8301.1 U8301.2 U8301.6 U8301.7 VGABD1.2
3D3V_S5: AFTP6103.1 C1702.1 C1703.1 C2415.1 C2416.1 C2421.1 C3108.1 C3110.1 C4014.1 C4102.1 C6401.1 PC4517.1 PC5309.1 PC5403.1 PC5408.1 PD4302.2 PG4535.1 PG8301.2 PG8302.2 PG8303.2 PL4502.1 PR4304.1 PR4311.2 PR4450.2 PR4534.1 PR5303.2 PR5304.1 PR5402.1 PT4502.1 PU5401.5 PU5401.9 PU5402.1 PWR1.1 Q2412.G Q2413.G Q2414.G Q2416.G Q3104.S Q6408.5 R1709.1 R1711.1 R1714.1 R2409.2 R2433.2 R2434.1 R2438.2 R2442.1 R2443.1 R2446.1 R2484.2 R2488.2 R2489.2 R2498.2 R2712.2 R3109.1 R3113.2 R4026.1 R4031.1 R4101.1 R6105.1 R6118.1 R6402.1 R6521.2 R9101.2 R9109.2 R9110.2 U1701.5 U1702.5 U4001.6 U4001.7 U4003.5 U4005.5 U4101.2 U4101.3 U6101.1 U6101.2 U6101.5 U6101.6
3D3V_S5_KBC: C2410.1 C2411.1 C2412.1 C2413.1 C2414.1 C2417.1 C2420.1 C2422.1 C2429.1 D4304.2 D4305.2 D4306.2 KBC24.5 KBC24.19 KBC24.22 KBC24.43 KBC24.65 KBC24.82 KBC24.103 KBC24.115 PR4411.1 PR4412.1 PR8314.1 R2414.2 R2415.2 R2420.2 R2424.2 R2446.2 R2450.2 R2462.2 R2476.2 R2478.2 R2496.2 R2607.1 R2608.1 R4032.1 RN2402.1(A) RN2402.2(A) RN2403.1(A) RN2403.2(A) RN2403.3(A) RN2403.4(A) RN2404.1(A) RN2404.2(A) RN2404.3(A) RN2404.4(A) RN2409.1(A) RN2409.2(A) RN2409.3(A) RN2409.4(A) RN2410.1(A) RN2410.2(A) RN2410.3(A) RN2410.4(A) RN2411.1(A) RN2411.2(A) RN2411.3(A) RN2411.4(A) RN2412.1(A) RN2412.2(A) RN2412.3(A) RN2412.4(A) RN2603.1(A) RN2603.2(A) U2401.5
3D3V_S5_PCH: C2501.1 C2502.1 C2504.1 C2505.1 C4101.1 Q2604.2 Q2604.5 R1110.1 R1731.1 R1814.1 R1820.1 R1821.2 R1822.1 R1824.1 R1834.1 R1835.1 R2007.1 R2039.1 R2040.1 R2041.1 R2501.2 R2515.2 R4101.2 RN1602.1(A) RN1602.2(A) RN1602.3(A) RN1602.4(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1811.1(A) RN1811.2(A) RN2501.3(B) RN2501.4(B) RN2502.3(B) RN2502.4(B) SKT25.8 SKT26.8 SPI25.8 SPI252.8 U4101.6 U4101.7 U4101.8
3D3V_S5_WLAN: AFTP5801.1 C6107.1 C6108.1 C6109.1 C6110.1 C6111.1 C6112.1 R6118.2 U6101.4 WLAN1.2 WLAN1.4 WLAN1.72 WLAN1.74
3D3V_TP_S5_R: C6503.2 Q6504.S R6520.1 R6521.1
3D3V_TPM: C9101.1 C9102.1 C9103.1 Q9101.S R9101.1 R9103.2 R9104.2 R9108.1 R9111.2 R9112.2 R9117.1
3D3V_TPM_1: C9105.1 C9106.1 R9109.1 R9113.2
3D3V_VGA_CT_1: C8302.1 U8301.12
3D3V_VGA_S0: C7703.1 C7728.1 C7729.1 C7734.1 C8304.1 GPU1.G8 GPU1.G9 PR8256.1 PR8308.1 PR8318.1 R7608.1 R7611.1 R7616.1 R7626.2 R7638.1 R7639.1 R7640.1 R8301.2 U8301.13 U8301.14
3D3V_VGA_S0_DISCHG: PQ8307.3 PR8318.2
27MHZ_IN: C7607.2 GPU1.C11 R7603.1 X7601.1
27MHZ_OUT: GPU1.B10 R7603.2 R7604.2
27MHZ_OUT_R: C7608.2 R7604.1 X7601.3
81208_AGND: PC4604.1 PC4609.2 PC4613.2 PC4615.1 PC4619.2 PC4626.2 PC4628.2 PC4629.2 PC4630.2 PC4631.2 PC4632.2 PC4633.2 PG4601.1 PR4602.1 PR4611.2 PR4613.2 PR4628.2 PR4632.1 PR4635.2 PR4636.2 PR4658.2 PR4659.2 PR4660.2 PR4662.2 PR4663.2 PR4664.2 PU4601.49
+0D675V_DDR_P: PC5115.1 PC5116.1 PC5117.1 PG5101.2 PG5102.2 PU5101.1 PU5101.3
+DC_IN: AFTP3801.1 AFTP3805.1 AFTP3807.1 DCIN1.1 DCIN1.2 EC4301.1 EC4302.1 EC4303.1 EC4304.1 PC4301.1 PC4302.1 PD4301.K PQ4305.E PR4307.1 PR4312.1 PR4314.1 PU4301.1 PU4301.2 PU4301.3
+PWR_SRC_1D35V: PC5109.1 PC5111.1 PC5112.1 PC5113.2 PC5114.1 PG5103.1 PG5104.1 PG5105.1 PG5106.1 PG5124.1 PU5102.5 PU5102.6 PU5102.7 PU5102.8
+RTC_VCC: AFTP2502.1 R2502.2 RTC1.1
+SDC_IN: PG4402.1 PR4402.1 PR4403.1 PR4410.1 PU4402.1 PU4402.2 PU4402.3
+UZ12_TPM: C9104.1 R9110.1 R9114.1 U9101.8
+V_VREF_PATH1: C4202.2 R4211.1
+V_VREF_PATH2: C4203.2 R4215.1
+V_VREF_PATH3: C4201.2 R4207.1
AC_DIS: KBC24.69 PQ4306.5 PQ4403.G PR4310.1
AC_DIS_M: PQ4403.D PR4422.2 PU4403.4
AC_IN#_G: PQ4306.2 PR4312.2 PR4313.1
AC_IN_KBC#: PQ4306.6 R2493.2 R2494.2
AC_IN_KBC#_R: R2493.1 U2401.1
AC_PRESENT: CPU1.AY15 D1703.A D7601.K EC1707.1 Q1702.3 R1709.2
ACAV_IN: KBC24.128 R2469.2
ACOK_IN: PQ4402.2 PR4416.1
AD+: PC4303.1 PC4304.1 PC4305.1 PC4306.1 PD4402.A PR4405.1 PR4408.1 PR4422.1 PR4430.1 PR4431.1 PU4301.5 PU4301.6 PU4301.7 PU4301.8 PU4402.5 PU4402.6 PU4402.7 PU4402.8
AD+_G_1: PQ4402.5 PQ4402.6 PR4406.1
AD+_G_2: PR4403.2 PR4406.2 PU4402.4
AD_IA: PC4423.1 PG4401.2 R2421.1
AD_OFF_L: PQ4304.C PQ4305.B
AD_OFF_R: PC4301.2 PQ4305.C PR4307.2 PR4308.1 PR4319.1
ALL_SYS_PWRGD: D1701.A D4002.1 EC1709.1 R1716.1 R2481.2 R4002.1 R4005.2 R4011.2 U1701.2 U1702.4 U2401.6
ALWON: KBC24.121 R4009.2
AMBER_LED_BAT: EC6402.1 Q6403.C R6407.1
AUD_AGND: C2702.1 C2705.1 C2710.2 C2711.2 C2712.1 C2713.2 C2715.2 C2721.2 EC2703.1 EC2704.1 EC2705.1 EC2706.1 EC2707.1 EC2905.2 EC2906.2 EC2907.2 EC2908.2 EC9739.1 EC9743.1 EC9744.1 EC9745.1 HDA27.25 HDA27.38 HPMIC1.MS R307.2 R2706.1 R2707.2 R2711.1 R2727.1 R2730.1 R2919.2 R2920.2
AUD_HP1_JACK_L: HDA27.32 R2908.1
AUD_HP1_JACK_L1: EC2907.1 R2907.2 R2908.2 R2912.2 R2919.1 R2922.2
AUD_HP1_JACK_R: HDA27.33 R2910.1
AUD_HP1_JACK_R1: EC2908.1 R2909.2 R2910.2 R2913.2 R2920.1 R2921.2
AUD_PC_BEEP: HDA27.12 R2715.1
AUD_PC_BEEP_3246: HDA27.16 R2723.1
AUD_PC_BEEP_C: C2720.1 D2701.3 R2717.1
AUD_PC_BEEP_R: C2720.2 R2715.2 R2723.2
AUD_PORTA_L_HPMIC1: ED303.1 HPMIC1.1 R2907.1
AUD_PORTA_R_HPMIC1: ED304.1 HPMIC1.2 R2909.1
AUD_SENSE: R2709.2 R2923.2
AUD_SENSE_A: HDA27.13 R2709.1 R2722.2
AUD_SPK_L+: EC2904.2 HDA27.42 L2904.2
AUD_SPK_L+_C: AFTP2902.1 L2904.1 SPK1.1
AUD_SPK_L-: EC2903.2 HDA27.43 L2903.2
AUD_SPK_L-_C: AFTP2901.1 L2903.1 SPK1.2
AUD_SPK_R+: EC2902.2 HDA27.45 L2902.2
AUD_SPK_R+_C: AFTP2904.1 L2902.1 SPK1.3
AUD_SPK_R-: EC2901.2 HDA27.44 L2901.2
AUD_SPK_R-_C: AFTP2903.1 L2901.1 SPK1.4
AUD_VREF: C2705.2 HDA27.28
AUX_EN_WOWL: R1721.2 R2401.2 R2499.2 R6104.1 R6105.2
AUX_EN_WOWL_R: CPU1.BB17 R1721.1
BAT1_LED#: KBC24.1 Q2412.S R2484.1
BAT2_LED#: KBC24.106 Q2413.S R2488.1
BAT_AMBER: AFTP6308.1 LEDBD1.1 R6407.2
BAT_WHITE: AFTP6307.1 LEDBD1.2 R6406.2
BATT_WHITE_LED#: Q2412.D Q6406.4
BATT_WHITE_LED#_M: Q6406.3 R6404.1
BATT_WHITE_LED_R#: Q6404.B R6404.2
BEEP: KBC24.45 RN2701.1(A)
BKLGT_PWM: KBC24.44 Q6501.G R6505.1
BKLT_CTRL: D5503.3 R5524.1 RN5502.8(B) RN5503.7(B)
BLON_OUT_C: LCD1.21 RN5502.7(B) RN5503.3(A)
BLUETOOTH_EN: CPU1.AB2 R2002.2 R6113.1
BLUETOOTH_EN_NGFF: AFTP5804.1 R6113.2 WLAN1.54
BOARD_ID: KBC24.111 R2494.1 R2495.1 R2499.1
BOARD_ID2: CPU1.AB3 R2005.2 R2008.1
BOARD_ID3: CPU1.BA7 R2025.2 R2026.1
BOARD_ID_C: C2408.2 R2443.2 R2444.1 R2495.2
BOOST_MON: PC4424.1 PG4414.2 R2423.1
BT+: AFTP3905.1 AFTP3907.1 AFTP3908.1 BATT1.1 BATT1.2 EC4307.1 EC4308.1 EC4311.1 EC4312.1 EC4313.1 EC4314.1 PC4415.1 PC4416.1 PC4417.1 PC4418.1 PC4419.1 PD4304.K PD4405.A PG4413.2 PG4417.2 PR4415.2
BT+_1: PG4417.1 PR4414.2
BUFRST#: GPU1.D11 R7628.2
CAP_LED: AFTP6243.1 KB1.4 R6506.2
CAP_LED#: KBC24.93 Q2414.S R2489.1
CAP_LED#_S: EC6507.1 Q2414.D R6508.1
CAP_LED_Q: Q6502.C R6506.1
CAP_LED_R#: Q6502.B R6508.2
CBN: C2703.1 HDA27.35
CBP: C2703.2 HDA27.37
CFG0: CPU1.E68 TP9933.1
CFG1: CPU1.B67 TP9925.1
CFG2: CPU1.D65 TP9929.1
CFG3: CPU1.D67 R604.1 TP9926.1
CFG4: CPU1.E70 R605.1 TP9928.1
CFG5: CPU1.C68 TP9924.1
CFG6: CPU1.D68 TP9932.1
CFG7: CPU1.C67 TP9930.1
CFG8: CPU1.F71 TP9943.1
CFG9: CPU1.G69 TP9935.1
CFG10: CPU1.F70 TP9939.1
CFG11: CPU1.G68 TP9936.1
CFG12: CPU1.H70 TP9942.1
CFG13: CPU1.G71 TP9940.1
CFG14: CPU1.H69 TP9941.1
CFG15: CPU1.G70 TP9937.1
CFG16: CPU1.E63 TP9927.1
CFG17: CPU1.F63 TP9931.1
CFG18: CPU1.E66 TP9934.1
CFG19: CPU1.F66 TP9938.1
CFG_RCOMP: CPU1.E60 R601.1
CHARGER_SRC: PC4405.1 PC4406.1 PC4407.1 PC4408.1 PC4409.1 PC4410.1 PC4411.1 PG4404.1 PG4405.1 PG4406.1 PG4407.1 PU4404.5 PU4404.6 PU4404.7 PU4404.8
CHG_AGND: PC4403.1 PC4404.1 PC4412.1 PC4421.2 PC4422.2 PC4423.2 PC4424.2 PG4411.1 PR4423.2 PR4424.2 PR4425.2 PU4401.29
CHG_AMBER_LED#: Q2413.D Q6406.1
CHG_AMBER_LED#_M: Q6406.6 R6405.1
CHG_AMBER_LED_R#: Q6403.B R6405.2
CL_CLK: CPU1.G3 R6109.1
CL_CLK_R: R6109.2 WLAN1.42
CL_DATA: CPU1.G2 R6119.1
CL_DATA_R: R6119.2 WLAN1.40
CL_RST#: CPU1.G1 EC1805.1 R6108.1
CL_RST#_R: R6108.2 WLAN1.38
CLK_LAN_REQ4#_R: LOM31.12 Q3102.E R3103.2 R3104.2
CLK_LAN_REQ#_EN: Q3102.B R3102.2
CLK_PCI_LPC: DB1.9 EC1802.1 R1804.2
CLK_PCI_LPC_MEC: EC1801.1 KBC24.57 R1805.2
CLK_PCIE_VGA: CPU1.C42 GPU1.AE8
CLK_PCIE_VGA#: CPU1.D42 GPU1.AD8
CLK_TP_SIO: EC6503.1 KBC24.78 RN6503.1(A) RN6504.4(B)
CLKREQ_PCIE#1: CPU1.AT7 R1829.2 R6112.2
CLKREQ_PCIE#2: CPU1.AT8 Q3102.C R1830.2 R3104.1
CLKREQ_PCIE#3: CPU1.AT10 R1831.2
CLKREQ_PCIE#4: CPU1.AU8 R1832.2
CLKREQ_PCIE#5: CPU1.AU7 R1833.2
CLKREQ_PEG#0: CPU1.AR10 Q7301.D R1817.2 R7305.1
CLKRUN#: KBC24.63 R1819.2 R2510.1
CLKRUN#_R: CPU1.AW11 R1818.1 R1819.1
CMP_STRAP0: KBC24.118 R2420.1
CMP_VIN0: KBC24.20 R2470.2
CMP_VIN0_R: C2612.1 C2613.1 R2470.1 R2608.2 R2609.2 R2610.1
CMP_VOUT0: KBC24.85 R2602.2 R2607.2 R2612.2
CMP_VOUT1: KBC24.83 Q2408.G R2417.1 R2418.1
CODEC_BITCLK_R: HDA27.6 R2720.2
CODEC_SDOUT_R: HDA27.5 R2719.2
COMBO-GPI: HDA27.48 TP2702.1
CPU_A16_TP: CPU1.BB9 TP1902.1
CPU_D1_TP: CPU1.M2 TP1801.1
CPU_D4_TP: CPU1.V1 TP1804.1
CPU_D5_TP: CPU1.V2 TP1805.1
CPU_D6_TP: CPU1.M1 TP1806.1
CPU_DP1_CTRL_CLK: CPU1.L13 Q5402.4 RN801.4(B)
CPU_DP1_CTRL_DATA: CPU1.L12 Q5402.1 RN801.3(B)
CPU_DP1_HPD: CPU1.L9 R5419.1
CPU_DP2_CTRL_CLK: CPU1.N7 R803.2
CPU_DP2_CTRL_DATA: CPU1.N8 R804.2
CPU_DP2_HPD: R805.2 R806.1 R807.2 VGABD1.16
CPU_DP2_HPD1: CPU1.L7 R805.1
CPU_DP2_HPD3: CPU1.N9 R807.1
CPU_POPIRCOMP: CPU1.AT16 R412.1
CPU_RXN_C_DGPU_TXN0: C7302.1 CPU1.H13
CPU_RXN_C_DGPU_TXN1: C7304.1 CPU1.G11
CPU_RXN_C_DGPU_TXN2: C7306.1 CPU1.H16
CPU_RXN_C_DGPU_TXN3: C7308.1 CPU1.G15
CPU_RXP_C_DGPU_TXP0: C7301.1 CPU1.G13
CPU_RXP_C_DGPU_TXP1: C7303.1 CPU1.F11
CPU_RXP_C_DGPU_TXP2: C7305.1 CPU1.G16
CPU_RXP_C_DGPU_TXP3: C7307.1 CPU1.F15
CPVDD: C2701.1 C2714.1 HDA27.36 R2725.2 R2726.2
CPVEE: C2704.2 HDA27.34
CSI2_COMP: CPU1.E13 R1501.1
DAT_TP_SIO: EC6501.1 KBC24.79 RN6503.2(A) RN6504.3(B)
DBC_EN_R: LCD1.8 R5518.1
DBC_PANEL_EN: CPU1.AM5 R2043.2 R5518.2
DC_IN_D: PQ4402.3 PR4405.2
DCBATOUT: EC9701.1 EC9702.1 EC9703.1 EC9704.1 EC9705.1 EC9706.1 EC9707.1 EC9708.1 EC9709.1 EC9710.1 EC9711.1 EC9712.1 EC9713.1 EC9714.1 EC9715.1 EC9716.1 EC9717.1 EC9723.1 EC9724.1 EC9726.1 EC9727.1 EC9728.1 F5503.1 PC4519.1 PC4531.1 PC4701.1 PC4702.1 PC4703.1 PC4704.1 PC4705.1 PC4710.1 PC4802.1 PC4803.1 PC4804.1 PC4805.1 PC4806.1 PC4811.1 PC8208.1 PC8209.1 PC8210.1 PC8212.1 PC8213.1 PC8214.1 PC8215.1 PC8220.2 PC8221.2 PC8224.1 PG4403.1 PG4404.2 PG4405.2 PG4406.2 PG4407.2 PG4518.2 PG4520.2 PG4521.2 PG4524.2 PG4525.2 PG4531.2 PG4534.2 PG4536.2 PG4542.2 PG4543.2 PG5023.2 PG5024.2 PG5103.2 PG5104.2 PG5105.2 PG5106.2 PG5124.2 PG5304.2 PG5308.2 PG5309.2 PG5310.2 PR4402.2 PR4458.1 PR4601.1 PR8202.1 PR8312.2 PT4702.1 PT4703.1 PU4403.1 PU4403.2 PU4403.3 PU4503.12 PU4701.25 PU4701.26 PU4701.27 PU4701.28 PU4701.29 PU4701.30 PU4801.25 PU4801.26 PU4801.27 PU4801.28 PU4801.29 PU4801.30 PU8202.2 PU8202.3 PU8202.4 PU8202.10 PU8204.2 PU8204.3 PU8204.4 PU8204.10 PU8206.2 PU8206.3 PU8206.4 PU8206.10 PU8208.2 PU8208.3 PU8208.4 PU8208.10 R5501.2 R6002.1 R6103.1
DCBATOUT_+VCCSA: PC5002.1 PC5027.1 PC5029.1 PG5023.1 PG5024.1 PU5002.5 PU5002.6 PU5002.7 PU5002.8
DCBATOUT_CAMERA: C5516.1 C5542.2 EC5505.1 IRCCD1.1 IRCCD1.2 R5501.1
DCBATOUT_LCD: C5515.1 C5535.2 F5503.2 LCD1.1 LCD1.2
DDC_CLK_HDMI: EU5703.4 EU5703.7 HDMI1.15 Q5402.3 RN5401.1(A)
DDC_CLK_PH1: D5401.2 RN5401.4(B)
DDC_DATA_HDMI: EU5703.1 EU5703.10 HDMI1.16 Q5402.6 RN5401.2(A)
DDC_DATA_PH2: D5401.1 RN5401.3(B)
DDPD_CTRLDATA: CPU1.N12 TP802.1
DDR0_PAR: CPU1.AT52 TP501.1
DDR1_PAR: CPU1.AP43 TP502.1
DDR3_DRAMRST#: C1217.1 C1301.1 D1217.2 D1319.2 DM1.30 DM2.30 R504.2
DDR_VREF_S3: PR5111.2 R4204.1 R4210.1 R4212.1
DDR_VTT_PG_CTRL_R: PR5109.1 PR5110.1 PU5101.17
DGPU_HOLD_RST#: CPU1.P3 EC2002.1 R7304.1 RN2009.4(B) U7301.1
DGPU_PWR_EN: CPU1.U1 PQ8306.2 PR8260.1 R8306.1 RN2009.3(B) U8301.5
DGPU_PWR_EN#: PQ8306.5 PQ8306.6 PR8317.1
DGPU_PWROK: CPU1.C8 EC1903.1 EC2401.1 PR8203.2 PU8201.13 R1904.2 R2427.2 R8302.1
DGPU_PWROK_KBC: KBC24.47 R2427.1
DGPU_RXN_C_CPU_TXN0: C1606.1 GPU1.AG7
DGPU_RXN_C_CPU_TXN1: C1608.1 GPU1.AE7
DGPU_RXN_C_CPU_TXN2: C1610.1 GPU1.AF9
DGPU_RXN_C_CPU_TXN3: C1612.1 GPU1.AG10
DGPU_RXP_C_CPU_TXP0: C1605.1 GPU1.AG6
DGPU_RXP_C_CPU_TXP1: C1607.1 GPU1.AF7
DGPU_RXP_C_CPU_TXP2: C1609.1 GPU1.AE9
DGPU_RXP_C_CPU_TXP3: C1611.1 GPU1.AG9
DGPU_TXN_CPU_RXN0: C7302.2 GPU1.AB9
DGPU_TXN_CPU_RXN1: C7304.2 GPU1.AC10
DGPU_TXN_CPU_RXN2: C7306.2 GPU1.AC11
DGPU_TXN_CPU_RXN3: C7308.2 GPU1.AB12
DGPU_TXP_CPU_RXP0: C7301.2 GPU1.AC9
DGPU_TXP_CPU_RXP1: C7303.2 GPU1.AB10
DGPU_TXP_CPU_RXP2: C7305.2 GPU1.AD11
DGPU_TXP_CPU_RXP3: C7307.2 GPU1.AC12
DIS_1D35V_VGA_S0: PQ8302.D PR8313.2
DMIC_CLK: C2723.2 EC5501.1 R2716.1 RN5504.4(B)
DMIC_CLK_EDP: LCD1.27 RN5504.1(A) RN5505.1(A)
DMIC_CLK_R: HDA27.3 R2716.2
DMIC_DATA: EC5502.1 R2714.1 RN5504.3(B)
DMIC_DATA_EDP: LCD1.28 RN5504.2(A) RN5505.2(A)
DMIC_DATA_R: EC2701.1 HDA27.2 R2714.2
DMIC_PCH_CLK: R1910.1 RN5505.4(B)
DMIC_PCH_CLK_R: CPU1.H5 R1910.2
DMIC_PCH_DATA: R1913.1 RN5505.3(B)
DMIC_PCH_DATA_R: CPU1.D7 R1913.2
DS3_PWRCTL: R4102.2 U4101.4
E51_RX1: TP6102.1 WLAN1.46
E51_RX2: TP6103.1 WLAN1.58
E51_TX1: R6115.2 WLAN1.44
E51_TXD_R: DB3.5 R2466.1
EC_AGND: C2407.1 C2408.1 C2415.2 C2416.2 C2421.2 C2422.2 C2427.2 C2435.2 C2441.2 KBC24.112 R2441.2 R2444.2 R2445.2
EC_MUTE#: KBC24.119 R2708.1 R2724.2
EC_SPI_CLK: KBC24.32 R2485.2
EC_SPI_CS0#: KBC24.27 R2490.2
EC_SPI_MISO: KBC24.29 R2487.2
EC_SPI_MOSI: KBC24.28 R2486.2
EC_VTT: C2406.1 KBC24.95 R2402.2 R2440.2 R2492.2
EC_WAKE#: KBC24.35 R1736.1
ECVBAT: C2428.1 KBC24.122 R2451.2 R2452.2 R2472.1 R2473.1
EDP_AUX_CON_N: C5533.2 LCD1.12 R5529.1
EDP_AUX_CON_P: C5531.2 LCD1.11 R5528.1
EDP_AUX_CPU_N: C5533.1 CPU1.E45
EDP_AUX_CPU_P: C5531.1 CPU1.F45
EDP_BKLT_CTRL: D5503.1 R5524.2 R5530.2
EDP_COMP: CPU1.E52 R801.2
EDP_DISP_UTIL: CPU1.B52 TP801.1
EDP_HPD: CPU1.L10 R5519.2 RN5502.6(B)
EDP_HPD_CONN: LCD1.9 R5519.1
EDP_TX_CON_N0: C5508.2 LCD1.14
EDP_TX_CON_N1: C5534.2 LCD1.17
EDP_TX_CON_P0: C5532.2 LCD1.15
EDP_TX_CON_P1: C5537.2 LCD1.18
EDP_TX_CPU_N0: C5508.1 CPU1.C47
EDP_TX_CPU_N1: C5534.1 CPU1.D46
EDP_TX_CPU_P0: C5532.1 CPU1.C46
EDP_TX_CPU_P1: C5537.1 CPU1.C45
EDP_VDD_EN: CPU1.U13 D5502.1
EMMC_RCOMP: CPU1.AT1 R1502.1
EXT_PWR_GATE#: CPU1.AM10 R1731.2
FALL_INT2: Q6701.2 Q6701.3 R6703.2
FAN1_DAC_1: FAN261.4 KBC24.24
FAN1_TACH: D2403.A KBC24.40 R2430.1
FAN_TACH1: D2403.K EC2602.1 R2606.1
FAN_TACH1_C: AFTP2802.1 FAN1.2 R2606.2
FAN_VCC1: AFTP2801.1 C2603.1 C2604.1 D2601.K EC2601.1 FAN1.4 FAN261.3
FB_CAL_PD_VDDQ: GPU1.D22 R7505.1
FB_CAL_PU_GND: GPU1.C24 R7507.2
FB_CAL_TERM_GND: GPU1.B25 R7506.1
FB_CLAM: GPU1.F3 R7518.1 R7519.1
FB_VREF: GPU1.D23 TP7503.1
FBA_CLK0N: GPU1.D25 R7810.1 VRAM1.K7 VRAM3.K7
FBA_CLK0P: GPU1.D24 R7810.2 VRAM1.J7 VRAM3.J7
FBA_CLK1N: GPU1.M22 R7914.1 VRAM2.K7 VRAM4.K7
FBA_CLK1P: GPU1.N22 R7914.2 VRAM2.J7 VRAM4.J7
FBA_CMD0: GPU1.C27 R7512.1 VRAM1.L2 VRAM3.L2
FBA_CMD1: GPU1.C26 TP7501.1
FBA_CMD2: GPU1.E24 VRAM1.K1 VRAM3.K1
FBA_CMD3: GPU1.F24 R7510.1 VRAM1.K9 VRAM3.K9
FBA_CMD4: GPU1.D27 VRAM1.T7 VRAM2.T7 VRAM3.T7 VRAM4.T7
FBA_CMD5: GPU1.D26 VRAM1.T2 VRAM2.T2 VRAM3.T2 VRAM4.T2
FBA_CMD6: GPU1.F25 VRAM1.R3 VRAM2.R3 VRAM3.R3 VRAM4.R3
FBA_CMD7: GPU1.F26 VRAM1.R2 VRAM2.R2 VRAM3.R2 VRAM4.R2
FBA_CMD8: GPU1.F23 VRAM1.P3 VRAM2.P3 VRAM3.P3 VRAM4.P3
FBA_CMD9: GPU1.G22 VRAM1.N3 VRAM2.N3 VRAM3.N3 VRAM4.N3
FBA_CMD10: GPU1.G23 VRAM1.P8 VRAM2.P8 VRAM3.P8 VRAM4.P8
FBA_CMD11: GPU1.G24 VRAM1.P7 VRAM2.P7 VRAM3.P7 VRAM4.P7
FBA_CMD12: GPU1.F27 VRAM1.M2 VRAM2.M2 VRAM3.M2 VRAM4.M2
FBA_CMD13: GPU1.G25 VRAM1.L3 VRAM2.L3 VRAM3.L3 VRAM4.L3
FBA_CMD14: GPU1.G27 TP7502.1
FBA_CMD15: GPU1.G26 VRAM1.K3 VRAM2.K3 VRAM3.K3 VRAM4.K3
FBA_CMD16: GPU1.M24 R7511.1 VRAM2.L2 VRAM4.L2
FBA_CMD17: GPU1.M23 TP7505.1
FBA_CMD18: GPU1.K24 VRAM2.K1 VRAM4.K1
FBA_CMD19: GPU1.K23 R7509.1 VRAM2.K9 VRAM4.K9
FBA_CMD20: GPU1.M27 R7508.1 VRAM1.T3 VRAM2.T3 VRAM3.T3 VRAM4.T3
FBA_CMD21: GPU1.M26 VRAM1.T8 VRAM2.T8 VRAM3.T8 VRAM4.T8
FBA_CMD22: GPU1.M25 VRAM1.R8 VRAM2.R8 VRAM3.R8 VRAM4.R8
FBA_CMD23: GPU1.K26 VRAM1.R7 VRAM2.R7 VRAM3.R7 VRAM4.R7
FBA_CMD24: GPU1.K22 VRAM1.P2 VRAM2.P2 VRAM3.P2 VRAM4.P2
FBA_CMD25: GPU1.J23 VRAM1.N2 VRAM2.N2 VRAM3.N2 VRAM4.N2
FBA_CMD26: GPU1.J25 VRAM1.M3 VRAM2.M3 VRAM3.M3 VRAM4.M3
FBA_CMD27: GPU1.J24 VRAM1.N8 VRAM2.N8 VRAM3.N8 VRAM4.N8
FBA_CMD28: GPU1.K27 VRAM1.N7 VRAM2.N7 VRAM3.N7 VRAM4.N7
FBA_CMD29: GPU1.K25 VRAM1.L7 VRAM2.L7 VRAM3.L7 VRAM4.L7
FBA_CMD30: GPU1.J27 VRAM1.J3 VRAM2.J3 VRAM3.J3 VRAM4.J3
FBA_CMD31: GPU1.J26 TP7504.1
FBA_D0: GPU1.E18 VRAM3.E3
FBA_D1: GPU1.F18 VRAM3.H3
FBA_D2: GPU1.E16 VRAM3.F2
FBA_D3: GPU1.F17 VRAM3.G2
FBA_D4: GPU1.D20 VRAM3.F7
FBA_D5: GPU1.D21 VRAM3.H8
FBA_D6: GPU1.F20 VRAM3.H7
FBA_D7: GPU1.E21 VRAM3.F8
FBA_D8: GPU1.E15 VRAM3.C8
FBA_D9: GPU1.D15 VRAM3.B8
FBA_D10: GPU1.F15 VRAM3.D7
FBA_D11: GPU1.F13 VRAM3.A7
FBA_D12: GPU1.C13 VRAM3.C2
FBA_D13: GPU1.B13 VRAM3.C3
FBA_D14: GPU1.E13 VRAM3.A3
FBA_D15: GPU1.D13 VRAM3.A2
FBA_D16: GPU1.B15 VRAM1.F8
FBA_D17: GPU1.C16 VRAM1.F7
FBA_D18: GPU1.A13 VRAM1.H7
FBA_D19: GPU1.A15 VRAM1.H8
FBA_D20: GPU1.B18 VRAM1.F2
FBA_D21: GPU1.A18 VRAM1.E3
FBA_D22: GPU1.A19 VRAM1.H3
FBA_D23: GPU1.C19 VRAM1.G2
FBA_D24: GPU1.B24 VRAM1.A2
FBA_D25: GPU1.C23 VRAM1.C3
FBA_D26: GPU1.A25 VRAM1.C2
FBA_D27: GPU1.A24 VRAM1.A3
FBA_D28: GPU1.A21 VRAM1.B8
FBA_D29: GPU1.B21 VRAM1.A7
FBA_D30: GPU1.C20 VRAM1.D7
FBA_D31: GPU1.C21 VRAM1.C8
FBA_D32: GPU1.R22 VRAM2.E3
FBA_D33: GPU1.R24 VRAM2.G2
FBA_D34: GPU1.T22 VRAM2.H3
FBA_D35: GPU1.R23 VRAM2.F2
FBA_D36: GPU1.N25 VRAM2.F8
FBA_D37: GPU1.N26 VRAM2.H7
FBA_D38: GPU1.N23 VRAM2.H8
FBA_D39: GPU1.N24 VRAM2.F7
FBA_D40: GPU1.V23 VRAM4.H3
FBA_D41: GPU1.V22 VRAM4.E3
FBA_D42: GPU1.T23 VRAM4.G2
FBA_D43: GPU1.U22 VRAM4.F2
FBA_D44: GPU1.Y24 VRAM4.H7
FBA_D45: GPU1.AA24 VRAM4.F7
FBA_D46: GPU1.Y22 VRAM4.H8
FBA_D47: GPU1.AA23 VRAM4.F8
FBA_D48: GPU1.AD27 VRAM4.B8
FBA_D49: GPU1.AB25 VRAM4.D7
FBA_D50: GPU1.AD26 VRAM4.A7
FBA_D51: GPU1.AC25 VRAM4.C8
FBA_D52: GPU1.AA27 VRAM4.A3
FBA_D53: GPU1.AA26 VRAM4.C3
FBA_D54: GPU1.W26 VRAM4.C2
FBA_D55: GPU1.Y25 VRAM4.A2
FBA_D56: GPU1.R26 VRAM2.C8
FBA_D57: GPU1.T25 VRAM2.A7
FBA_D58: GPU1.N27 VRAM2.D7
FBA_D59: GPU1.R27 VRAM2.B8
FBA_D60: GPU1.V26 VRAM2.A3
FBA_D61: GPU1.V27 VRAM2.C3
FBA_D62: GPU1.W27 VRAM2.A2
FBA_D63: GPU1.W25 VRAM2.C2
FBA_DEBUG0: GPU1.F22 R7501.1
FBA_DEBUG1: GPU1.J22 R7503.1
FBA_DQM0: GPU1.D19 VRAM3.E7
FBA_DQM1: GPU1.D14 VRAM3.D3
FBA_DQM2: GPU1.C17 VRAM1.E7
FBA_DQM3: GPU1.C22 VRAM1.D3
FBA_DQM4: GPU1.P24 VRAM2.E7
FBA_DQM5: GPU1.W24 VRAM4.E7
FBA_DQM6: GPU1.AA25 VRAM4.D3
FBA_DQM7: GPU1.U25 VRAM2.D3
FBA_DQS_RN0: GPU1.F19 VRAM3.G3
FBA_DQS_RN1: GPU1.C14 VRAM3.B7
FBA_DQS_RN2: GPU1.A16 VRAM1.G3
FBA_DQS_RN3: GPU1.A22 VRAM1.B7
FBA_DQS_RN4: GPU1.P25 VRAM2.G3
FBA_DQS_RN5: GPU1.W22 VRAM4.G3
FBA_DQS_RN6: GPU1.AB27 VRAM4.B7
FBA_DQS_RN7: GPU1.T27 VRAM2.B7
FBA_EDC0: GPU1.E19 VRAM3.F3
FBA_EDC1: GPU1.C15 VRAM3.C7
FBA_EDC2: GPU1.B16 VRAM1.F3
FBA_EDC3: GPU1.B22 VRAM1.C7
FBA_EDC4: GPU1.R25 VRAM2.F3
FBA_EDC5: GPU1.W23 VRAM4.F3
FBA_EDC6: GPU1.AB26 VRAM4.C7
FBA_EDC7: GPU1.T26 VRAM2.C7
FBA_PLL_AVDD: C7505.1 C7506.1 C7518.1 GPU1.F16 GPU1.H22 GPU1.P22 L7501.1
FBA_VREF_0: C7803.1 R7806.2 R7807.1 VRAM1.H1 VRAM1.M8 VRAM3.H1 VRAM3.M8
FBA_VREF_1: C7902.1 R7903.2 R7904.1 VRAM2.H1 VRAM2.M8 VRAM4.H1 VRAM4.M8
FBA_ZQ0: R7808.2 VRAM3.L8
FBA_ZQ1: R7809.2 VRAM1.L8
FBA_ZQ2: R7912.2 VRAM2.L8
FBA_ZQ3: R7913.2 VRAM4.L8
FFS_INT2: CPU1.AC2 Q6701.5 R6704.2 R6706.1 R6707.1 U6701.11
FFS_INT2_Q: HDD1.11 Q6701.6 R6705.2 R6706.2
FON#: FAN261.1 R2605.2
FP_PWR: AFTP8902.1 C9201.1 C9202.1 FPR1.6 R9201.2 R9202.1
GC6_FB_EN: D8301.1 R2004.1 R7519.2 R7623.1
GC6_FB_EN_GPU: GPU1.C6 R7623.2 R7627.1
GC6_FB_EN_MCP: CPU1.AP7 R2004.2
GPD2/LAN_WAKE#: CPU1.AM15 R1707.2 R1736.2
GPIO5_GC6_PWR_EN: PQ8307.2 R7636.2 R8306.2 U8301.3
GPIO5_GC6_PWR_EN#: PQ8307.5 PQ8307.6 PR8319.1
GPIO5_GC6_PWR_EN_GPU: GPU1.A3 R7633.2 R7636.1
GPIO9_ALERT: GPU1.F8 Q7602.1 R7612.1
GPIO10_FBVREF: GPU1.C5 R7610.1
GPP_B2/VRALERT#: CPU1.AM11 TP1708.1
GPP_B4/CPU_GP3: CPU1.AY5 TP404.1
GPP_B18/GSPI0_MOSI: CPU1.AR7 R2007.2 R2019.1
GPP_B23/SML1ALERT#: CPU1.AM7 R1820.2
GPP_C2/SMBALERT#: CPU1.R10 R1821.1
GPP_C5/SML0ALERT#: CPU1.W1 R1822.2 R1823.1
GPP_E0/SATAXPCIE0/SATAGP0: CPU1.H2 TP1601.1
GPP_E1/SATAXPCIE1/SATAGP1: CPU1.H3 TP1602.1
GPP_E2/SATAXPCIE2/SATAGP2: CPU1.G4 TP1603.1
GPP_E3/CPU_GP0: CPU1.A6 TP403.1
GPU_CLKREQ#: GPU1.AC6 Q7301.S R7303.1 R7305.2
GPU_EVENT#: Q7606.D R2003.1 R7644.1 R7648.1
GPU_EVENT_GPU#: GPU1.A4 Q7606.S R7644.2 R7649.1
GPU_EVENT_MCP#: CPU1.AN8 R2003.2
GPU_PEX_RST#: GPU1.AC7 Q7602.5 R7308.1 R7312.2 R7313.2 R7613.1
GPU_PEX_RST_D#: D7301.3 R7308.2
GPU_PEX_RST_HOLD: D7301.1 R7630.2 R7631.2
GPU_PEX_RST_HOLD_GPU#: GPU1.C4 R7630.1
GPU_PLL_VDD: C7605.1 C7606.1 GPU1.L6 L7601.2
H_CATERR#: CPU1.D63 TP401.1
H_CPU_SVIDALRT#: CPU1.B63 R728.2
H_CPU_SVIDCLK: CPU1.A63 R732.1
H_CPU_SVIDDAT: CPU1.D64 R709.1 R726.2
H_CPUPWRGD: CPU1.A68 EC1710.2 R405.1 R1710.2
H_PECI: CPU1.A54 R2437.2
H_PROCHOT#: C2403.1 PQ4303.3 PR4418.1 PR4455.2 PR4624.2 PR4668.2 PR4669.2 R404.1 R2416.2
H_PROCHOT#_EC: Q2408.D R2416.1 R2418.2
H_PROCHOT#_R: CPU1.C65 R403.2
H_PROCHOT#_R_R: R401.2 R403.1 R404.2
H_THERMTRIP#: Q4002.E R420.2
H_THERMTRIP_EN: C4003.1 Q4002.B R1710.1 R4003.1 R4007.2
H_VCCST_PWRGD: CPU1.B65 R1734.2
H_VCCST_PWRGD_R: EC1708.1 R1716.2 R1719.1 R1722.2 R1734.1 U1701.4
HDA_BITCLK: CPU1.AY22 R1907.2
HDA_CODEC_BITCLK: EC1901.2 EC2709.1 R1907.1 R2720.1
HDA_CODEC_RST#: EC1902.1 R1911.1 R2721.1
HDA_CODEC_RST#_R: HDA27.11 R2721.2
HDA_CODEC_SDIN0: HDA27.8 R2718.2
HDA_CODEC_SDOUT: EC2708.1 R1912.1 R2719.1
HDA_CODEC_SYNC: HDA27.10 R1908.1
HDA_RST#: CPU1.AW22 R1911.2
HDA_SDIN0: CPU1.BA21 R2718.1
