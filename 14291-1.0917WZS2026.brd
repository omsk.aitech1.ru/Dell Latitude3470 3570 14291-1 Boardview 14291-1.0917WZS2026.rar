# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ5: length 77.9
  TOP w0.14: v2(68.95,32.07) 68.8,32.07 v1(68.48,31.75)
  L3 w0.127: v2(88.75,78.52) 87.82,77.59 86.28,77.59 85.95,77.59 72.59,64.24 72.59,64.01 72.75,63.86 72.97,63.86 76.21,67.1 76.43,67.1 76.58,66.94 76.58,66.72 68.76,58.89 68.76,39.18 68.04,38.46 68.04,32.99 68.95,32.07 v2(68.95,32.07)
  BOTTOM w0.089: 93.77,79.42 94.51,79.42 94.94,78.99 95.13,78.99 95.28,79.06 95.52,79.06 95.66,79.01 95.8,79.01 96.01,79.07 96.18,79.07 CPU1.AL69
  BOTTOM w0.14: v2(68.95,32.07) 68.88,32.07 68.44,31.63 68.44,31.04 68.35,30.95 DM1.18 ; v2(88.75,78.52) 89.16,78.94 92.74,78.94 93.22,79.42 93.77,79.42
M_A_DQ6: length 76.5
  TOP w0.14: v2(64.34,34.16) 64,34.16 v1(63.63,33.79)
  L3 w0.127: v2(91.2,76.97) 92.44,78.21 92.44,78.7 90.92,80.22 84.23,80.22 66.29,62.28 66.29,46.55 66.08,46.35 65.18,46.35 64.8,45.97 64.8,37.8 64.51,37.51 64.51,34.33 v2(64.34,34.16)
  BOTTOM w0.14: DM1.6 64.75,31.56 65.02,31.83 65.02,33.68 64.54,34.16 v2(64.34,34.16) ; CPU1.AN70 95.45,77.67 94.79,77.67 94.74,77.71 93.55,77.71 93.22,77.38 91.62,77.38 v2(91.2,76.97)
M_A_DQ7: length 75.4
  TOP w0.14: v1(68.47,33.05) 68.76,33.34 v2(68.95,33.34)
  L3 w0.127: v2(68.95,33.34) 68.43,33.86 68.43,38.3 69.15,39.02 69.15,58.73 80.05,69.62 80.05,69.84 79.89,70 79.67,70 76.99,67.32 76.77,67.32 76.61,67.48 76.61,67.7 86.11,77.2 87.98,77.2 88.27,77.48 90.03,77.48 v2(90.55,76.97)
  BOTTOM w0.14: v2(68.95,33.34) 68.05,34.24 DM1.17 ; CPU1.AN71 93.26,77.95 92.92,77.62 91.2,77.62 v2(90.55,76.97)
M_A_DQ8: length 64.3
  TOP w0.14: v2(70.64,33.39) 70.87,33.39 v1(71.13,33.13)
  L3 w0.127: v2(90,75.57) 89.78,75.79 89.35,75.79 89.12,76.02 88.51,76.02 88.31,75.82 87.03,75.82 83.18,71.97 83.18,70.37 71.82,59.01 71.82,58.12 71.62,57.93 71.44,57.93 71.32,58.05 71.09,58.05 70.94,57.89 70.94,57.67 71.06,57.55 71.06,57.37 70.75,57.06 70.75,38.64 70.27,38.16 70.27,33.77 v2(70.64,33.39)
  BOTTOM w0.089: CPU1.AR70 95.74,76.88 95.56,76.7 95.31,76.7 95.1,76.65 94.39,76.65 94.21,76.47 93.28,76.47 93.11,76.29
  BOTTOM w0.14: 93.11,76.29 92.93,76.12 90.54,76.12 v2(90,75.57) ; v2(70.64,33.39) 70.39,33.39 69.55,32.55 DM1.22
M_A_DQ9: length 64.7
  TOP w0.14: v1(69.6,36.33) 69.28,36 v2(69.02,36)
  L3 w0.127: v2(96.79,77.43) 95.88,76.52 90.16,76.52 90.11,76.57 89.67,76.57 89.44,76.81 88.18,76.81 87.99,76.61 86.7,76.61 82.39,72.29 82.39,71.21 82.27,71.1 82.01,71.1 81.86,71.25 81.64,71.25 81.48,71.09 81.48,70.87 81.87,70.49 81.87,70.31 81.67,70.11 81.49,70.11 81.16,70.44 80.94,70.44 80.78,70.29 80.78,70.06 81.11,69.73 81.11,69.48 69.93,58.3 69.93,39.01 69.44,38.52 69.44,36.43 v2(69.02,36)
  BOTTOM w0.14: DM1.21 69.25,37.2 69.54,36.91 69.54,36.41 69.13,36 v2(69.02,36) ; v2(96.79,77.43) 97.04,77.19 CPU1.AR68
M_A_DQ10: length 62.5
  TOP w0.14: v1(73.39,35.4) 73.1,35.11 v2(72.9,35.11)
  L3 w0.127: v2(72.9,35.11) 72.46,35.55 72.46,56.05 77.28,60.88 77.28,61.06 76.98,61.36 76.98,61.54 77.16,61.72 77.34,61.72 77.64,61.42 77.82,61.42 78,61.6 78,61.78 77.7,62.08 77.7,62.26 83.7,68.27 89.24,68.27 90.7,69.73 90.7,72.62 90.39,72.93 89.9,72.93 89.24,73.6 89.24,74.05 v2(89.4,74.21)
  BOTTOM w0.089: CPU1.AU71 94.8,75.6 93.99,74.79 90.77,74.79
  BOTTOM w0.14: 90.77,74.79 89.97,74.79 v2(89.4,74.21) ; v2(72.9,35.11) 73.45,35.66 DM1.35
M_A_DQ11: length 64
  TOP w0.14: v2(73.58,31.43) v1(73.58,30.83)
  L3 w0.127: v2(92.63,73.97) 93.09,73.5 93.09,72.39 92.11,71.41 92.11,69.47 89.15,66.51 84.6,66.51 75.39,57.3 75.39,56 75.23,55.84 75.05,55.84 74.61,56.27 74.4,56.27 74.25,56.12 74.25,55.91 74.69,55.48 74.69,55.3 74.51,55.12 74.33,55.12 74.11,55.34 73.9,55.34 73.75,55.19 73.75,54.98 73.97,54.76 73.97,54.58 73.89,54.5 73.89,38.71 73.74,38.56 73.74,33.43 74.02,33.15 74.02,31.87 v2(73.58,31.43)
  BOTTOM w0.089: v2(92.63,73.97) 93.04,73.56 93.41,73.56 93.68,73.84 94.3,73.84 94.99,74.52 96.56,74.52 96.8,74.77 96.8,75.39 CPU1.AU68
  BOTTOM w0.14: v2(73.58,31.43) 73.75,31.26 DM1.36
M_A_DQ12: length 62.9
  TOP w0.14: v1(70.15,31.86) 70.41,32.12 v2(70.64,32.12)
  L3 w0.127: v2(70.64,32.12) 71.09,32.57 71.09,34.06 70.66,34.49 70.66,37.89 71.19,38.41 71.19,56.75 72.39,57.95 72.39,58.13 72.22,58.3 72.22,58.52 72.38,58.68 72.6,58.68 72.77,58.51 72.95,58.51 73.15,58.71 73.15,58.89 72.93,59.1 72.93,59.56 83.57,70.2 83.57,71.81 87.19,75.43 88.55,75.43 v2(88.7,75.57)
  BOTTOM w0.089: 92.9,76.58 93,76.68 94.17,76.68 94.42,76.92 CPU1.AR71
  BOTTOM w0.14: 92.9,76.58 92.78,76.46 89.59,76.46 v2(88.7,75.57) ; v2(70.64,32.12) 70.52,32.12 70.15,31.75 DM1.24
M_A_DQ13: length 63.9
  TOP w0.14: v2(69,34.69) 69.25,34.69 v1(69.57,35.01)
  L3 w0.127: v2(69,34.69) 69.84,35.53 69.84,38.33 70.35,38.84 70.35,58.15 82.79,70.58 82.79,72.13 86.87,76.21 88.15,76.21 88.35,76.41 89.28,76.41 89.51,76.18 89.95,76.18 90,76.13 92.39,76.13 v2(92.88,75.63)
  BOTTOM w0.089: 94.14,76.21 94.22,76.21 94.48,76.47 95.12,76.47 95.33,76.52 95.77,76.52 96.03,76.65 96.1,76.7 CPU1.AR69
  BOTTOM w0.14: 94.14,76.21 93.45,76.21 v2(92.88,75.63) ; DM1.23 69.85,37.18 69.99,37.04 69.99,35.6 69.08,34.69 v2(69,34.69)
M_A_DQ14: length 62.7
  TOP w0.14: v1(72.99,37.01) 72.9,36.91 v2(72.9,36.44)
  L3 w0.127: v2(72.9,36.44) 72.9,55.92 78.66,61.68 78.66,61.86 78.34,62.17 78.34,62.35 78.52,62.53 78.7,62.53 79.02,62.22 79.2,62.22 79.38,62.4 79.38,62.58 79.06,62.89 79.06,63.07 79.24,63.25 79.42,63.25 79.73,62.94 79.91,62.94 80.09,63.12 80.09,63.3 79.78,63.61 79.78,63.79 79.96,63.97 80.14,63.97 80.45,63.66 80.63,63.66 80.81,63.84 80.81,64.02 80.5,64.33 80.5,64.51 80.68,64.69 80.86,64.69 81.17,64.38 81.35,64.38 81.53,64.56 81.53,64.74 81.22,65.05 81.22,65.23 81.4,65.41 81.58,65.41 81.89,65.09 82.07,65.09 82.25,65.27 82.25,65.45 81.94,65.77 81.94,65.95 83.86,67.87 89.4,67.87 91.1,69.57 91.1,73.39 90.95,73.54 90.68,73.54 90.55,73.67 90.55,74.06 v2(90.7,74.21)
  BOTTOM w0.089: v2(90.7,74.21) 91.08,74.6 94.05,74.6 94.78,75.33 95.47,75.33 CPU1.AU70
  BOTTOM w0.14: v2(72.9,36.44) 72.85,36.49 DM1.33
M_A_DQ15: length 63.3
  TOP w0.14: v2(73.58,32.86) 73.58,32.89 v1(73.19,33.28)
  L3 w0.127: v2(91.35,74.21) 91.35,69.26 89.56,67.48 85.01,67.48 84.3,66.77 84.12,66.77 83.83,67.05 83.62,67.05 83.48,66.9 83.48,66.69 83.76,66.41 83.76,66.23 83.58,66.05 83.4,66.05 83.1,66.34 82.89,66.34 82.74,66.19 82.74,65.98 83.04,65.69 83.04,65.51 74.99,57.45 74.99,56.96 74.72,56.69 74.23,56.69 73.35,55.82 73.35,33.27 73.58,33.04 v2(73.58,32.86)
  BOTTOM w0.089: 93.17,74.39 94.09,74.39 94.85,75.14 95.6,75.14 95.75,75.29 96.08,75.29 CPU1.AU69
  BOTTOM w0.14: v2(91.35,74.21) 91.52,74.39 93.17,74.39 ; v2(73.58,32.86) 73.06,32.34 73.06,31.17 73.15,31.08 DM1.34
M_A_DQ16: length 58.1
  TOP w0.14: v2(75.37,36.49) 75.16,36.49 v1(74.88,36.21)
  L3 w0.127: v2(93.64,66.45) 91.31,66.45 89.8,64.93 85.92,64.93 81.88,60.9 81.88,60.21 80.94,59.27 80.26,59.27 78.55,57.56 78.55,57.35 78.7,57.2 78.91,57.2 80.3,58.6 80.48,58.6 80.66,58.42 80.66,58.24 75.91,53.49 75.91,37.48 75.4,36.96 75.4,36.52 v2(75.37,36.49)
  BOTTOM w0.089: CPU1.BB65 98.84,72.28 98.76,72.19 98.76,71.69 97.44,70.37 95.57,70.37 94.57,69.37 94.57,68.8
  BOTTOM w0.14: v2(75.37,36.49) 75.25,36.61 DM1.41 ; v2(93.64,66.45) 94.01,66.45 94.57,67.01 94.57,68.8
M_A_DQ17: length 59.9
  TOP w0.14: v1(75.44,33.1) 75.1,32.76 v2(74.97,32.76)
  L3 w0.127: v2(74.97,32.76) 74.14,33.6 74.14,37.68 74.67,38.21 74.67,54.15 76.32,55.81 76.32,57.13 85.31,66.11 89.31,66.11 92.89,69.7 v2(93.64,69.7)
  BOTTOM w0.089: CPU1.AW65 98.49,73.72 98.49,73.51 98.45,73.37 98.41,73.25 98.27,73.11 98.13,73.11 97.96,73.02 97.92,72.86 97.92,72.69 97.94,72.62 97.94,71.91 96.95,70.92 96.02,70.92 95.31,70.92 94.37,69.98
  BOTTOM w0.14: 94.37,69.98 94.09,69.7 v2(93.64,69.7) ; v2(74.97,32.76) 75.55,32.18 DM1.42
M_A_DQ18: length 61.1
  TOP w0.14: v2(77.29,33.42) 77.11,33.42 v1(76.81,33.11)
  L3 w0.127: v2(95.49,69.04) 95.24,69.28 94.76,69.28 94.53,69.06 94.53,68.09 94.21,67.77 94.21,65.14 93.81,64.74 91.4,64.74 90.32,63.65 86.46,63.65 83.52,60.72 83.52,59.09 77.18,52.75 77.18,36.66 77.29,36.56 v2(77.29,33.42)
  BOTTOM w0.089: 96.8,69.53 96.97,69.7 98.05,69.7 99.93,71.58 99.93,72.02 99.73,72.22 99.73,72.56 99.77,72.7 99.77,73.58 99.73,73.62 99.73,73.89 99.88,74.15 CPU1.AW63
  BOTTOM w0.14: 96.8,69.53 96.31,69.04 v2(95.49,69.04) ; DM1.52 78.55,30.98 78.37,31.16 78.37,32.78 77.74,33.42 v2(77.29,33.42)
M_A_DQ19: length 60
  TOP w0.14: v1(78.94,35.81) 79.19,36.06 v2(79.45,36.06)
  L3 w0.127: v2(95.49,65.7) 95.49,65.42 94.12,64.04 92.43,64.04 90.86,62.47 87.31,62.47 85.45,60.61 85.45,60.4 85.6,60.26 85.81,60.26 87.48,61.92 87.69,61.92 87.83,61.77 87.83,61.56 78.36,52.09 78.36,37.15 78.52,37 78.52,36.2 78.74,35.98 79.37,35.98 v2(79.45,36.06)
  BOTTOM w0.089: CPU1.AY63 100.47,73.21 100.47,71.37 98.14,69.03 97.62,69.03 97.24,68.66
  BOTTOM w0.14: v2(95.49,65.7) 96.51,66.72 96.51,67.93 97.24,68.66 ; v2(79.45,36.06) 79.38,36.13 79.22,36.13 78.96,36.39 78.96,37.24 78.85,37.35 DM1.53
M_A_DQ20: length 59
  TOP w0.14: v1(74.9,34.85) 75.22,35.17 v2(75.38,35.17)
  L3 w0.127: v2(75.38,35.17) 74.92,35.62 74.92,37.24 75.49,37.8 75.49,53.71 78.47,56.69 78.47,56.87 78.29,57.05 78.11,57.05 77.56,56.5 77.35,56.5 77.2,56.65 77.2,56.86 80.13,59.78 80.73,59.78 81.46,60.51 81.46,61.03 85.76,65.33 89.64,65.33 91.12,66.81 92.7,66.81 v2(93.64,67.75)
  BOTTOM w0.089: 94.34,68.96 94.34,69.39 95.52,70.56 97.27,70.56 98.58,71.87 98.58,72.54 98.65,72.8 CPU1.BA65
  BOTTOM w0.14: v2(75.38,35.17) 75.18,35.17 74.65,35.7 DM1.39 ; 94.34,68.96 94.34,68.35 93.74,67.75 v2(93.64,67.75)
M_A_DQ21: length 59.3
  TOP w0.14: v1(74.96,30.88) 74.97,30.89 v2(74.97,31.44)
  L3 w0.127: v2(93.64,68.4) 93.59,68.45 92.21,68.45 89.47,65.72 85.47,65.72 76.75,57 76.75,55.58 75.07,53.9 75.07,37.97 74.53,37.43 74.53,34.62 75.41,33.74 75.41,31.89 v2(74.97,31.44)
  BOTTOM w0.089: CPU1.AY65 98.84,73.52 98.61,73.29 98.6,73.25 98.6,73.24 98.53,72.99 98.48,72.87 98.4,72.56 98.4,71.99 97.15,70.74 95.42,70.74 94.12,69.43 94.12,69.15
  BOTTOM w0.14: v2(93.64,68.4) 93.82,68.4 94.12,68.69 94.12,69.15 ; DM1.40 74.95,31.42 v2(74.97,31.44)
M_A_DQ22: length 59.3
  TOP w0.14: v1(76.79,31.82) 77.07,32.09 v2(77.29,32.09)
  L3 w0.127: v2(95.49,67.74) 95.09,67.74 94.59,67.24 94.59,65.21 93.89,64.51 91.73,64.51 90.48,63.26 86.72,63.26 83.92,60.46 83.92,58.89 77.58,52.55 77.58,36.82 77.73,36.67 77.73,32.38 78.07,32.04 78.07,31.83 77.92,31.67 77.71,31.67 v2(77.29,32.09)
  BOTTOM w0.089: CPU1.BA63 99.97,72.8 99.91,72.54 99.91,72.29 100.11,72.09 100.11,71.51 98.07,69.46 97.22,69.46 96.81,69.06
  BOTTOM w0.14: v2(77.29,32.09) 77.52,32.09 77.95,31.66 DM1.50 ; 96.81,69.06 v2(95.49,67.74)
M_A_DQ23: length 58.4
  TOP w0.14: v2(79.45,34.74) 79.11,34.74 v1(78.92,34.54)
  L3 w0.127: v2(95.49,67.09) 95.13,67.09 94.9,66.86 94.9,65.22 93.95,64.27 92.1,64.27 90.7,62.87 87.09,62.87 84.34,60.12 84.34,59.91 84.49,59.76 84.7,59.76 85.03,60.09 85.21,60.09 85.39,59.91 85.39,59.73 77.97,52.31 77.97,36.99 78.12,36.83 78.12,35.99 78.64,35.47 78.64,34.72 78.86,34.5 79.21,34.5 v2(79.45,34.74)
  BOTTOM w0.089: 97.04,68.88 97.42,69.25 98.1,69.25 100.29,71.44 100.29,72.33 CPU1.BB63
  BOTTOM w0.14: DM1.51 78.25,37.38 78.55,37.08 78.55,35.63 79.26,34.93 79.26,34.93 v2(79.45,34.74) ; v2(95.49,67.09) 96.19,67.79 96.19,68.02 97.04,68.88
M_A_DQ24: length 56.7
  TOP w0.14: v2(79.45,31.59) 79.45,31.02 v1(79.44,31.01)
  L3 w0.127: v2(97.62,67.15) 96.13,65.66 96.13,65.44 94.07,63.38 92.96,63.38 91.12,61.54 89.49,61.54 79.77,51.82 79.77,48.97 80.37,48.37 80.37,46.52 79.61,45.76 79.61,45.64 79.71,45.54 80.15,45.54 80.29,45.39 80.29,45.18 80.15,45.03 79.65,45.03 79.52,44.91 79.52,37.9 80.29,37.13 80.29,32.43 v2(79.45,31.59)
  BOTTOM w0.089: 98.44,68.38 98.44,68.79 100.85,71.2 100.85,72.76 CPU1.BA61
  BOTTOM w0.14: v2(97.62,67.15) 97.62,67.15 98.44,67.98 98.44,68.38 ; DM1.56 79.75,31.29 v2(79.45,31.59)
M_A_DQ25: length 58.7
  TOP w0.14: v1(81.34,35.71) 81.02,35.39 v2(80.88,35.39)
  L3 w0.127: v2(80.88,35.39) 81.32,35.83 81.32,37.65 80.31,38.66 80.31,40.34 80.46,40.49 80.67,40.49 80.82,40.34 80.82,38.91 80.96,38.76 81.18,38.76 81.32,38.91 81.32,48.59 80.57,49.34 80.57,51.51 89.82,60.75 91.51,60.75 93.36,62.6 94.22,62.6 96.73,65.11 v2(97.62,65.11)
  BOTTOM w0.089: 100.76,70.51 101.24,70.99 101.24,72.05 101.49,72.3 101.49,72.69 101.55,72.75 101.55,73.45 101.63,73.66 101.63,73.91 101.62,73.95 CPU1.AW61
  BOTTOM w0.14: v2(97.62,65.11) 97.79,65.11 98.98,66.31 98.98,68.73 100.76,70.51 ; v2(80.88,35.39) 80.05,36.22 DM1.57
M_A_DQ26: length 57
  TOP w0.14: v1(83.16,35.3) 83.5,34.96 v2(83.64,34.96)
  L3 w0.127: v2(83.64,34.96) 83.24,34.96 82.86,35.35 82.86,36.75 82.59,37.01 82.59,46.73 82.86,46.99 82.86,47.75 82.98,47.88 83.71,47.88 83.83,48.01 83.83,48.26 83.71,48.39 82.98,48.39 82.86,48.51 82.86,50.76 82.71,50.91 82.5,50.91 82.35,50.76 82.35,50.05 82.2,49.9 81.99,49.9 81.84,50.05 81.84,50.98 90.34,59.48 92.09,59.48 96.72,64.11 97.87,64.11 98.82,65.06 98.82,65.33 v2(99.41,65.92)
  BOTTOM w0.089: 102.01,70.64 102.52,71.15 CPU1.BB59
  BOTTOM w0.14: DM1.67 83.05,37.29 82.99,37.23 82.99,35.61 v2(83.64,34.96) ; v2(99.41,65.92) 100.35,66.86 100.35,68.98 102.01,70.64
M_A_DQ27: length 59.2
  TOP w0.14: v2(84.55,32.1) 84.37,32.1 v1(84.06,32.41)
  L3 w0.127: v2(84.55,32.1) 84.87,31.78 85.08,31.78 85.24,31.93 85.24,32.14 84.99,32.39 84.99,33.63 84.48,34.14 84.48,36.82 83.78,37.53 83.78,46.24 85.09,47.55 85.09,52.55 87.41,54.87 88.66,54.87 92.06,58.27 92.64,58.27 96.93,62.57 98.7,62.57 v2(99.46,63.33)
  BOTTOM w0.089: CPU1.AW59 102.82,74.71 102.82,74.87 103.02,75.07 103.3,75.07 103.5,74.87 103.5,74.59 103.46,74.56 103.46,74.28 103.5,74.24 103.5,73.37 103.48,73.36 103.48,72.86 103.34,72.59 103.34,70.99 102.43,70.07
  BOTTOM w0.14: v2(84.55,32.1) 84.38,32.1 83.95,31.66 DM1.70 ; v2(99.46,63.33) 101.1,64.97 101.1,68.75 102.43,70.07
M_A_DQ28: length 56.4
  TOP w0.14: v1(80.87,37.28) 80.88,37.27 v2(80.88,36.71)
  L3 w0.127: v2(97.62,66.47) 94.16,63.02 93.15,63.02 91.28,61.15 89.65,61.15 80.16,51.66 80.16,49.14 80.93,48.37 80.93,41.24 80.78,41.09 80.57,41.09 80.42,41.24 80.42,44.38 80.27,44.53 80.06,44.53 79.91,44.38 79.91,38.06 80.88,37.1 v2(80.88,36.71)
  BOTTOM w0.089: CPU1.BB61 101.05,72.31 101.05,71.12 98.69,68.76 98.69,68.43
  BOTTOM w0.14: 98.69,68.43 98.69,67.55 v2(97.62,66.47) ; DM1.59 80.65,36.94 v2(80.88,36.71)
M_A_DQ29: length 57.9
  TOP w0.14: v1(79.55,33.47) 79.45,33.37 v2(79.45,32.91)
  L3 w0.127: v2(79.45,32.91) 79.7,32.91 79.9,33.11 79.9,36.97 79.13,37.73 79.13,46.35 79.25,46.48 79.55,46.48 79.67,46.6 79.67,46.86 79.54,46.99 79.25,46.99 79.13,47.12 79.13,47.37 79.25,47.5 79.46,47.5 79.61,47.65 79.61,47.86 79.46,48.01 79.25,48.01 79.13,48.13 79.13,51.74 89.33,61.93 90.96,61.93 92.83,63.81 94.2,63.81 95.9,65.52 95.9,66.73 v2(97.62,68.45)
  BOTTOM w0.089: CPU1.AY61 100.81,73.09 100.65,72.93 100.65,71.25 98.23,68.83
  BOTTOM w0.14: v2(97.62,68.45) 97.85,68.45 98.23,68.83 ; v2(79.45,32.91) 80.35,32.01 DM1.58
M_A_DQ30: length 58
  TOP w0.14: v1(83.64,36.84) 83.64,36.84 v2(83.64,36.25)
  L3 w0.127: v2(99.44,65.26) 97.76,63.58 96.79,63.58 92.27,59.06 90.48,59.06 88.23,56.81 88.23,56.63 88.63,56.22 88.63,56.01 88.48,55.86 88.27,55.86 87.87,56.27 87.69,56.27 83.29,51.87 83.29,48.96 83.43,48.81 83.64,48.81 83.79,48.96 83.79,51.63 83.94,51.78 84.15,51.78 84.3,51.63 84.3,47.88 82.99,46.57 82.99,37.17 83.69,36.47 83.69,36.25 v2(83.64,36.25)
  BOTTOM w0.089: CPU1.BA59 102.63,73 102.63,72.78 102.73,72.68 102.78,72.55 102.78,71.08 102.22,70.52
  BOTTOM w0.14: DM1.69 83.65,36.26 v2(83.64,36.25) ; 102.22,70.52 100.64,68.93 100.64,66.46 v2(99.44,65.26)
M_A_DQ31: length 58.6
  TOP w0.14: v2(84.55,33.42) 84.78,33.42 v1(85.05,33.14)
  L3 w0.127: v2(84.55,33.42) 84.09,33.88 84.09,36.63 83.38,37.34 83.38,46.4 84.7,47.72 84.7,52.72 87.24,55.27 88.5,55.27 89.4,56.17 89.4,56.35 89.13,56.61 89.13,56.82 89.28,56.97 89.49,56.97 89.76,56.71 89.94,56.71 90.12,56.89 90.12,57.07 89.84,57.34 89.84,57.55 89.99,57.7 90.2,57.7 90.47,57.43 90.65,57.43 90.83,57.61 90.83,57.79 90.59,58.03 90.59,58.24 90.74,58.39 90.95,58.39 91.19,58.15 91.37,58.15 91.9,58.67 92.46,58.67 96.84,63.04 98.54,63.04 v2(99.46,63.96)
  BOTTOM w0.089: CPU1.AY59 102.52,73.75 102.83,73.35 102.87,73.26 102.87,72.86 102.96,72.58 102.96,70.93 102.27,70.24
  BOTTOM w0.14: 102.27,70.24 100.87,68.84 100.87,65.37 v2(99.46,63.96) ; v2(84.55,33.42) 83.35,32.22 DM1.68
M_A_DQ32: length 50
  TOP w0.14: v2(104.48,35.35) 104.7,35.35 v1(104.97,35.08)
  L3 w0.089: v2(112.76,69.81) 112.99,69.58 112.99,62.68 112.84,62.53 112.84,62.37
  L3 w0.127: 112.84,62.37 112.84,54.93 113.59,54.18 113.59,49.07 113.23,48.71 113.23,48.53 113.59,48.17 113.59,47.94 113.44,47.79 113.21,47.79 112.85,48.16 112.62,48.16 112.47,48 112.47,47.78 112.95,47.29 112.95,47.09 112.78,46.92 112.58,46.92 112.08,47.41 111.94,47.41 111.64,47.12 111.64,45.02 106.22,39.6 106.22,39.18 104.03,36.99 104.03,35.79 v2(104.48,35.35)
  BOTTOM w0.089: CPU1.AY39 113.57,73.53 113.25,73.22 113.25,72.86 113.12,72.59 113.12,71.35 113.02,71.25 113.02,70.07 v2(112.76,69.81)
  BOTTOM w0.14: v2(104.48,35.35) 104.36,35.35 103.99,35.72 103.99,36.91 104.05,36.98 DM1.129
M_A_DQ33: length 48.1
  TOP w0.14: v1(104.96,36.34) 104.67,36.62 v2(104.48,36.62)
  L3 w0.127: v2(114.17,69.86) 113.23,68.92 113.23,55.1 113.99,54.34 113.99,46.81 113.86,46.68 113.68,46.68 113.5,46.86 113.28,46.86 113.13,46.7 113.13,46.48 113.3,46.31 113.3,46.13 113.11,45.93 112.93,45.93 112.42,46.44 112.2,46.44 112.04,46.28 112.04,46.06 112.55,45.55 112.55,45.37 106.62,39.44 106.62,39.02 104.95,37.35 104.95,37.09 v2(104.48,36.62)
  BOTTOM w0.089: CPU1.AW39 114.21,74.41 114.49,74.13 114.49,73.35 114.45,73.21 114.45,72.96 114.49,72.88 114.49,72.68 114.45,72.6 114.45,72.07 114.57,71.96
  BOTTOM w0.14: v2(114.17,69.86) 114.17,69.94 114.59,70.35 114.59,71.94 114.57,71.96 ; v2(104.48,36.62) 104.65,36.79 DM1.131
M_A_DQ34: length 50.5
  TOP w0.14: v2(108.62,34.7) 108.95,35.03 v1(109.12,35.03)
  L3 w0.089: v2(114.17,69.21) 115.07,68.32 115.07,63.65 115.2,63.53
  L3 w0.127: v2(108.62,34.7) 108.58,34.7 107.78,35.5 107.78,37.03 108.67,37.92 108.67,38.59 116.79,46.7 116.79,49.7 116.66,49.83 116.23,49.83 116.1,49.95 116.1,50.23 116.23,50.36 116.66,50.36 116.79,50.49 116.79,50.77 116.66,50.9 116.23,50.9 116.1,51.02 116.1,55.14 115.29,55.95 115.29,63.43 115.2,63.53
  BOTTOM w0.089: CPU1.AY37 114.73,73.43 114.66,73.29 114.66,73.28 114.63,73.18 114.63,73.01 114.67,72.92 114.67,72.64 114.63,72.56 114.63,72.26 114.79,72.11
  BOTTOM w0.14: 114.79,72.11 114.82,72.08 114.82,69.85 v2(114.17,69.21) ; v2(108.62,34.7) 107.65,35.67 DM1.141
M_A_DQ35: length 51
  TOP w0.14: v2(108.62,36.02) 108.91,36.32 v1(109.11,36.32)
  L3 w0.127: v2(115.9,66.52) 115.9,66.64 115.78,66.76 115.48,66.76 115.32,66.6 115.32,63.84 115.68,63.47 115.68,56.11 116.56,55.23 116.56,54.81 116.69,54.69 117.08,54.69 117.23,54.53 117.23,54.31 117.08,54.15 116.69,54.15 116.56,54.03 116.56,53.75 116.69,53.62 117.07,53.62 117.23,53.46 117.23,53.24 117.07,53.08 116.69,53.08 116.56,52.96 116.56,52.68 116.69,52.55 117.06,52.55 117.21,52.4 117.21,52.17 117.06,52.02 116.69,52.02 116.56,51.89 116.56,51.55 117.18,50.94 117.18,46.54 109.07,38.42 109.07,37.76 108.18,36.87 108.18,35.89 108.25,35.81 108.55,35.81 108.62,35.87 v2(108.62,36.02)
  BOTTOM w0.089: CPU1.AW37 114.79,74.29 115.11,73.98 115.11,73.35 115.49,72.97 115.49,72.69 115.48,72.68 115.48,72.23 115.49,72.22 115.49,70.24
  BOTTOM w0.14: v2(108.62,36.02) 108.13,36.51 108.13,37.07 108.25,37.19 DM1.143 ; v2(115.9,66.52) 115.9,66.59 115.49,67 115.49,70.24
M_A_DQ36: length 48.9
  TOP w0.14: v2(105.56,33.39) v1(105.56,34.01)
  L3 w0.127: v2(105.56,33.39) 105.56,37.4 105.67,37.52 107.01,38.85 107.01,39.28 114.38,46.65 114.38,54.51 113.63,55.26 113.63,62.49 113.47,62.65 113.47,65.8 113.63,65.96 v2(114.17,65.96)
  BOTTOM w0.089: 113.35,69.48 113.38,69.51 113.38,71.04 113.57,71.23 CPU1.BB39
  BOTTOM w0.14: 113.35,69.48 113.35,69.47 113.05,69.17 113.05,67.09 v2(114.17,65.96) ; v2(105.56,33.39) 105.55,33.39 105.49,33.33 105.46,33.33 104.35,32.22 DM1.130
M_A_DQ37: length 49.5
  TOP w0.14: v2(105.55,32.1) 105.44,32.1 v1(105.03,32.51)
  L3 w0.089: 113.85,62.86 113.66,63.05 113.66,64.8 v2(114.17,65.31)
  L3 w0.127: 113.85,62.86 114.02,62.7 114.02,55.42 114.78,54.67 114.78,46.49 107.4,39.11 107.4,38.69 106.07,37.35 106.07,32.61 v2(105.55,32.1)
  BOTTOM w0.089: 113.1,69.54 113.2,69.65 113.2,71.14 113.3,71.24 113.3,72.56 113.38,72.72 113.46,72.89 113.46,73 CPU1.BA39
  BOTTOM w0.14: v2(105.55,32.1) 105.39,32.1 104.95,31.66 DM1.132 ; v2(114.17,65.31) 112.82,66.66 112.82,69.27 113.1,69.54
M_A_DQ38: length 50.3
  TOP w0.14: v2(108.61,33.36) 108.21,33.36 v1(107.96,33.12)
  L3 w0.089: 115.72,63.95 115.51,64.15 115.51,64.7 v2(115.9,65.09)
  L3 w0.127: v2(108.61,33.36) 108.72,33.25 109.04,33.25 109.22,33.43 109.22,37.21 109.46,37.44 109.46,38.26 117.63,46.43 117.63,54.73 116.08,56.28 116.08,63.59 115.72,63.95
  BOTTOM w0.089: CPU1.BA37 115.25,72.75 115.25,69.62 115.15,69.51 115.15,69.35
  BOTTOM w0.14: 115.15,69.35 115.15,65.85 v2(115.9,65.09) ; v2(108.61,33.36) 108.21,33.36 107.35,32.5 DM1.140
M_A_DQ39: length 49.4
  TOP w0.14: v2(108.62,32.08) 108.24,32.08 v1(107.96,31.81)
  L3 w0.127: v2(115.9,64.38) 116.47,63.81 116.47,56.44 118.02,54.89 118.02,46.26 109.85,38.1 109.85,37.28 109.62,37.04 109.62,32.43 109.27,32.08 v2(108.62,32.08)
  BOTTOM w0.089: 114.84,69.34 114.84,69.5 115.02,69.68 115.02,72.33 CPU1.BB37
  BOTTOM w0.14: v2(108.62,32.08) 108.33,32.08 107.95,31.7 DM1.142 ; 114.84,69.34 114.84,65.45 v2(115.9,64.38)
M_A_DQ40: length 56.9
  TOP w0.14: v2(110.07,35.37) 110.34,35.65 v1(110.6,35.65)
  L3 w0.089: 117.26,59.82 117.26,64.38 116.68,64.96 116.68,67.7 v2(115.9,68.47)
  L3 w0.127: 117.26,59.82 117.26,57.21 119.05,55.42 119.05,53.27 119.21,53.12 119.43,53.12 119.58,53.27 119.58,55.61 119.26,55.94 119.26,56.15 119.41,56.31 119.63,56.31 120.12,55.81 120.12,47.03 110.64,37.56 110.64,35.3 110.47,35.13 110.24,35.13 110.07,35.3 v2(110.07,35.37)
  BOTTOM w0.089: 116.56,69.47 116.56,70.62 116.2,70.98 116.2,72.52 116.15,72.64 116.15,72.91 116.18,73.02 116.18,73.2 116.14,73.31 116.14,73.64 CPU1.AY35
  BOTTOM w0.14: v2(115.9,68.47) 116.32,68.89 116.32,69.23 116.56,69.47 ; DM1.147 109.45,36.72 109.09,36.36 109.09,35.47 109.32,35.24 109.94,35.24 v2(110.07,35.37)
M_A_DQ41: length 57.3
  TOP w0.14: v2(110.07,36.69) 110.07,37.16 v1(110.16,37.25)
  L3 w0.089: v2(115.9,67.17) 116.3,66.78 116.3,64.7 116.84,64.16 116.84,64.15 116.9,64.09 116.9,59.75 116.86,59.71
  L3 w0.127: v2(110.07,36.69) 110.07,36.92 110.25,37.1 110.25,37.12 110.25,37.72 119.72,47.2 119.72,52.56 119.57,52.72 119.35,52.72 119.19,52.56 119.19,47.42 119.03,47.26 118.81,47.26 118.66,47.42 118.66,55.23 116.86,57.03 116.86,59.71
  BOTTOM w0.089: CPU1.AW35 116.32,74.11 116.32,73.34 116.36,73.24 116.36,72.97 116.32,72.88 116.32,72.67 116.36,72.59 116.36,72.59 116.39,72.53 116.39,71.04 116.76,70.67 116.76,69.27 116.55,69.05 116.55,68.78
  BOTTOM w0.14: v2(115.9,67.17) 116.55,67.81 116.55,68.78 ; DM1.149 110.05,37.29 109.99,37.23 109.99,36.76 v2(110.07,36.69)
M_A_DQ42: length 56.5
  TOP w0.14: v2(113.24,31.5) v1(113.24,30.94)
  L3 w0.089: 119.72,62.19 119.56,62.35 v2(119.56,65.74)
  L3 w0.127: 119.72,62.19 124.56,57.35 124.56,46.84 114.71,36.99 114.71,33.52 115.06,33.16 115.06,31.53 114.91,31.38 114.7,31.38 114.55,31.53 114.55,33 114.4,33.15 114.19,33.15 114.05,33 114.05,31.9 113.64,31.5 v2(113.24,31.5)
  BOTTOM w0.089: CPU1.AY33 117.4,73.53 117.54,73.33 117.54,73.09 117.62,72.74 117.66,72.68 117.68,72.57 117.7,72.5 117.7,72.06 117.57,71.94 117.57,71.53 117.91,71.19 117.92,71.19 118.15,70.96 118.15,69.12 118.23,69.04
  BOTTOM w0.14: v2(119.56,65.74) 119.53,65.74 118.57,66.71 118.57,68.71 118.23,69.04 ; v2(113.24,31.5) 113.35,31.39 DM1.160
M_A_DQ43: length 55.3
  TOP w0.14: v2(113.24,32.77) 113.36,32.77 v1(113.72,33.13)
  L3 w0.089: v2(115.92,74.97) 116.12,74.77 116.12,74.51 118.85,71.77 118.85,69.66 119.15,69.36 119.15,62.2 119.31,62.03
  L3 w0.127: 119.31,62.03 124.16,57.18 124.16,47 114.31,37.15 114.31,33.84 v2(113.24,32.77)
  BOTTOM w0.14: DM1.158 112.75,32.3 113.21,32.77 v2(113.24,32.77) ; v2(115.92,74.97) 116.48,74.41 CPU1.AW33
M_A_DQ44: length 55.3
  TOP w0.14: v2(110.08,33.52) 109.93,33.52 v1(109.57,33.16)
  L3 w0.127: v2(110.08,33.52) 110.08,34.09 111.04,35.04 111.04,37.34 120.51,46.82 120.51,56.05 118.55,58.02 118.33,58.02 118.17,57.86 118.17,57.64 119.07,56.74 119.07,56.52 118.91,56.37 118.69,56.37 117.65,57.4 117.65,64.47 117.14,64.98 117.14,68.99 116.76,69.37 116.15,69.37 v2(115.9,69.12)
  BOTTOM w0.114: v2(115.9,69.12) 116.33,69.55 116.33,70.57 115.92,70.97 115.92,72.14 115.92,72.14 CPU1.BB35
  BOTTOM w0.14: DM1.146 109.15,32.6 v2(110.08,33.52)
M_A_DQ45: length 55.7
  TOP w0.14: v1(109.61,31.86) 109.95,32.2 v2(110.08,32.2)
  L3 w0.127: v2(110.08,32.2) 110.43,32.2 110.52,32.3 110.52,33.97 111.43,34.88 111.43,37.18 120.91,46.66 120.91,56.23 120.74,56.39 120.74,56.57 121.07,56.9 121.07,57.11 120.92,57.26 120.71,57.26 120.38,56.93 120.2,56.93 120.03,57.11 120.03,57.29 120.35,57.62 120.35,57.83 120.2,57.97 119.99,57.97 119.67,57.65 119.49,57.65 119.31,57.83 119.31,58.01 119.64,58.34 119.64,58.55 119.49,58.7 119.28,58.7 118.95,58.37 118.77,58.37 118.59,58.55 118.59,58.73 118.89,59.04 118.89,59.25 118.75,59.4 118.54,59.4 118.3,59.16 118.18,59.16 118.05,59.3 118.05,64.5 117.42,65.12 117.42,69.43 116.44,70.42 v2(115.88,70.42)
  BOTTOM w0.089: v2(115.88,70.42) 115.67,70.63 115.67,72.3 115.66,72.3 115.66,72.61 115.67,72.61 115.67,72.85 CPU1.BA35
  BOTTOM w0.14: DM1.148 109.75,30.91 109.6,31.07 109.6,31.72 v2(110.08,32.2)
M_A_DQ46: length 56.1
  TOP w0.14: v2(113.24,34.66) 113.1,34.66 v1(112.76,34.99)
  L3 w0.089: 119.15,61.64 118.95,61.83 118.95,68.93 118.53,69.35 118.05,69.35 117.92,69.22 117.92,68.48 v2(117.92,68.48)
  L3 w0.127: 119.15,61.64 123.77,57.02 123.77,52.37 123.64,52.25 123.53,52.25 123.38,52.1 123.38,51.89 123.53,51.74 123.62,51.74 123.77,51.59 123.77,51.38 123.62,51.23 123.55,51.23 123.4,51.08 123.4,50.87 123.55,50.72 123.62,50.72 123.77,50.57 123.77,50.36 123.62,50.21 123.54,50.21 123.39,50.07 123.39,49.86 123.54,49.71 123.62,49.71 123.77,49.56 123.77,49.35 123.62,49.2 123.53,49.2 123.38,49.05 123.38,48.84 123.53,48.69 123.61,48.69 123.76,48.54 123.76,48.33 123.61,48.18 123.51,48.18 123.39,48.06 123.39,47.8 123.51,47.67 123.64,47.67 123.77,47.55 123.77,47.17 113.75,37.14 113.75,34.01 113.6,33.86 113.39,33.86 113.24,34.01 v2(113.24,34.66)
  BOTTOM w0.089: 117.83,70.99 117.4,71.43 117.4,72.04 117.52,72.17 117.52,72.47 117.49,72.6 117.25,72.99 CPU1.BA33
  BOTTOM w0.14: DM1.157 112.45,37.2 112.32,37.07 112.32,35.4 113.06,34.66 v2(113.24,34.66) ; v2(117.92,68.48) 117.92,68.63 117.95,68.66 117.95,70.87 117.83,70.99
M_A_DQ47: length 54.8
  TOP w0.14: v1(112.76,36.25) 113.08,35.93 v2(113.24,35.93)
  L3 w0.089: 118.98,61.06 118.77,61.28 118.77,67.66 118.48,67.94 118.04,67.94 v2(117.92,67.83)
  L3 w0.127: v2(113.24,35.93) 113.24,35.88 113.11,35.75 112.92,35.75 112.79,35.88 112.79,36.75 122.95,46.9 122.95,52.62 123.26,52.93 123.26,55.82 123.1,55.97 122.88,55.97 122.73,55.82 122.73,53.43 122.57,53.28 122.35,53.28 122.19,53.43 122.19,56.16 122.41,56.38 122.41,56.72 122.53,56.84 122.83,56.84 122.99,57 122.99,57.22 122.83,57.38 122.53,57.38 122.41,57.5 122.41,57.64 118.98,61.06
  BOTTOM w0.089: 117.72,70.76 117.62,70.86 117.62,70.95 117.22,71.35 117.22,72.43 CPU1.BB33
  BOTTOM w0.14: v2(113.24,35.93) 112.85,35.93 112.72,36.05 112.72,36.79 113.05,37.12 DM1.159 ; v2(117.92,67.83) 117.92,67.9 117.51,68.31 117.51,68.65 117.72,68.87 117.72,70.76
M_A_DQ48: length 60.6
  TOP w0.14: v2(115.52,32.07) 115.38,32.07 v1(115.03,31.73)
  L3 w0.089: v2(119.56,69.64) 120.16,69.64 120.65,69.15 120.65,63.14 120.75,63.04
  L3 w0.127: 120.75,63.04 123.17,60.63 123.84,60.63 127.58,56.89 127.58,50.24 128.43,49.39 128.43,48.57 127.63,47.77 127.63,47.57 127.75,47.44 128.3,47.44 128.45,47.29 128.45,47.08 128.3,46.94 127.81,46.94 126.87,45.99 126.87,45.78 127.02,45.63 127.23,45.63 127.94,46.34 128.15,46.34 128.3,46.19 128.3,45.98 125.44,43.13 123.08,43.13 116.87,36.92 116.87,33.98 116.58,33.69 116.58,32.87 115.78,32.07 v2(115.52,32.07)
  BOTTOM w0.089: CPU1.AY31 118.77,73.47 118.82,73.4 118.9,73.24 118.9,72.91 118.97,72.63 118.97,72.5
  BOTTOM w0.14: DM1.166 115.15,30.86 115.04,30.98 115.04,31.85 115.26,32.07 v2(115.52,32.07) ; v2(119.56,69.64) 118.97,70.24 118.97,72.5
M_A_DQ49: length 61.7
  TOP w0.14: v2(115.54,35.79) 115.32,35.79 v1(115.04,36.06)
  L3 w0.089: 120.13,62.64 119.96,62.8 119.96,66.88 119.8,67.04 v2(119.56,67.04)
  L3 w0.127: v2(115.54,35.79) 115.25,35.79 115.1,35.94 115.1,36.83 122.59,44.31 123.45,44.31 125.35,46.22 125.35,56.19 125.5,56.34 125.71,56.34 125.86,56.19 125.86,52.14 126.01,51.99 126.22,51.99 126.37,52.14 126.37,56.4 120.13,62.64
  BOTTOM w0.089: CPU1.AW31 118.55,74.18 118.23,73.86 118.23,72.8 118.11,72.68 118.11,72.17 118.36,71.91 118.36,69.49
  BOTTOM w0.14: 118.36,69.49 118.86,68.99 118.86,66.99 119.05,66.81 119.33,66.81 v2(119.56,67.04) ; v2(115.54,35.79) 115.26,35.51 114.85,35.51 114.66,35.7 114.66,37.06 114.85,37.25 DM1.165
M_A_DQ50: length 60.4
  TOP w0.14: v1(116.92,33.23) 117.27,32.88 v2(117.37,32.88)
  L3 w0.089: v2(121.24,66.51) 121.67,66.51 122.35,65.83 122.35,62.91 123.5,61.77 125.65,61.77
  L3 w0.127: v2(117.37,32.88) 117.78,32.47 117.99,32.47 118.14,32.63 118.14,32.84 117.85,33.14 117.85,33.35 118,33.5 118.21,33.5 118.39,33.31 118.57,33.31 120.16,34.9 120.16,37.25 122.81,39.9 126.23,39.9 130.55,44.21 130.55,56.87 125.65,61.77
  BOTTOM w0.089: CPU1.AY29 119.83,73.81 119.98,73.81 120.09,73.7 120.09,73.35 120.38,73.06 120.38,72.08 120.26,71.96 120.26,71.48 120.61,71.13
  BOTTOM w0.14: 120.61,71.13 120.82,70.92 120.82,67.21 121.24,66.79 v2(121.24,66.51) ; v2(117.37,32.88) 117.64,32.88 118.15,32.37 DM1.176
M_A_DQ51: length 60.4
  TOP w0.14: v2(117.4,31.53) 117.4,30.89 v1(117.43,30.86)
  L3 w0.089: v2(119.88,74.98) 119.88,71.6 120.84,70.63 120.84,67.25 121.08,67.01 121.48,67.01 122.54,65.94 122.54,63 123.56,61.98
  L3 w0.127: v2(117.4,31.53) 117.7,31.53 119.31,33.13 119.31,33.49 120.56,34.74 120.56,37.08 122.93,39.46 126.35,39.46 130.94,44.04 130.94,57.04 125.99,61.98 123.56,61.98
  BOTTOM w0.14: v2(117.4,31.53) 117.4,31.49 117.55,31.34 DM1.174 ; CPU1.AW29 119.77,74.88 v2(119.88,74.98)
M_A_DQ52: length 58.8
  TOP w0.14: v2(115.51,33.34) 115.37,33.34 v1(115.03,33)
  L3 w0.089: v2(119.56,68.99) 120.41,68.14 120.41,63.05 120.54,62.93
  L3 w0.127: v2(115.51,33.34) 116.48,34.31 116.48,37.09 122.91,43.52 125.28,43.52 126.8,45.04 126.8,45.25 126.65,45.4 126.44,45.4 125.08,44.04 124.87,44.04 124.72,44.19 124.72,44.4 127.17,46.85 127.17,48.32 127.32,48.47 127.32,49.87 127.17,50.02 127.17,56.74 123.5,60.41 123.06,60.41 120.54,62.93
  BOTTOM w0.089: v2(119.56,68.99) 118.73,69.83 118.73,72.28 CPU1.BB31
  BOTTOM w0.14: v2(115.51,33.34) 114.85,33.34 114.46,32.95 114.46,31 114.55,30.92 DM1.164
M_A_DQ53: length 59.8
  TOP w0.14: v2(115.54,34.47) 115.39,34.47 v1(115.08,34.79)
  L3 w0.089: v2(119.56,67.69) 119.94,67.69 120.19,67.44 120.19,62.96 120.34,62.81
  L3 w0.127: 120.34,62.81 122.95,60.19 123.16,60.19 126.76,56.6 126.76,50.07 126.61,49.92 126.4,49.92 126.25,50.07 126.25,51.44 126.13,51.56 125.87,51.56 125.74,51.44 125.74,47.36 125.89,47.21 126.1,47.21 126.25,47.36 126.25,48.19 126.4,48.33 126.61,48.33 126.76,48.19 126.76,47.04 123.64,43.92 122.75,43.92 116.08,37.25 116.08,34.66 115.89,34.47 v2(115.54,34.47)
  BOTTOM w0.089: CPU1.BA31 118.55,72.87 118.29,72.61 118.29,72.24 118.54,71.99 118.54,69.69 118.63,69.6
  BOTTOM w0.14: DM1.163 114.25,35.5 115.28,34.47 v2(115.54,34.47) ; 118.63,69.6 119.15,69.08 119.15,68.17 119.56,67.76 v2(119.56,67.69)
M_A_DQ54: length 59.6
  TOP w0.14: v2(119.17,36.07) 119,36.07 v1(118.68,36.39)
  L3 w0.089: 125.74,61.12 125.38,61.48 123.53,61.48 122.16,62.85 122.16,65.73 121.78,66.11 121.49,66.11 v2(121.24,65.86)
  L3 w0.127: 125.74,61.12 130.15,56.71 130.15,44.58 127.04,41.47 123.85,41.47 123.7,41.32 123.7,41.11 123.85,40.96 126.23,40.96 126.38,40.81 126.38,40.6 126.23,40.45 122.81,40.45 119.65,37.29 119.65,36.76 119.77,36.64 119.77,35.8 119.65,35.68 119.51,35.68 119.17,36.03 v2(119.17,36.07)
  BOTTOM w0.089: CPU1.BA29 119.97,73.11 120.15,72.92 120.15,72.15 120.09,72.09 120.09,71.29 120.42,70.96
  BOTTOM w0.14: 120.42,70.96 120.59,70.78 120.59,67.08 120.8,66.88 120.8,66.04 120.98,65.86 v2(121.24,65.86) ; v2(119.17,36.07) 118.68,36.07 118.45,36.3 DM1.177
M_A_DQ55: length 58.9
  TOP w0.14: v1(118.64,35.17) 118.87,35.39 v2(119.17,35.39)
  L3 w0.089: v2(121.24,65.21) 121.27,65.24 121.79,65.24 121.97,65.06 121.97,62.79 123.52,61.24 125.06,61.24 125.4,60.9
  L3 w0.127: 125.4,60.9 129.76,56.55 129.76,44.79 129.42,44.46 129.24,44.46 129.02,44.68 128.84,44.68 128.66,44.5 128.66,44.32 128.88,44.1 128.88,43.92 128.7,43.74 128.52,43.74 128.3,43.96 128.12,43.96 127.94,43.78 127.94,43.6 128.16,43.38 128.16,43.2 126.82,41.86 123.66,41.86 118.72,36.92 118.72,35.91 117.87,35.06 117.87,34.02 117.99,33.9 118.27,33.9 118.4,34.02 118.4,34.83 118.96,35.39 v2(119.17,35.39)
  BOTTOM w0.089: CPU1.BB29 119.87,71.22 120.39,70.7 120.39,66.88 120.57,66.7
  BOTTOM w0.14: v2(121.24,65.21) 120.57,65.87 120.57,66.7 ; DM1.175 117.85,37.15 117.92,37.08 117.92,36.19 118.73,35.39 v2(119.17,35.39)
M_A_DQ56: length 62
  TOP w0.14: v2(121.39,36.02) 121.25,36.02 v1(120.9,36.37)
  L3 w0.089: 127.23,62.02 126.96,62.3 123.58,62.3 122.75,63.13 122.75,66.54 v2(121.24,68.05)
  L3 w0.127: 127.23,62.02 131.53,57.73 131.53,54.02 131.68,53.86 131.68,44.23 127.8,40.35 127.8,40.14 127.95,39.99 128.16,39.99 130.06,41.89 130.27,41.89 130.42,41.74 130.42,41.53 128.37,39.48 126.93,39.48 126.52,39.06 123.09,39.06 120.95,36.92 120.95,36.47 v2(121.39,36.02)
  BOTTOM w0.089: CPU1.AY27 121.05,73.63 121.05,73.44 121.18,73.18 121.25,73.03 121.25,72.91 121.3,72.71 121.36,72.5 121.36,72.03 121.46,71.93 121.46,70.25 121.75,69.96
  BOTTOM w0.14: v2(121.24,68.05) 121.29,68.05 121.95,68.71 121.95,69.76 121.75,69.96 ; DM1.183 120.25,36.56 120.79,36.02 v2(121.39,36.02)
M_A_DQ57: length 62
  TOP w0.14: v2(119.93,31.57) v1(119.93,31)
  L3 w0.089: v2(120.38,74.16) 120.38,72.69 123.31,69.76 123.31,63.32 123.57,63.06 124.76,63.06 125.26,63.55 127.65,63.55 127.84,63.36
  L3 w0.127: 127.84,63.36 132.71,58.49 132.71,54.95 132.86,54.8 132.86,42.3 128.86,38.3 127.66,38.3 127.25,37.88 123.58,37.88 122.86,37.16 122.86,34.96 121.29,33.4 121.29,32.94 121.26,32.9 v2(119.93,31.57)
  BOTTOM w0.14: v2(119.93,31.57) 119.95,31.55 DM1.182 ; CPU1.AW27 120.76,74.16 v2(120.38,74.16)
M_A_DQ58: length 61.9
  TOP w0.14: v1(123.05,32.96) 123.28,32.73 v2(123.61,32.73)
  L3 w0.127: v2(123.73,68) 125.48,66.25 128.35,66.25 135.31,59.29 135.31,56.96 135.73,56.54 135.73,53.69 135.08,53.05 135.08,41.58 133.99,40.49 133.99,40.31 134.18,40.12 134.18,39.94 134,39.76 133.82,39.76 133.63,39.95 133.45,39.95 133.27,39.77 133.27,39.59 133.46,39.41 133.46,39.23 130.07,35.83 130.07,33.41 129.01,32.36 125.5,32.36 125.18,32.67 124.55,32.67 124.31,32.44 123.9,32.44 v2(123.61,32.73)
  BOTTOM w0.089: CPU1.AY25 122.5,73.4 122.54,73.32 122.54,73.32 122.54,72.98 122.68,72.55 122.68,71.83 122.86,71.65 122.86,71.4
  BOTTOM w0.14: v2(123.61,32.73) 123.34,32.73 122.95,32.34 DM1.192 ; v2(123.73,68) 123.73,70.21 122.86,71.08 122.86,71.4
M_A_DQ59: length 61.1
  TOP w0.14: v2(123.66,31.43) 123.42,31.43 v1(123.13,31.72)
  L3 w0.127: v2(122.73,74.15) 122.73,70.97 127.13,66.57 128.59,66.57 135.7,59.45 135.7,57.12 136.12,56.7 136.12,53.53 135.51,52.92 135.51,41.45 135.38,41.32 135.38,41.19 135.51,41.07 135.6,40.97 135.6,40.76 135.45,40.61 135.24,40.61 135.05,40.79 134.87,40.79 134.69,40.61 134.69,40.43 134.87,40.25 134.87,40.08 130.46,35.67 130.46,33.25 129.17,31.96 124.75,31.96 124.32,31.53 124.32,31.37 124.21,31.26 123.82,31.26 v2(123.66,31.43)
  BOTTOM w0.14: v2(122.73,74.15) 122.47,74.41 CPU1.AW25 ; v2(123.66,31.43) 123.55,31.32 DM1.194
M_A_DQ60: length 59.9
  TOP w0.14: v1(119.45,33.17) 119.78,32.84 v2(119.93,32.84)
  L3 w0.089: 127.96,62.54 127.73,62.78 123.6,62.78 123.11,63.26 123.11,67.48 v2(121.24,69.35)
  L3 w0.127: v2(119.93,32.84) 120.16,32.84 120.7,33.37 120.7,33.55 120.41,33.84 120.41,34.02 120.59,34.2 120.77,34.2 121.06,33.91 121.23,33.91 122.46,35.14 122.46,37.32 123.42,38.28 127.08,38.28 127.5,38.69 128.69,38.69 132.47,42.47 132.47,54.44 132.31,54.6 132.31,58.19 127.96,62.54
  BOTTOM w0.089: v2(121.24,69.35) 121.1,69.49 121.1,71.78 120.98,71.9 120.98,72.37 CPU1.BB27
  BOTTOM w0.14: v2(119.93,32.84) 119.85,32.76 119.66,32.76 119.37,32.48 119.37,32.29 119.35,32.27 DM1.180
M_A_DQ61: length 60.7
  TOP w0.14: v1(120.91,35) 121.21,34.7 v2(121.39,34.7)
  L3 w0.089: 127.5,62.35 127.24,62.6 123.52,62.6 122.92,63.2 122.92,67.02 v2(121.24,68.7)
  L3 w0.127: v2(121.39,34.7) 122.07,35.38 122.07,37.48 123.26,38.67 126.92,38.67 127.33,39.08 128.53,39.08 131.87,42.42 131.87,42.63 131.72,42.78 131.51,42.78 130.82,42.1 130.64,42.1 130.46,42.28 130.46,42.46 132.08,44.07 132.08,54.14 131.92,54.3 131.92,57.93 127.5,62.35
  BOTTOM w0.089: 121.36,69.93 121.28,70.01 121.28,71.85 121.18,71.96 121.18,72.48 121.1,72.8 CPU1.BA27
  BOTTOM w0.14: v2(121.39,34.7) 121.38,34.68 120.75,34.68 119.65,35.79 DM1.181 ; 121.36,69.93 121.65,69.64 121.65,69.12 v2(121.24,68.7)
M_A_DQ62: length 60.5
  TOP w0.14: v1(124.66,34.49) 124.35,34.49 v2(124.13,34.71)
  L3 w0.127: v2(123.72,66.69) 124.44,65.98 128.06,65.98 134.92,59.12 134.92,55.64 134.69,55.41 134.69,41.78 132.8,39.89 132.8,39.12 129.67,35.99 129.67,33.58 128.85,32.75 127.28,32.75 126.7,33.33 125.51,33.33 v2(124.13,34.71)
  BOTTOM w0.089: CPU1.BA25 122.42,72.75 122.5,72.51 122.5,71.74 122.57,71.67 122.57,71.39
  BOTTOM w0.14: DM1.191 122.65,36.04 123.98,34.71 v2(124.13,34.71) ; 122.57,71.39 122.57,71.03 123.31,70.29 123.31,67.1 v2(123.72,66.69)
M_A_DQ63: length 59.6
  TOP w0.14: v1(123.55,36.16) 123.67,36.03 v2(124.13,36.03)
  L3 w0.127: v2(124.13,36.03) 124.16,36.03 126.45,33.74 127.02,33.74 127.62,33.14 128.68,33.14 129.28,33.74 129.28,36.16 130.97,37.85 130.97,38.03 130.77,38.23 130.77,38.41 130.95,38.59 131.13,38.59 131.33,38.39 131.51,38.39 131.69,38.57 131.69,38.75 131.49,38.95 131.49,39.13 131.67,39.31 131.85,39.31 132.05,39.11 132.23,39.11 132.41,39.29 132.41,39.47 132.21,39.67 132.21,39.85 134.3,41.94 134.3,55.58 134.52,55.8 134.52,58.64 128.17,64.99 124.78,64.99 v2(123.73,66.05)
  BOTTOM w0.14: v2(124.13,36.03) 123.88,36.03 123.25,36.66 DM1.193 ; v2(123.73,66.05) 123.09,66.69 123.09,70.19 122.28,70.99 122.28,72.4 CPU1.BB25
M_A_DQS_DN0: length 77.4
  TOP w0.127: v1(66.53,32.41) 66.26,32.68 v2(66.01,32.68)
  L3 w0.114: v2(90.7,78.52) 89.95,79.26 84.57,79.26 67.23,61.92 67.23,39.85 67.08,39.7 66.86,39.7 66.71,39.85 66.71,41.67 66.43,41.95 66.03,41.95 65.76,41.67 65.76,39.01 66.06,38.7 66.06,35.37 65.25,34.56 65.25,33.45 v2(66.01,32.68)
  BOTTOM w0.089: CPU1.AM70 95.98,78.53 95.86,78.41 95.68,78.41 95.48,78.35 95.34,78.35 95.19,78.4 94.63,78.4 94.56,78.33 92.95,78.33 92.92,78.36 92.9,78.36
  BOTTOM w0.127: 92.9,78.36 92.62,78.36 92.33,78.07 90.63,78.07 90.49,78.21 90.49,78.31 v2(90.7,78.52) ; DM1.10 65.95,30.89 66.32,31.26 66.32,31.47 66.58,31.73 66.58,32.87 66.46,32.99 66.17,32.99 66.01,32.84 v2(66.01,32.68)
M_A_DQS_DN1: length 63.9
  TOP w0.127: v2(71.87,35.18) 71.66,35.18 v1(71.37,34.89)
  L3 w0.114: v2(71.87,35.18) 71.65,35.4 71.44,35.4 71.19,35.64 71.19,37.32 71.71,37.84 71.71,56.43 74.04,58.76 74.04,58.92 73.74,59.22 73.74,59.61 74.02,59.89 74.41,59.89 74.71,59.59 74.87,59.59 75.08,59.8 75.08,59.96 74.81,60.24 74.81,60.63 75.08,60.91 75.48,60.91 75.75,60.64 75.91,60.64 76.12,60.85 76.12,61.01 75.86,61.27 75.86,61.65 84.1,69.89 84.1,71.59 87.41,74.9 89.97,74.9 v2(90.65,75.57)
  BOTTOM w0.089: CPU1.AT69 96.71,76.16 96.58,76.04 96.24,76.04 96.18,75.98 96.04,75.88 95.71,75.88 95.5,75.82 95.31,75.82 95.16,75.86 94.77,75.86 93.88,74.97 91.35,74.97 90.75,75.57 v2(90.65,75.57)
  BOTTOM w0.127: DM1.27 71.05,35.68 71.33,35.39 71.65,35.39 v2(71.87,35.18)
M_A_DQS_DN2: length 60
  TOP w0.127: v2(76.67,35.72) 77.21,35.72 v1(77.28,35.79)
  L3 w0.114: v2(93.64,65.15) 93.64,65.22 93.29,65.58 91.5,65.58 90.11,64.19 86.23,64.19 82.74,60.71 82.74,59.09 82.41,58.75 82.07,58.75 81.91,58.91 81.69,58.91 81.54,58.76 81.54,58.54 81.7,58.38 81.7,58.04 76.66,53 76.66,37.17 76.15,36.66 76.15,35.38 76.29,35.24 76.53,35.24 76.75,35.46 76.75,35.65 v2(76.67,35.72)
  BOTTOM w0.089: 96.16,69.84 96.18,69.84 96.2,69.87 96.65,69.87 96.77,69.99 97.71,69.99 99.13,71.41 99.13,71.95 99.29,72.1 99.29,72.56 99.24,72.71 99.24,72.85 99.3,73.05 99.3,73.28 99.45,73.43 CPU1.BA64
  BOTTOM w0.127: DM1.45 76.45,37.1 76.55,36.99 76.88,36.99 77.21,36.67 77.21,35.51 76.98,35.28 76.81,35.28 76.67,35.41 v2(76.67,35.72) ; 96.16,69.84 95.71,69.84 95.02,69.16 95.02,66.09 94.5,65.57 94,65.57 93.64,65.21 v2(93.64,65.15)
M_A_DQS_DN3: length 57.8
  TOP w0.127: v2(80.88,32.1) 81.13,32.1 v1(81.39,31.84)
  L3 w0.114: v2(99.4,67.22) 99.04,67.22 98.6,66.78 98.6,65.14 97.93,64.47 96.68,64.47 94.39,62.18 94.04,62.18 91.87,60.01 90.12,60.01 81.31,51.2 81.31,49.79 82.07,49.04 82.07,37.34 82.07,32.84 81.48,32.25 81.04,32.25 v2(80.88,32.1)
  BOTTOM w0.089: 102.28,71.91 102.28,71.93 102.26,71.96 102.26,72.53 102.3,72.68 102.3,72.88 102.24,73.08 102.24,73.41 102.1,73.6 102.1,73.94 CPU1.AY60
  BOTTOM w0.127: DM1.62 81.55,30.99 81.73,31.17 81.73,31.79 81.36,32.16 80.95,32.16 v2(80.88,32.1) ; v2(99.4,67.22) 99.56,67.39 99.89,67.39 100.12,67.63 100.12,69.08 102.28,71.24 102.28,71.91
M_A_DQS_DN4: length 50
  TOP w0.127: v1(107.12,34.93) 106.88,35.17 v2(106.6,35.17)
  L3 w0.114: v2(106.6,35.17) 106.96,35.53 107.04,35.53 107.25,35.75 107.25,37.26 108.15,38.16 108.15,38.8 115.52,46.18 115.52,46.67 115.63,46.78 115.95,46.78 116.23,47.06 116.23,47.46 115.95,47.74 115.63,47.74 115.52,47.85 115.52,48.14 115.63,48.26 115.98,48.26 116.26,48.54 116.26,48.93 115.98,49.21 115.63,49.21 115.52,49.32 115.52,54.98 114.76,55.73 114.76,64.17 114.86,64.27 114.86,67.49 114.61,67.74 114.34,67.74 v2(114.17,67.91)
  BOTTOM w0.089: 113.76,69.18 113.76,69.2 113.73,69.22 113.73,70.8 114,71.07 114,72.6 113.97,72.68 113.97,72.88 114,72.96 114,73.29 114.14,73.43 CPU1.BA38
  BOTTOM w0.127: DM1.135 105.85,35.69 106.14,35.4 106.36,35.4 v2(106.6,35.17) ; 113.76,69.18 113.76,68.88 113.62,68.74 113.62,67.76 113.72,67.67 113.93,67.67 v2(114.17,67.91)
M_A_DQS_DN5: length 56.7
  TOP w0.127: v2(112.06,33.01) 111.83,33.01 v1(111.56,33.28)
  L3 w0.114: v2(117.92,66.53) 118.57,65.88 118.57,60.71 121.81,57.46 121.81,56.59 121.65,56.43 121.65,52.88 121.76,52.77 122.14,52.77 122.42,52.49 122.42,52.09 122.14,51.81 121.76,51.81 121.65,51.7 121.65,51.41 121.76,51.29 122.1,51.29 122.38,51.01 122.38,50.62 122.1,50.34 121.76,50.34 121.65,50.23 121.65,49.93 121.76,49.82 122.1,49.82 122.38,49.54 122.38,49.14 122.1,48.87 121.76,48.87 121.65,48.75 121.65,48.46 121.76,48.35 122.04,48.35 122.32,48.07 122.32,47.67 122.04,47.39 121.76,47.39 121.65,47.28 121.65,46.35 112.27,36.97 112.27,34.65 111.53,33.92 111.53,33.32 111.84,33.01 v2(112.06,33.01)
  BOTTOM w0.089: 117.46,70.35 117.46,70.38 117.44,70.4 117.44,70.84 116.98,71.29 116.98,72.53 117.03,72.68 117.03,72.88 116.97,73.08 116.97,73.41 CPU1.AY34
  BOTTOM w0.127: DM1.152 110.95,32.43 111.4,32.88 111.94,32.88 v2(112.06,33.01) ; v2(117.92,66.53) 117.75,66.36 117.59,66.36 117.26,66.69 117.26,68.74 117.46,68.94 117.46,70.35
M_A_DQS_DN6: length 60.9
  TOP w0.127: v2(117.4,35.42) 117.18,35.42 v1(116.88,35.13)
  L3 w0.114: v2(117.4,35.42) 117.69,35.72 117.76,35.72 118.07,36.03 118.07,37.07 123.39,42.39 125.8,42.39 126.1,42.68 126.26,42.68 126.41,42.53 126.75,42.53 127.08,42.87 127.08,43.21 126.93,43.36 126.93,43.52 129.23,45.81 129.23,49.76 128.37,50.62 128.37,51.04 128.49,51.15 128.93,51.15 129.21,51.43 129.21,51.83 128.93,52.11 128.47,52.11 128.32,52.26 128.32,52.48 128.47,52.63 128.94,52.63 129.22,52.91 129.22,53.3 128.94,53.58 128.47,53.58 128.32,53.73 128.32,53.95 128.47,54.1 128.93,54.1 129.21,54.38 129.21,54.78 128.93,55.06 128.47,55.06 128.32,55.2 128.32,55.43 128.47,55.58 128.87,55.58 129.15,55.85 129.15,56.25 128.87,56.53 128.49,56.53 128.37,56.64 128.37,57.01 128.37,57.19 124.51,61.05 123.41,61.05 121.76,62.7 121.76,63.46 v2(121.16,64.07)
  BOTTOM w0.089: 119.97,70.11 119.97,70.13 119.99,70.16 119.99,70.56 119.43,71.12 119.43,72.56 119.48,72.71 119.48,72.85 119.41,73.05 119.41,73.23 CPU1.BA30
  BOTTOM w0.127: 119.97,70.11 119.97,65.12 120.52,64.57 121.64,64.57 121.82,64.39 121.82,64 121.67,63.85 121.37,63.85 v2(121.16,64.07) ; DM1.169 116.05,36.2 116.71,35.54 117.28,35.54 v2(117.4,35.42)
M_A_DQS_DN7: length 62
  TOP w0.127: v1(121.14,33.03) 121.53,32.64 v2(121.83,32.64)
  L3 w0.114: v2(123.73,64.09) 123.83,64.2 127.84,64.2 133.78,58.26 133.78,56.12 133.39,55.73 133.39,42.09 129.79,38.48 129.79,38.14 129.92,38.01 129.92,37.85 129.71,37.64 129.55,37.64 129.42,37.77 127.88,37.77 127.47,37.36 123.8,37.36 123.38,36.94 123.38,34.61 122.59,33.82 122.59,33.4 v2(121.83,32.64)
  BOTTOM w0.089: CPU1.AY26 121.66,73.94 121.3,73.58 121.3,73.33 121.35,73.23 121.46,73.13 121.67,73.13 121.79,72.97 121.79,72.97 121.81,72.92 121.84,72.83 121.84,72.83 121.83,72.71 121.81,72.65 121.78,72.54 121.78,72.35 121.82,72.22 121.86,72.08 121.86,72.05 121.86,70.61 122.23,70.24 122.23,70.2 122.25,70.19
  BOTTOM w0.127: v2(123.73,64.09) 123.55,64.27 122.99,64.27 122.52,64.74 122.52,69.92 122.25,70.19 ; v2(121.83,32.64) 121.22,32.02 121.22,30.93 121.15,30.87 DM1.186
M_A_DQS_DP0: length 77.3
  TOP w0.127: v1(65.56,33.72) 65.86,33.42 v2(66.04,33.42)
  L3 w0.114: v2(66.04,33.42) 65.96,33.35 65.66,33.35 65.46,33.54 65.46,34.47 66.28,35.28 66.28,38.79 65.97,39.1 65.97,41.58 66.12,41.73 66.34,41.73 66.49,41.58 66.49,39.76 66.77,39.48 67.17,39.48 67.44,39.76 67.44,61.83 84.66,79.05 89.86,79.05 90.14,78.77 90.14,78.61 v2(90.05,78.52)
  BOTTOM w0.089: 92.9,78.13 92.92,78.13 92.95,78.16 94.64,78.16 94.7,78.22 95.16,78.22 95.31,78.17 95.5,78.17 95.71,78.23 96.04,78.23 96.18,78.33 96.24,78.39 96.58,78.39 96.71,78.52 CPU1.AM69
  BOTTOM w0.127: DM1.12 66.55,31.37 66.81,31.64 66.81,32.96 66.56,33.22 66.24,33.22 v2(66.04,33.42) ; v2(90.05,78.52) 90.26,78.31 90.26,78.12 90.53,77.84 92.43,77.84 92.71,78.13 92.9,78.13
M_A_DQS_DP1: length 64
  TOP w0.127: v1(71.38,36.36) 71.67,36.07 v2(71.93,36.07)
  L3 w0.114: v2(71.93,36.07) 71.93,35.73 71.81,35.61 71.53,35.61 71.41,35.73 71.41,37.23 71.93,37.75 71.93,56.35 74.25,58.67 74.25,59.01 73.96,59.3 73.96,59.52 74.11,59.67 74.32,59.67 74.62,59.38 74.96,59.38 75.29,59.71 75.29,60.05 75.02,60.33 75.02,60.54 75.17,60.69 75.39,60.69 75.66,60.42 76,60.42 76.34,60.76 76.34,61.1 76.08,61.36 76.08,61.56 84.32,69.8 84.32,71.5 87.5,74.68 90.06,74.68 90.48,75.1 90.99,75.1 91.08,75.19 91.08,75.47 91.21,75.6 91.46,75.6 v2(91.49,75.58)
  BOTTOM w0.089: CPU1.AT70 96.06,76.15 95.97,76.06 95.68,76.06 95.48,76 95.34,76 95.19,76.04 94.7,76.04 93.81,75.15 91.42,75.15 91.34,75.23 91.34,75.44 v2(91.49,75.58)
  BOTTOM w0.127: DM1.29 71.65,37.17 71.56,37.08 71.36,37.08 71.28,37 71.28,35.77 71.43,35.62 71.99,35.62 72.08,35.71 72.08,35.91 v2(71.93,36.07)
M_A_DQS_DP2: length 60
  TOP w0.127: v1(77.19,34.56) 76.92,34.82 v2(76.66,34.82)
  L3 w0.114: v2(93.64,65.8) 91.41,65.8 90.02,64.41 86.14,64.41 82.53,60.8 82.53,59.17 82.32,58.97 82.16,58.97 82,59.13 81.6,59.13 81.32,58.85 81.32,58.46 81.48,58.29 81.48,58.13 76.44,53.09 76.44,37.26 75.93,36.75 75.93,35.29 76.2,35.03 76.46,35.03 v2(76.66,34.82)
  BOTTOM w0.089: CPU1.AY64 99.26,73.94 99.26,73.6 99.12,73.41 99.12,73.08 99.06,72.88 99.06,72.68 99.11,72.53 99.11,72.18 98.95,72.02 98.95,71.48 97.63,70.17 96.69,70.17 96.57,70.05 96.2,70.05 96.18,70.07 96.16,70.07
  BOTTOM w0.127: v2(93.64,65.8) 94.4,65.8 94.79,66.19 94.79,69.25 95.62,70.07 96.16,70.07 ; v2(76.66,34.82) 76.89,35.05 77.07,35.05 77.44,35.41 77.44,36.76 77.05,37.15 DM1.47
M_A_DQS_DP3: length 57.8
  TOP w0.127: v1(81.4,33.08) 81.16,32.84 v2(80.88,32.84)
  L3 w0.114: v2(99.4,67.87) 99.4,67.8 99.04,67.44 98.95,67.44 98.38,66.87 98.38,65.23 97.84,64.69 96.59,64.69 94.3,62.4 93.95,62.4 91.78,60.23 90.03,60.23 81.1,51.29 81.1,49.7 81.85,48.95 81.85,37.43 81.85,37.43 81.85,32.93 81.39,32.47 81.12,32.47 80.88,32.7 v2(80.88,32.84)
  BOTTOM w0.089: 102.05,71.91 102.05,71.93 102.08,71.96 102.08,72.56 102.13,72.71 102.13,72.85 102.06,73.05 102.06,73.23 CPU1.BA60
  BOTTOM w0.127: 102.05,71.91 102.05,71.34 99.9,69.18 99.9,67.72 99.79,67.62 99.65,67.62 v2(99.4,67.87) ; v2(80.88,32.84) 80.88,32.72 81.21,32.39 81.46,32.39 81.96,31.89 81.96,31.12 82.15,30.93 DM1.64
M_A_DQS_DP4: length 50.1
  TOP w0.127: v2(106.62,35.83) 106.64,35.83 v1(107.03,36.21)
  L3 w0.114: v2(106.62,35.83) 106.7,35.74 106.95,35.74 107.04,35.84 107.04,37.35 107.93,38.25 107.93,38.89 115.3,46.27 115.3,46.76 115.54,47 115.86,47 116.01,47.15 116.01,47.37 115.86,47.52 115.54,47.52 115.3,47.76 115.3,48.23 115.54,48.47 115.89,48.47 116.05,48.63 116.05,48.84 115.89,48.99 115.54,48.99 115.3,49.24 115.3,54.89 114.55,55.64 114.55,64.26 114.65,64.36 114.65,67.4 114.52,67.53 114.34,67.53 114.17,67.36 v2(114.17,67.26)
  BOTTOM w0.089: CPU1.AY38 113.83,73.68 113.83,73.18 113.83,73.01 113.79,72.92 113.79,72.64 113.83,72.56 113.83,71.14 113.56,70.87 113.56,69.22 113.53,69.2 113.53,69.18
  BOTTOM w0.127: v2(106.62,35.83) 106.42,35.63 106.23,35.63 106.08,35.78 106.08,37.07 106.17,37.16 106.32,37.16 106.45,37.29 DM1.137 ; 113.53,69.18 113.53,68.97 113.4,68.84 113.4,67.66 113.62,67.44 114,67.44 v2(114.17,67.26)
M_A_DQS_DP5: length 56.7
  TOP w0.127: v1(111.58,31.94) 111.9,32.26 v2(112.06,32.26)
  L3 w0.114: v2(117.92,65.88) 118,65.96 118.19,65.96 118.35,65.79 118.35,60.62 121.6,57.38 121.6,56.68 121.43,56.52 121.43,52.79 121.67,52.55 122.05,52.55 122.2,52.4 122.2,52.18 122.05,52.03 121.67,52.03 121.43,51.79 121.43,51.32 121.67,51.08 122.02,51.08 122.17,50.92 122.17,50.71 122.02,50.56 121.67,50.56 121.43,50.32 121.43,49.84 121.67,49.6 122.01,49.6 122.16,49.45 122.16,49.23 122.01,49.08 121.67,49.08 121.43,48.84 121.43,48.37 121.67,48.13 121.95,48.13 122.11,47.98 122.11,47.76 121.95,47.61 121.67,47.61 121.43,47.37 121.43,46.44 112.05,37.06 112.05,34.74 111.32,34.01 111.32,33.23 111.62,32.92 111.62,32.71 v2(112.06,32.26)
  BOTTOM w0.089: CPU1.BA34 116.79,73.23 116.79,73.05 116.85,72.85 116.85,72.71 116.8,72.56 116.8,71.22 117.26,70.76 117.26,70.4 117.23,70.38 117.23,70.35
  BOTTOM w0.127: v2(112.06,32.26) 112.06,32.39 111.79,32.65 111.5,32.65 111.18,32.34 111.18,31.14 111.55,30.77 DM1.154 ; 117.23,70.35 117.23,69.03 117.04,68.84 117.04,66.59 117.5,66.13 117.67,66.13 v2(117.92,65.88)
