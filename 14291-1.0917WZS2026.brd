# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D54: length 43.2
  TOP w0.178: v2(185.57,155.76) 185.57,156.54 v1(185.57,156.55) ; VRAM4.C2 174.35,165.93 174.16,165.74 172.11,165.74 172,165.63 171.05,165.63 170.74,165.32 v2(170.74,165.08)
  L3 w0.165: v2(185.57,155.76) 185.66,155.76 185.88,155.54 185.88,154.65 185.77,154.54 182.71,154.54 180.4,156.85 179.46,156.85 179.36,156.74 179.36,156.22 178.84,155.7 175.03,155.7 174.91,155.82 174.91,156.16 175.03,156.27 178.59,156.27 178.71,156.4 178.71,156.72 178.59,156.85 173.93,156.85 173.93,156.84 173.6,156.84 170.74,159.7 v2(170.74,165.08)
  BOTTOM w0.178: v2(185.57,155.76) 185.95,155.38 186.55,155.38 187.89,154.04 187.89,153.07 188.39,152.57 GPU1.W26
FBA_D55: length 43.4
  TOP w0.178: v1(184.84,154.97) 184.84,154.97 v2(184.84,155.76) ; VRAM4.A2 172.75,166.11 172.66,166.02 171.29,166.02 171.18,165.9 170.79,165.9 v2(170.73,165.97)
  L3 w0.165: v2(170.73,165.97) 170.96,165.97 171.09,165.84 171.09,165.35 171.18,165.25 171.18,164.87 171.25,164.81 171.25,164.49 171.01,164.25 171.01,163.86 171.14,163.72 171.65,163.72 171.83,163.55 171.83,163.24 171.65,163.06 171.13,163.06 171.01,162.94 171.01,162.53 171.13,162.4 171.51,162.4 171.7,162.21 171.7,162.12 171.7,161.94 171.51,161.74 171.22,161.74 171.14,161.66 171.14,161.17 171.22,161.08 171.54,161.08 174.38,158.24 174.38,158.06 174.15,157.84 173.97,157.84 171.53,160.28 171.35,160.28 171.14,160.07 171.14,159.87 173.76,157.24 180.56,157.24 180.84,156.96 180.84,156.97 182.97,154.84 185.31,154.84 185.44,154.96 185.44,155.26 185.31,155.39 185.04,155.39 184.91,155.51 184.91,155.69 v2(184.84,155.76)
  BOTTOM w0.178: GPU1.Y25 187.68,151.88 187.4,151.88 187.33,151.95 187.33,152.65 187.61,152.93 187.61,153.85 186.38,155.08 185.52,155.08 v2(184.84,155.76)
FBA_D56: length 45.4
  BOTTOM w0.178: GPU1.R26 192.16,152.57 192.29,152.7 192.29,153.75 192.17,153.87 192.17,153.88 192.15,153.9 192.15,154.46 192.15,155.35 192.15,155.35 192.15,155.59 192.41,155.86 193.21,155.86 193.37,156.01 193.37,156.95 193.49,157.08 194.89,157.08 195.04,156.93 195.04,156.06 195.27,155.83 195.75,155.83 195.88,155.96 195.88,156.87 196.01,157 196.64,157 196.79,156.85 196.79,156.06 196.95,155.91 197.35,155.91 197.51,156.06 197.51,158.58 197.29,158.79 v1(196.62,158.79) 193.12,158.79 191.92,160 189.56,160 189.5,160.05 189.48,160.05 187.7,161.83 178.28,161.83 178.13,161.68 178.13,161.37 177.85,161.09 177.04,161.09 174.65,163.48 174.04,163.48 173.55,163.96 173.55,164.2 173.92,164.56 173.92,165.22 173.92,166.2 174.04,166.32 174.22,166.32 174.35,166.2 VRAM2.C8
FBA_D57: length 44
  BOTTOM w0.178: VRAM2.A7 172.41,166.58 172.41,166.58 171.7,165.87 171.7,164.34 173.37,162.67 174.31,162.67 176.82,160.16 178.21,160.16 179.06,161.02 v1(180.48,161.02) 182.29,161.02 182.47,160.84 182.47,159.87 182.75,159.59 186.84,159.59 186.96,159.72 186.96,160.18 186.84,160.3 183.66,160.3 183.54,160.43 183.54,160.89 183.66,161.02 187.19,161.02 188.14,160.07 188.14,159.81 187.89,159.56 187.89,159.31 188.14,159.05 188.39,159.05 188.65,159.31 188.9,159.31 189.15,159.06 189.15,158.81 188.89,158.55 188.89,158.3 189.14,158.05 189.4,158.05 189.65,158.3 189.9,158.3 190.15,158.05 190.15,157.8 189.9,157.55 189.9,157.29 190.15,157.04 190.4,157.04 190.66,157.3 190.91,157.3 191.16,157.05 191.16,155.58 191.33,155.4 191.33,153.69 191.49,153.53 191.49,152.15 GPU1.T25
FBA_D58: length 43.8
  BOTTOM w0.178: GPU1.N27 193.59,153.69 192.91,154.37 192.64,154.37 192.43,154.59 192.43,155.23 192.69,155.49 193.59,155.49 193.77,155.67 193.77,156.47 193.95,156.65 194.51,156.65 194.64,156.52 194.64,156.06 194.69,156.01 194.69,155.78 194.91,155.55 197.73,155.55 197.91,155.73 v1(197.91,156.48) 197.91,159.03 197.71,159.24 197.46,159.24 197.28,159.41 197.28,160.28 197.11,160.46 196.75,160.46 196.57,160.28 196.57,159.41 196.4,159.24 193.26,159.24 192.1,160.41 189.73,160.41 187.9,162.23 176.5,162.23 174.76,163.98 174.76,166.8 174.91,166.95 175.12,166.95 VRAM2.D7
FBA_D59: length 44.1
  BOTTOM w0.178: GPU1.R27 191.91,153.61 191.89,153.63 191.89,153.75 191.87,153.78 191.87,156.14 192.02,156.29 192.81,156.29 192.96,156.44 192.96,157.38 193.11,157.54 196.97,157.54 197.1,157.66 197.1,158.25 196.97,158.37 192.43,158.37 192.25,158.2 192.25,157.15 192.07,156.98 191.76,156.98 191.59,157.15 191.59,159.34 191.41,159.52 191.05,159.52 190.87,159.34 190.87,158.75 190.69,158.58 190.34,158.58 190.16,158.75 190.16,159.34 189.98,159.52 189.43,159.52 187.52,161.42 v1(185.59,161.42) 178.76,161.42 178.02,160.68 176.87,160.68 174.47,163.09 173.66,163.09 173.04,163.7 173.04,164.29 172.88,164.45 172.88,164.91 173.16,165.18 173.16,165.92 173.35,166.12 VRAM2.B8
FBA_D60: length 42.8
  BOTTOM w0.178: GPU1.V26 189.43,152.81 189.05,153.19 189.05,153.55 189.28,153.78 189.43,153.78 189.63,153.98 189.63,154.25 186.76,157.12 v1(181.1,157.12) 176.63,157.12 173.72,160.04 173.54,160.04 173.22,159.71 173.22,159.53 174.82,157.93 174.82,157.68 174.57,157.43 174.31,157.43 172.99,158.75 172.08,158.75 168.6,162.23 168.6,167.81 170.06,169.27 171.9,169.27 172.65,170.02 172.65,170.02 VRAM2.A3
FBA_D61: length 41.6
  BOTTOM w0.178: GPU1.V27 189.45,153.37 189.91,153.83 189.91,154.55 186.9,157.56 183.4,157.56 v1(183.39,157.56) 183.39,157.56 176.78,157.56 173.48,160.86 172.57,160.86 172.14,161.29 171.89,161.29 171.64,161.03 171.64,160.78 172.76,159.66 172.76,159.49 172.44,159.16 172.26,159.16 169.01,162.41 169.01,167.39 169.24,167.62 170.35,167.62 170.61,167.87 170.61,168.46 171.02,168.87 172.31,168.87 172.71,169.27 173.5,169.27 VRAM2.C3
FBA_D62: length 41.5
  BOTTOM w0.178: VRAM2.A2 171.9,170.92 170.71,169.73 169.92,169.73 168.19,168 168.19,162.06 168.55,161.7 168.55,161.45 168.39,161.28 168.39,161.1 168.71,160.78 168.89,160.78 169.06,160.94 169.31,160.94 169.56,160.69 169.56,160.44 169.39,160.28 169.39,160.1 169.72,159.77 169.9,159.77 170.06,159.94 170.31,159.94 170.56,159.69 170.56,159.43 170.4,159.27 170.4,159.09 170.72,158.77 170.9,158.77 171.07,158.93 171.32,158.93 171.9,158.35 172.79,158.35 172.96,158.18 172.96,157.93 172.34,157.3 172.34,157.15 172.69,156.8 172.84,156.8 173.47,157.42 173.72,157.42 174.24,156.9 174.95,156.9 175.13,157.08 175.13,157.33 175.31,157.51 175.66,157.51 175.84,157.33 175.84,157.08 176.22,156.7 v1(184.6,156.7) 186.61,156.7 188.63,154.68 GPU1.W27
FBA_D63: length 41.7
  BOTTOM w0.178: VRAM2.C2 173.93,171.34 172.6,171.34 172.46,171.2 171.78,171.2 170.91,170.34 169.95,170.34 167.79,168.18 167.79,161.12 172.66,156.24 v1(176.36,156.24) 186.48,156.24 188.17,154.55 188.17,153.29 188.47,152.99 188.75,152.99 189.01,152.73 189.01,152.15 GPU1.W25
FBA_DEBUG0: length 1.3
  TOP w0.102: v2(199.79,148.92) 199.71,149 R7501.1
  BOTTOM w0.102: v2(199.79,148.92) 199.44,149.27 GPU1.F22
FBA_DEBUG1: length 2.2
  TOP w0.102: R7503.1 197.28,147.3 v1(197.28,148.2) v2(197.28,148.9)
  BOTTOM w0.102: v2(197.28,148.9) 197.26,148.94 GPU1.J22
FBA_DQM0: length 37.5
  TOP w0.178: v1(201.94,146.71) 201.64,146.4 v2(201.46,146.4) ; v2(204.41,168.93) 204.41,167.72 204.55,167.58 VRAM3.E7
  L3 w0.165: v2(201.46,146.4) 204.01,148.95 204.67,148.95 207.57,151.84 207.71,151.84 208.3,152.43 208.3,159.76 204.87,163.19 204.87,163.37 205.09,163.6 205.27,163.6 207.19,161.68 207.42,161.68 207.6,161.85 207.6,162.08 204.95,164.72 204.95,165.06 205.56,165.67 205.56,166.64 204.98,167.22 204.98,168.35 v2(204.41,168.93)
  BOTTOM w0.178: GPU1.D19 201.08,146.79 v2(201.46,146.4)
FBA_DQM1: length 48.2
  TOP w0.178: v2(206.31,169.52) 206.3,169.51 205.96,169.51 VRAM3.D3 ; v1(202.35,144.66) 202.35,143.94 v2(201.48,143.08)
  L4 w0.165: v2(206.31,169.52) 206.66,169.52 206.83,169.68 206.83,170.17 206.66,170.34 206.12,170.34 205.71,169.93 205.71,168.86 206.88,167.7 209.34,167.7 214.88,162.16 214.88,151.76 214.47,151.35 214.47,150.99 212.49,149.01 212.49,146.87 209.65,144.02 207.26,144.02 206.86,143.62 204.18,143.62 203.96,143.84 202.25,143.84 v2(201.48,143.08)
  BOTTOM w0.178: GPU1.D14 201.07,142.67 201.43,143.03 201.44,143.03 v2(201.48,143.08)
FBA_DQM2: length 44.1
  L4 w0.165: v2(203.25,168.65) 203.64,168.65 204.08,168.22 204.49,168.22 204.59,168.11 204.59,167.57 204.31,167.29 204.01,167.29 203.86,167.14 203.86,165.71 204.52,165.05 204.52,164.72 206.06,163.18 208.57,163.18 211.08,160.67 211.08,152.06 208.06,149.04 206.92,149.04 206.75,148.87 206.75,148.54 206.92,148.38 207.75,148.38 207.92,148.21 207.92,147.86 207.72,147.65 v2(207.31,147.65)
  BOTTOM w0.178: VRAM1.E7 204.43,170.12 204.29,169.98 204.29,169.7 204.71,169.27 205.2,169.27 205.33,169.14 205.33,168.61 204.9,168.18 203.71,168.18 v2(203.25,168.65) ; v2(207.31,147.65) 207.21,147.76 207.21,148.01 207.03,148.19 206.67,148.19 206.5,148.01 v1(206.5,147.94) 206.5,147.25 206.46,147.21 206.45,147.21 206.37,147.13 206.18,147.13 205.59,146.54 205.2,146.15 205.2,146.02 204.17,144.99 203.35,144.99 202.74,145.6 201.96,145.6 201.85,145.49 GPU1.C17
FBA_DQM3: length 48.7
  BOTTOM w0.102: GPU1.C22 202.23,149.65 203.97,149.65 204.45,150.13
  BOTTOM w0.178: 204.45,150.13 206.21,151.9 206.75,151.9 v1(207.21,152.35) 214.74,159.88 214.74,164.92 214.56,165.1 211.32,165.1 211.15,165.28 211.15,165.63 211.32,165.81 214.56,165.81 214.74,165.99 214.74,166.36 214.57,166.53 212.31,166.53 212.29,166.5 211.83,166.5 211.81,166.53 209.24,166.53 209.06,166.7 209.06,167.06 209.24,167.24 210.99,167.24 211.15,167.39 211.15,167.8 210.99,167.95 206.62,167.95 206.34,168.23 206.34,168.3 206.17,168.48 205.61,168.48 205.43,168.3 205.43,168.3 205.43,168.08 205.43,168.08 205.25,167.9 204.44,167.9 204.26,167.72 204.26,167.47 204.44,167.29 205.17,167.29 205.35,167.11 VRAM1.D3
FBA_DQM4: length 46.1
  TOP w0.178: v2(192.36,150.56) 192.39,150.56 v1(192.78,150.17)
  L3 w0.165: v2(192.36,150.56) 192.36,150.75 191.22,151.89 191.22,153.11 190.92,153.4 190.92,157.86 190.79,157.99 190.48,157.99 190.35,157.86 190.35,152.87 190.22,152.74 189.91,152.74 189.78,152.87 189.78,157.89 189.65,158.02 186.4,158.02 186.08,158.34 186.08,158.34 184.07,160.35 182.79,160.35 182.06,161.08 181.54,161.08 181.38,161.25 181.38,161.29 181.21,161.45 180.97,161.45 180.81,161.29 180.81,161.25 180.64,161.08 180.4,161.08 180.24,161.25 180.24,161.29 180.07,161.45 179.83,161.45 179.67,161.29 179.67,161.25 179.5,161.08 179.26,161.08 179.09,161.25 179.09,161.29 178.93,161.45 178.69,161.45 178.52,161.29 178.52,161.25 178.36,161.08 177.47,161.08 175.66,162.88 175.66,164.11 175.08,164.7 175.08,168.3 v2(175.58,168.8)
  BOTTOM w0.178: v2(192.36,150.56) 192.75,150.94 GPU1.P24 ; VRAM2.E7 175.95,168.44 v2(175.58,168.8)
FBA_DQM5: length 47
  TOP w0.178: v1(187.13,151.9) 187.35,151.68 v2(187.35,151.38) ; VRAM4.E7 175.95,169.39 v2(175.92,169.36)
  L4 w0.165: v2(175.92,169.36) 176.54,168.74 176.54,168.03 175.97,167.46 175.97,164.7 175.62,164.35 175.28,164.35 175.05,164.58 175.05,164.89 174.76,165.17 174.46,165.17 174.33,165.3 174.33,165.79 174.14,165.98 173.87,165.98 173.67,165.79 173.67,165.36 173.48,165.17 173.21,165.17 173.04,165.34 171.98,165.34 169.92,163.28 169.92,159.27 177.23,151.96 177.43,151.96 177.52,152.05 177.52,152.43 177.71,152.62 177.98,152.62 178.18,152.43 178.18,152.12 178.34,151.96 181.56,151.96 181.72,152.13 181.72,152.81 181.89,152.97 182.22,152.97 182.38,152.81 182.38,152.13 182.55,151.96 184.09,151.96 184.42,152.29 184.42,153.37 184.67,153.63 185.22,153.63 185.51,153.34 185.51,153.14 185.74,152.92 186,152.92 186.67,152.25 186.67,152.06 v2(187.35,151.38)
  BOTTOM w0.178: GPU1.W24 188.25,150.59 187.63,150.59 187.35,150.87 v2(187.35,151.38)
FBA_DQM6: length 44.1
  TOP w0.178: v1(185.74,153.11) 185.69,153.16 185.69,153.92 v2(185.7,153.93) ; VRAM4.D3 175.15,167.32 173.93,168.54 171.57,168.54 171.39,168.36 v2(171.37,168.36)
  L3 w0.165: v2(171.37,168.36) 171.18,168.17 171.18,167.38 170.25,166.45 170.25,166.22 170.25,159.64 173.59,156.3 173.83,156.3 173.98,156.45 174.09,156.45 174.28,156.45 174.46,156.27 174.46,156 174.29,155.83 174.29,155.6 174.63,155.26 178.96,155.26 179.98,156.28 180.41,156.28 180.85,155.84 181.03,155.84 182.71,154.16 182.71,152.69 182.84,152.56 183.15,152.56 183.28,152.69 183.28,154.08 183.44,154.25 183.69,154.25 183.85,154.08 183.85,152.94 183.98,152.81 184.3,152.81 184.42,152.94 184.42,154.08 184.59,154.25 184.97,154.25 185.11,154.1 185.11,153.56 185.23,153.44 185.65,153.44 185.76,153.56 185.76,153.86 v2(185.7,153.93)
  BOTTOM w0.178: GPU1.AA25 186.95,151.77 186.88,151.69 186.61,151.69 186.53,151.77 186.53,153.58 186.18,153.93 v2(185.7,153.93)
FBA_DQM7: length 43.9
  BOTTOM w0.178: GPU1.U25 190.27,151.54 190.16,151.44 189.99,151.44 189.83,151.59 189.83,153.22 190.19,153.57 190.19,154.9 188.69,156.4 188.69,156.42 187.08,158.03 v1(184.55,158.03) 176.94,158.03 173.6,161.37 172.69,161.37 170.65,163.41 170.47,163.41 170.14,163.09 170.14,162.91 171.39,161.67 171.39,161.42 171.14,161.16 170.88,161.16 169.46,162.58 169.46,166.5 170.2,167.24 170.56,167.24 171.23,167.91 171.55,167.91 172.22,168.58 172.46,168.58 172.78,168.91 173.62,168.91 174.44,169.73 174.49,169.73 174.89,170.12 VRAM2.D3
FBA_DQS_RN0: length 36.1
  TOP w0.152: v2(203.29,169.58) 203.36,169.65 203.36,169.82 203.06,170.12 VRAM3.G3
  L3 w0.127: v2(199.84,147.16) 200.19,146.82 200.8,146.82 201.07,147.08 201.47,147.08 203.9,149.52 204.53,149.52 205.99,150.98 205.99,154.96 206.26,155.23 206.72,155.23 206.98,154.96 206.98,152.75 207.11,152.62 207.39,152.62 207.52,152.75 207.52,155.54 207.27,155.79 207.27,159.58 204.21,162.65 204.21,167.14 204.26,167.19 204.26,167.96 203.7,168.52 203.7,168.9 203.29,169.32 v2(203.29,169.58)
  BOTTOM w0.152: v2(199.84,147.16) 199.47,146.79 GPU1.F19
FBA_DQS_RN1: length 45.1
  TOP w0.152: VRAM3.B7 206.85,167.02 206.85,167.81 v2(207.44,168.39)
  L4 w0.127: v2(207.44,168.39) 207.65,168.18 208.31,168.18 208.44,168.31 208.44,168.78 208.7,169.04 209.14,169.04 209.4,168.78 209.4,168.31 209.53,168.18 209.99,168.18 215.66,162.52 215.66,151.43 215.25,151.03 215.25,149.88 213.35,147.98 213.35,146.62 209.95,143.22 207.44,143.22 207.21,142.98 204.44,142.98 204.13,142.67 204.13,142.14 203.8,141.81 203.38,141.81 202.57,142.63 202.38,142.63 202.24,142.48 v2(202.24,142.27)
  BOTTOM w0.152: v2(202.24,142.27) 201.85,142.66 GPU1.C14
FBA_DQS_RN2: length 38.8
  L4 w0.127: v2(203.23,167.99) 203.37,167.85 203.37,165.46 204.02,164.82 204.02,163.73 204.34,163.4 204.61,163.4 204.79,163.59 204.97,163.59 205.15,163.41 205.15,163.23 205,163.07 205,162.8 205.64,162.16 205.99,162.16 206.25,162.42 206.25,162.56 206.38,162.69 206.63,162.69 206.76,162.56 206.76,162.42 207.02,162.16 207.46,162.16 207.72,162.42 207.72,162.56 207.85,162.69 208.1,162.69 208.23,162.56 208.23,162.42 210.3,160.34 210.3,152.39 207.75,149.84 206.91,149.84 206.17,149.1 206.17,148.37 206.61,147.93 206.61,147.27 207.04,146.84 207.4,146.84 207.56,146.68 207.56,146.25 207.4,146.08 206.98,146.08 206.92,146.02 206.45,146.02 v2(206.27,146.2)
  BOTTOM w0.152: GPU1.A16 203.58,144.18 204.17,144.18 205.84,145.85 206.09,145.85 206.27,146.03 v2(206.27,146.2) v1(206.86,146.2) ; v2(203.23,167.99) 203.23,167.99 203.13,167.89 203.13,167.68 203.31,167.51 203.31,166.89 203.24,166.81 203.06,166.81 VRAM1.G3
FBA_DQS_RN3: length 42.3
  BOTTOM w0.152: VRAM1.B7 206.59,170.48 206,170.48 205.71,170.18 205.71,169.97 205.61,169.88 205.61,169.12 205.91,168.82 206.58,168.82 206.6,168.84 207.61,168.84 207.93,168.52 211.58,168.52 211.73,168.37 211.73,167.43 212.06,167.1 212.54,167.1 212.87,167.43 212.87,168.37 213.02,168.52 213.33,168.52 213.48,168.37 213.48,167.43 213.81,167.1 214.29,167.1 214.62,167.43 214.62,168.37 214.78,168.52 215.12,168.52 215.31,168.33 215.31,165.45 ; 215.31,165.45 v1(215.08,165.45) ; 215.31,165.45 215.31,159.62 206.91,151.22 206.08,151.22 204.14,149.27 GPU1.A22
FBA_DQS_RN4: length 44.9
  TOP w0.152: v1(192.11,152.73) 192.33,152.51 v2(192.33,152.12)
  L3 w0.127: v2(192.33,152.12) 192.22,152.01 192.06,152.01 191.9,152.17 191.9,152.39 192.25,152.74 192.25,153.45 191.99,153.71 191.81,153.71 191.69,153.84 191.69,154.17 191.81,154.29 193.56,154.29 193.8,154.54 193.8,158.67 193.54,158.93 192.67,158.93 192.41,158.67 192.41,155.51 192.28,155.38 191.83,155.38 191.7,155.51 191.7,158.59 191.44,158.85 186.68,158.85 186.4,159.13 183.86,161.67 183.62,161.67 182.61,161.67 182.04,162.24 177.74,162.24 176.27,163.7 176.27,166.69 175.66,167.31 175.66,167.74 176.72,168.8 176.94,168.8 177.33,169.19 v2(177.45,169.19)
  BOTTOM w0.152: GPU1.P25 192.64,151.77 192.33,152.08 v2(192.33,152.12) ; v2(177.45,169.19) 177.42,169.19 177.16,169.45 177.16,169.88 177.4,170.12 VRAM2.G3
FBA_DQS_RN5: length 46.3
  TOP w0.152: VRAM4.G3 177.52,166.92 177.36,167.07 177.36,167.46 177.41,167.5 177.47,167.56 v2(177.71,167.56)
  L4 w0.127: v2(177.71,167.56) 177.55,167.56 177.28,167.3 177.28,167.17 176.46,166.35 176.46,164.5 175.84,163.87 175.02,163.87 174.51,164.38 174.16,164.38 172.81,163.03 172.05,163.03 171.79,163.29 171.79,163.94 171.64,164.09 171.43,164.09 171.28,163.94 171.28,163.29 170.7,162.71 170.7,159.6 176.88,153.42 179.4,153.42 179.69,153.13 179.69,152.92 179.84,152.77 180.05,152.77 180.2,152.92 180.2,153.71 180.64,154.15 182.79,154.15 183.05,153.89 183.05,152.59 183.2,152.44 183.41,152.44 183.56,152.59 183.56,153.89 183.82,154.15 184.74,154.15 185.17,154.58 185.99,154.58 186.32,154.25 186.32,154.25 186.53,154.04 186.53,153.67 186.34,153.48 186.34,153.3 186.52,153.12 186.7,153.12 186.89,153.31 187.26,153.31 187.75,152.82 187.75,151.92 188.12,151.54 188.12,150.61 v2(188.98,149.75)
  BOTTOM w0.152: v2(188.98,149.75) 188.63,149.4 GPU1.W22
FBA_DQS_RN6: length 42.1
  TOP w0.152: v2(170.24,168.79) 170.24,168.61 170.33,168.52 170.53,168.52 171.26,169.25 173.43,169.25 173.97,169.79 173.97,170.02 173.87,170.12 VRAM4.B7 ; v2(181.21,154.88) v1(181.21,155.46)
  L3 w0.127: v2(181.21,154.88) 181.21,154.88 180.99,155.1 180.99,155.38 180.77,155.6 180.08,155.6 179.51,155.03 179.51,154.77 179.45,154.71 179.19,154.71 174.4,154.71 174.04,155.07 173.67,155.07 173.28,154.68 173.06,154.68 172.9,154.84 172.9,155.06 173.29,155.45 173.29,155.82 172.96,156.15 172.59,156.15 172.2,155.75 171.98,155.75 171.82,155.91 171.82,156.13 172.23,156.54 172.23,156.88 171.84,157.27 171.56,157.27 171.17,156.88 170.95,156.88 170.79,157.04 170.79,157.26 171.14,157.6 171.14,157.97 170.76,158.34 170.47,158.34 170.1,157.97 169.88,157.97 169.72,158.12 169.72,158.34 170.08,158.71 170.08,159.02 169.7,159.41 169.7,166.45 170.82,167.58 170.82,168.38 170.69,168.52 170.69,168.52 170.42,168.79 v2(170.24,168.79)
  BOTTOM w0.152: GPU1.AB27 186.15,153.13 186.08,153.06 185.93,153.06 184.35,154.64 181.28,154.64 181.21,154.71 v2(181.21,154.88)
FBA_DQS_RN7: length 43
  BOTTOM w0.102: 190.92,154.46 190.92,154.43 190.89,154.4 190.89,153.88 190.64,153.64 190.64,153.07 190.79,152.92 191.13,152.92 191.2,152.99 191.2,153.28 GPU1.T27
  BOTTOM w0.152: 190.92,154.46 190.92,155.41 187.32,159.01 181.97,159.01 181.81,159.16 181.81,160.03 181.48,160.37 181.01,160.37 180.67,160.03 180.67,159.16 180.52,159.01 180.21,159.01 180.06,159.16 180.06,160.01 179.73,160.34 179.25,160.34 178.92,160.01 178.92,159.16 178.77,159.01 178.18,159.01 ; 178.18,159.01 v1(178.18,159.21) ; 178.18,159.01 177.16,159.01 173.96,162.21 173.17,162.21 170.76,164.62 170.56,164.62 170.28,164.9 170.28,166.15 170.56,166.43 171.27,166.43 171.5,166.65 171.5,167.05 171.65,167.2 172.47,167.2 172.91,167.64 172.91,168.1 173.17,168.37 175.02,168.37 175.25,168.13 175.25,167.79 175.13,167.67 174.33,167.67 173.99,167.33 173.99,166.92 173.9,166.83 173.61,166.83 173.55,166.89 VRAM2.B7
FBA_EDC0: length 36.1
  TOP w0.152: VRAM3.F3 203.75,169.56 v2(203.93,169.38)
  L3 w0.127: v2(203.93,169.38) 203.93,168.61 204.49,168.05 204.49,167.1 204.43,167.04 204.43,162.74 207.5,159.68 207.5,155.89 207.75,155.64 207.75,152.65 207.49,152.39 207.02,152.39 206.76,152.65 206.76,154.87 206.63,155 206.35,155 206.22,154.87 206.22,150.88 204.63,149.29 204,149.29 201.57,146.86 201.16,146.86 200.9,146.59 200.03,146.59 v2(199.81,146.38)
  BOTTOM w0.152: GPU1.E19 200.23,146.79 v2(199.81,146.38)
FBA_EDC1: length 45.2
  TOP w0.152: VRAM3.C7 206.41,166.92 206.59,167.1 206.59,167.92 206.8,168.14 v2(206.8,168.41)
  L4 w0.127: v2(202.26,143.09) 202.43,143.09 203.47,142.04 203.71,142.04 203.91,142.24 203.91,142.77 204.35,143.21 207.11,143.21 207.35,143.44 209.86,143.44 213.13,146.71 213.13,148.07 215.03,149.97 215.03,151.12 215.43,151.53 215.43,162.42 209.89,167.95 209.44,167.95 209.18,168.22 209.18,168.68 209.05,168.81 208.79,168.81 208.67,168.68 208.67,168.22 208.41,167.95 207.26,167.95 v2(206.8,168.41)
  BOTTOM w0.152: v2(202.26,143.09) 202.07,143.09 201.85,143.31 GPU1.C15
FBA_EDC2: length 38.4
  L4 w0.127: v2(203.8,167.69) 203.78,167.69 203.6,167.51 203.6,165.56 204.24,164.91 204.24,163.82 204.43,163.63 204.52,163.63 204.7,163.82 205.07,163.82 205.38,163.5 205.38,163.13 205.23,162.98 205.23,162.89 205.74,162.38 205.89,162.38 206.02,162.51 206.02,162.65 206.28,162.92 206.73,162.92 206.99,162.65 206.99,162.51 207.11,162.38 207.37,162.38 207.49,162.51 207.49,162.65 207.75,162.92 208.2,162.92 208.46,162.65 208.46,162.51 210.53,160.44 210.53,152.3 207.84,149.61 207,149.61 206.4,149.01 206.4,148.47 206.84,148.02 206.84,147.36 207.13,147.07 207.49,147.07 207.79,146.77 207.79,146.15 207.49,145.85 207.08,145.85 207.02,145.79 206.58,145.79 v2(206.21,145.42)
  BOTTOM w0.152: VRAM1.F3 203.58,167.09 203.58,167.54 203.73,167.69 v2(203.8,167.69) ; GPU1.B16 202.92,144.31 203.31,143.92 204.28,143.92 205.89,145.52 206.11,145.52 206.21,145.42 v2(206.21,145.42)
FBA_EDC3: length 42.2
  BOTTOM w0.152: 206.7,150.95 206.2,150.95 204.14,148.9 203.2,148.9 202.83,149.27 GPU1.B22 ; 206.7,150.95 207.02,150.95 215.58,159.51 215.58,168.44 215.23,168.79 214.67,168.79 214.36,168.48 214.36,167.54 214.18,167.37 213.93,167.37 213.75,167.54 213.75,168.48 213.44,168.79 212.91,168.79 212.6,168.48 212.6,167.54 212.43,167.37 212.17,167.37 211.99,167.54 211.99,168.48 211.69,168.79 208.04,168.79 207.72,169.11 206.49,169.11 206.47,169.09 206.02,169.09 205.88,169.23 205.88,169.76 206.15,170.04 VRAM1.C7 ; 206.7,150.95 v1(206.7,150.76)
FBA_EDC4: length 44.1
  L3 w0.127: v2(192.34,151.4) 191.67,152.07 191.67,152.49 192.02,152.84 192.02,153.35 191.9,153.48 191.72,153.48 191.46,153.74 191.46,154.26 191.72,154.52 193.46,154.52 193.57,154.63 193.57,158.58 193.45,158.71 192.77,158.71 192.64,158.58 192.64,155.41 192.38,155.15 191.74,155.15 191.47,155.41 191.47,158.49 191.35,158.62 186.59,158.62 186.31,158.9 183.77,161.44 183.71,161.44 183.71,161.44 182.52,161.44 181.95,162.01 177.65,162.01 176.05,163.61 176.05,166.6 175.43,167.21 175.43,167.83 176.76,169.17 v2(176.76,169.22)
  BOTTOM w0.152: v2(192.34,151.4) 192.34,151.46 192.04,151.77 GPU1.R25 ; VRAM2.F3 176.89,169.98 176.89,169.35 v2(176.76,169.22)
FBA_EDC5: length 47
  TOP w0.152: v1(188.31,150.37) 188.31,149.8 v2(188.27,149.76) ; v2(177.05,167.97) 177.1,167.92 177.1,167.27 177.09,167.26 176.75,166.92 VRAM4.F3
  L4 w0.127: v2(188.27,149.76) 188.27,150.14 187.89,150.52 187.89,151.45 187.52,151.82 187.52,152.73 187.17,153.08 186.99,153.08 186.8,152.89 186.43,152.89 186.11,153.2 186.11,153.57 186.3,153.76 186.3,153.94 185.89,154.35 185.27,154.35 184.83,153.92 183.92,153.92 183.79,153.8 183.79,152.49 183.51,152.21 183.11,152.21 182.83,152.49 182.83,153.8 182.7,153.92 180.73,153.92 180.43,153.62 180.43,152.83 180.14,152.54 179.74,152.54 179.46,152.83 179.46,153.03 179.3,153.19 176.78,153.19 170.47,159.5 170.47,162.81 171.05,163.39 171.05,164.03 171.33,164.32 171.73,164.32 172.01,164.03 172.01,163.39 172.14,163.26 172.72,163.26 174.06,164.61 174.6,164.61 175.11,164.1 175.74,164.1 176.23,164.59 176.23,166.44 177.06,167.27 177.06,167.96 v2(177.05,167.97)
  BOTTOM w0.152: GPU1.W23 188.63,150.12 v2(188.27,149.76)
FBA_EDC6: length 42.3
  TOP w0.152: v2(170.16,168.07) 170.16,168.07 170.45,168.07 171.03,168.64 171.03,168.64 171.37,168.98 173.54,168.98 174.24,169.68 174.24,170.01 174.35,170.12 VRAM4.C7 ; v2(180.57,154.89) v1(179.97,154.89)
  L3 w0.127: v2(180.57,154.89) 180.61,154.89 180.76,155.03 180.76,155.29 180.68,155.37 180.17,155.37 179.74,154.94 179.74,154.68 179.55,154.48 179.28,154.48 174.3,154.48 173.94,154.84 173.76,154.84 173.38,154.45 172.97,154.45 172.68,154.74 172.68,155.15 173.06,155.54 173.06,155.72 172.87,155.92 172.69,155.92 172.29,155.53 171.88,155.52 171.59,155.82 171.59,156.23 172,156.64 172,156.78 171.74,157.04 171.65,157.04 171.26,156.65 170.85,156.65 170.56,156.94 170.56,157.35 170.91,157.7 170.91,157.88 170.67,158.11 170.57,158.11 170.19,157.74 169.78,157.74 169.49,158.03 169.49,158.44 169.85,158.8 169.85,158.93 169.47,159.32 169.47,166.55 170.59,167.67 170.59,168.18 170.49,168.29 170.38,168.29 v2(170.16,168.07)
  BOTTOM w0.152: v2(180.57,154.89) 180.57,154.88 181.08,154.37 184.24,154.37 185.34,153.28 185.82,152.79 185.82,152.79 185.9,152.72 186,152.72 186.15,152.57 GPU1.AB26
FBA_EDC7: length 43.2
  BOTTOM w0.102: 190.65,154.46 190.65,154.44 190.68,154.41 190.68,153.96 190.44,153.72 190.44,152.99 190.71,152.72 190.96,152.72 GPU1.T26
  BOTTOM w0.152: 182.43,158.74 v1(182.43,158.61) ; 182.43,158.74 187.21,158.74 190.65,155.3 190.65,154.46 ; 182.43,158.74 181.86,158.74 181.55,159.05 181.55,159.92 181.37,160.1 181.12,160.1 180.94,159.92 180.94,159.05 180.63,158.74 180.1,158.74 179.79,159.05 179.79,159.9 179.62,160.08 179.36,160.08 179.19,159.9 179.19,159.05 178.88,158.74 177.05,158.74 173.85,161.94 173.06,161.94 170.65,164.36 170.45,164.36 170.01,164.79 170.01,166.26 170.45,166.69 171.16,166.69 171.23,166.76 171.23,167.16 171.54,167.47 172.36,167.47 172.64,167.75 172.64,168.21 173.06,168.64 175.13,168.64 175.52,168.24 175.52,167.68 175.24,167.4 174.44,167.4 174.26,167.22 174.26,167.01 VRAM2.C7
FBA_PLL_AVDD: length 3.4
  TOP w0.508: C7506.1 199.13,144.05 v2(198.99,143.91)
  BOTTOM w0.356: v2(193.18,148.91) 192.91,149.18 192.91,149.19 192.77,149.33 GPU1.P22 192.38,148.96 v2(192.32,148.96) ; v2(198.99,143.91) 199.01,143.94 199.03,143.94 GPU1.F16 ; v2(198.17,148.9) 198.07,148.94 198.07,148.94 197.71,149.3 GPU1.H22
  vias: v1(193.16,148.35) v2(193.99,148.91)
FBA_VREF_0: length 32.1
  TOP w0.229: VRAM3.M8 199.35,165.72 199.35,164.85
  TOP w0.356: VRAM3.H1 202.15,171.94 201.73,172.35
  TOP w0.381: 199.35,164.85 198.72,164.22 v2(198.62,164.22)
  TOP w0.508: v2(198.86,173.19) 199.12,172.93 201.16,172.93 201.73,172.35
  L4 w0.254: v2(198.86,173.19) 198.27,173.78 196.84,173.78 196.55,173.5 196.55,172.64 196.93,172.26 196.93,169.92 197.71,169.14 197.78,169.07 197.78,168.86 198.13,168.52 198.13,166.26 199.06,165.33 199.06,164.66 v2(198.62,164.22)
  BOTTOM w0.203: v2(198.86,173.19) 199.33,172.72 199.33,171.3 VRAM1.M8
  BOTTOM w0.254: R7807.1 v1(199.88,159.73)
  BOTTOM w0.305: v2(198.62,164.22) 198.67,164.22 199.29,164.84 201.67,164.84 VRAM1.H1
  BOTTOM w0.508: v2(198.62,164.22) 198.62,163.82 199.88,162.55 C7803.1 R7807.1 199.84,160.67 R7806.2
FBA_VREF_1: length 34.9
  TOP w0.203: v2(181.99,173.13) 181.79,172.93 181.79,172.28 181.87,172.2 181.87,172.19 181.96,172.1 181.96,171.33 VRAM4.M8
  TOP w0.305: v2(178.59,164.4) 178.61,164.41 178.61,165.06 VRAM4.H1
  TOP w0.508: v2(178.59,164.4) 178.62,164.37 178.62,163.27 v1(179.2,162.69) C7902.1
  L3 w0.254: v2(181.99,173.13) 181.82,172.96 181.82,172.01 178.17,168.36 178.17,167.91 178.35,167.73 178.35,167.42 178.73,167.04 178.95,167.04 179.25,166.74 179.25,166.19 178.62,165.56 178.62,164.43 v2(178.59,164.4)
  L4 w0.508: v2(181.99,173.13) 181.99,173.81 181.11,174.69 178.63,174.69 178.27,174.34 178.27,173.24 v2(178.32,173.19)
  BOTTOM w0.203: 181.71,164.13 182.13,164.55 182.13,164.96 181.95,165.14 181.95,165.72 VRAM2.M8
  BOTTOM w0.356: 178.35,172.29 VRAM2.H1
  BOTTOM w0.508: v2(178.59,164.4) 178.59,164.04 178.88,163.76 180.47,163.76 180.84,164.13 181.71,164.13 ; R7904.1 179,175.67 R7903.2 178.23,175.66 178.23,173.89 178.32,173.79 v2(178.32,173.19) 178.35,173.16 178.35,172.29
FBA_ZQ0: length 6.9
  TOP w0.229: 200.16,165.15 200.16,165.49 199.75,165.89 VRAM3.L8
  TOP w0.254: v1(203.28,160.95) 202.67,161.57 R7808.2 200.16,163.64 200.16,165.15
FBA_ZQ1: length 6.1
  TOP w0.254: v2(199.87,174.7) 199.91,174.74 199.91,175.49 R7809.2 v1(198.82,175.67)
  BOTTOM w0.203: 200.13,172.84 200.13,171.51 199.75,171.13 VRAM1.L8
  BOTTOM w0.254: v2(199.87,174.7) 199.87,174.65 199.75,174.53 199.75,173.64 200.13,173.25 200.13,172.84
FBA_ZQ2: length 5.9
  TOP w0.254: v2(180.11,164.59) 181.14,163.56 v1(181.14,162.62) R7912.2
  BOTTOM w0.229: VRAM2.L8 181.14,165.73 181.14,165.16 180.91,164.93 180.9,164.93 180.57,164.59 v2(180.11,164.59)
FBA_ZQ3: length 5.4
  TOP w0.203: 181.17,173.5 181.17,172.9 181,172.73 180.77,172.73 180.37,172.32 180.37,171.53 180.75,171.15 VRAM4.L8
  TOP w0.254: 181.17,173.5 181.17,173.8 181.38,174.01 v1(181.38,174.6) R7913.2
FFS_INT2: length 54
  L3 w0.152: v2(138.79,82.23) 141.33,82.23 141.48,82.09 144.18,82.09 144.32,82.22 146.23,82.22 146.47,81.98 147.79,81.98 148,82.19 150.82,82.19 151.25,82.62 157.44,82.62 158.63,83.81 162.93,83.81 163.81,82.93 166.14,82.93 167.15,83.94 168.71,83.94 169.78,85 171.79,85 v2(172,85.22)
  BOTTOM w0.089: 137.7,82.42 136.36,82.42 136.03,82.75 135.62,82.75 135.46,82.68 135.01,82.68 CPU1.AC2
  BOTTOM w0.114: 137.7,82.42 138.42,82.42 138.42,82.41 138.6,82.41 v2(138.79,82.23)
  BOTTOM w0.152: U6701.11 171.69,92.63 171.95,92.37 171.95,91.77 171.69,91.51 171.69,91.03 R6704.2 R6707.1 R6706.1 173.77,90.14 174.25,90.62 Q6701.5 175.16,90.62 175.46,90.32 175.46,89.34 174.85,88.74 174.7,88.74 174.7,88.73 173.16,88.73 172.54,88.11 v1(172.54,86.31) 172.54,85.76 v2(172,85.22)
FFS_INT2_Q: length 85
  L3 w0.152: v2(182.08,91.4) 182.08,91.42 180.37,93.13 177.4,93.13 176.49,92.22 176.47,92.22 176.41,92.16 176.03,92.16 175.97,92.22 175.82,92.22 v2(175.71,92.33)
  L4 w0.152: v2(182.08,91.4) 182.08,87.18 183.72,85.54 184.25,85.54 185.06,86.35 185.58,86.35 186.26,85.67 186.26,82.84 186.11,82.7 186.11,75.19 186.17,75.14 186.17,74.72 186.55,74.34 186.55,71.55 187.25,70.85 187.25,68.76 187.22,68.73 187.22,66.41 187.68,65.95 187.68,61.76 187.17,61.24 187.17,58.16 186.09,57.08 186.09,54.12 186.24,53.97 186.24,53.57 185.84,53.17 185.84,44.06 187.08,42.82 187.08,30.55 v2(186.05,29.53)
  BOTTOM w0.152: v2(175.71,92.33) 174.82,92.33 R6705.2 173.48,92.48 R6706.2 173.94,91.03 174.18,91.27 Q6701.6 ; v2(182.08,91.4) 182.08,91.15 v1(181.82,90.89) ; v2(186.05,29.53) 186.81,29.53 187.31,29.02 HDD1.11
FON#: length 3.3
  BOTTOM w0.254: R2605.2 92.21,141.81 v1(93.06,141.81) 93.48,141.39 93.48,140.73 FAN261.1
FP_PWR: length 20
  TOP w0.254: FPR1.6 174.86,136.24 AFTP8902.1 174.42,134.98 173.97,134.53 173.97,132.1 174.05,132.02 v2(174.05,131.05) ; C9201.1 C9202.1 181.56,125.4 R9201.2 180.62,125.36 R9202.1 179.6,125.52 179.6,126.57 v2(179.62,126.58)
  L3 w0.254: v2(179.62,126.58) 179.59,126.56 176.03,126.56 174.05,128.54 v2(174.05,131.05)
GC6_FB_EN: length 155.6
  TOP w0.127: v2(147.55,67.25) 147.55,66.25 R2004.1 ; v2(151.18,42.19) 151.18,40.79 D8301.1 ; R7623.1 201.39,135.79 R7519.2 201.43,135.75 201.43,134.32 201.26,134.16 201.26,133.76 200.58,133.08 200.58,129.66 199.12,128.2 198.01,128.2 196.82,127.01 196.82,126.63 196.04,125.85 195.02,125.85 195.02,125.85 194.21,125.85 193.53,125.17 192.88,125.17 192.49,125.57 192.49,125.78 192.16,126.1 190.61,126.1 190.06,125.56 188.17,125.56 187.29,124.68 185.42,124.68 183.55,122.8 183.55,121.94 181.89,120.28 181.89,117.22 179.3,114.63 178.69,114.63 177.6,113.54 177.6,112.75 175.51,110.66 174.28,110.66 171.42,107.8 v1(169.9,107.8) v2(168.06,107.8)
  L3 w0.127: v2(168.31,67.64) 168.31,67.96 167.81,68.45 167.81,69.19 167.35,69.65 164.93,69.65 164.66,69.39 162.14,69.39 160.77,68.01 160.77,67.14 160.19,66.56 159.12,66.56 158.59,67.1 147.7,67.1 v2(147.55,67.25)
  L4 w0.127: v2(151.18,42.19) 151.18,48.94 149.88,50.24 149.88,51.21 151.24,52.57 151.24,56.28 154.6,59.64 154.6,62.35 152.26,64.68 150.02,64.68 149.13,65.57 149.13,65.66 v2(147.55,67.25) ; v2(168.06,107.8) 166.74,106.47 166.74,104.95 166.46,104.67 166.46,104.05 166.52,103.99 166.52,103.54 166.46,103.48 166.46,101.63 166.46,101.63 166.46,96.92 166.47,96.91 166.47,93.78 166.46,93.76 166.46,92.59 167.55,91.49 167.55,90.54 167.71,90.38 167.71,89.72 167.26,89.27 167.26,87.35 167.26,87.15 167.26,87.15 167.26,87.12 167.71,86.68 167.71,85.75 168.54,84.92 168.54,84.36 168.53,84.35 168.53,83.9 168.63,83.8 168.63,82.36 168.48,82.2 168.48,78.92 168.25,78.69 168.25,78.06 168.25,77.62 168.25,77.62 168.25,77.52 168.63,77.14 168.63,77.13 168.73,77.03 168.73,76.41 168.23,75.9 168.23,74.63 168.68,74.18 168.68,73.76 168.94,73.5 168.94,72.24 168.33,71.63 168.33,69.98 168.3,69.95 168.3,68.88 168.16,68.74 168.16,68.38 168.31,68.23 v2(168.31,67.64)
GC6_FB_EN_GPU: length 3.1
  TOP w0.127: R7623.2 202.01,136.61 R7627.1 202.29,135.68 v2(202.26,135.65) 202.26,135.33 v1(201.85,134.92)
  BOTTOM w0.127: GPU1.C6 201.85,136.06 v2(202.26,135.65)
GC6_FB_EN_MCP: length 20.8
  TOP w0.127: v2(132.59,77.85) 135.22,75.23 v1(136.62,75.23) 136.88,75.23 138.4,73.71 138.4,71.16 141.28,68.28 141.33,68.28 142.77,66.84 145.56,66.84 R2004.2
  BOTTOM w0.127: CPU1.AP7 132.27,77.52 v2(132.59,77.85)
GPD2/LAN_WAKE#: length 33.9
  TOP w0.102: v2(149.25,70.62) 149.66,70.21 v1(149.66,69.37) 149.66,68.32 150,67.99 150.57,67.99 150.87,67.69 R1736.2 150.88,67.4 R1707.2
  L3 w0.102: v2(149.25,70.62) 148.22,70.62 148.11,70.74 146.58,70.74 144.12,68.28 141.53,68.28 139.76,70.05 134.63,70.05 133.85,70.82 133.42,70.82 131.57,72.67 131.03,72.67 129,74.7 129,74.96 128.52,75.45 128.52,78.01 v2(128.03,78.5)
  BOTTOM w0.102: v2(128.03,78.5) 127.7,78.82 CPU1.AM15
GPIO5_GC6_PWR_EN: length 70.2
  TOP w0.127: v2(208.82,131.63) 208.36,131.63 207.82,131.09 207.82,130.18 v1(207.44,129.8) 206.27,128.63 205.54,128.63 205.3,128.39 201.31,128.39 198.92,126 197.48,126 196.47,124.99 194.67,124.99 193.7,124.02 193.7,123.5 192.25,122.05 192.23,122.03 189.6,122.03 188.84,121.27 188.46,120.89 188.46,120.89 188.26,120.69 v2(187.88,120.69)
  L3 w0.127: v2(187.88,120.69) 187.88,122.35 186.7,123.53 186.7,124.56 182.77,128.5 180.93,128.5 178.06,131.37 178.06,133.88 175.05,136.89 175.05,138.41 173.9,139.56 167.31,139.56 v2(166.8,139.05)
  BOTTOM w0.127: PQ8307.2 167.27,139.52 v2(166.8,139.05) 166.8,138.35 167.01,138.14 168.97,138.14 169.69,137.42 R8306.2 170.09,135.54 170.91,134.73 U8301.3 ; v2(208.82,131.63) 208.31,131.63 R7636.2
GPIO5_GC6_PWR_EN#: length 4.9
  BOTTOM w0.127: v1(172.17,141.04) 171.71,140.57 PR8319.1 171.18,139.52 PQ8307.5 169.57,139.52 169.46,139.41 169.46,138.98 169.57,138.87 PQ8307.6
GPIO5_GC6_PWR_EN_GPU: length 6.5
  BOTTOM w0.127: R7633.2 207.25,130.95 R7636.1 207.25,131.97 206.83,132.4 v1(206.48,132.4) 205.23,132.4 204.75,131.92 204.14,131.92 203.86,132.2 203.86,133.16 GPU1.A3
GPIO9_ALERT: length 17.5
  BOTTOM w0.127: GPU1.F8 198.94,137.24 198.42,137.24 198.4,137.23 198.4,137.23 198.19,137.02 198.19,135.86 197.97,135.64 197.45,135.64 197.23,135.41 197.23,133.38 197.4,133.2 198.7,133.2 198.93,132.97 198.93,131.68 198.34,131.09 198.09,131.09 197.28,130.28 197.28,128.68 v1(196.2,127.6) 195.94,127.34 R7612.1 194.34,127.34 194.17,127.52 Q7602.1
GPIO10_FBVREF: length 6.4
  BOTTOM w0.127: GPU1.C5 202.32,134.75 203.96,134.75 204.46,134.24 205.96,134.24 v1(206.5,133.7) 207.25,132.95 R7610.1
GPP_B2/VRALERT#: length 3.2
  TOP w0.102: TP1708.1 132.09,79.88 130.8,79.88 130.08,79.16 v2(129.84,79.16)
  BOTTOM w0.102: v2(129.84,79.16) 129.84,79.16 129.83,79.15 129.69,79.15 129.4,78.85 CPU1.AM11
GPP_B4/CPU_GP3: length 6
  TOP w0.102: v2(136.22,70.61) 135.66,70.61 TP404.1
  BOTTOM w0.089: CPU1.AY5 133.06,73.8 133.48,73.39 133.48,72.9 133.66,72.72 133.66,72.25 134.08,71.83 134.08,71.76 134.39,71.45 135.07,71.45
  BOTTOM w0.102: v2(136.22,70.61) 135.95,70.61 135.66,70.9 135.63,70.9 135.07,71.45
GPP_B18/GSPI0_MOSI: length 21.9
  TOP w0.102: R2007.2 148.9,72.32 R2019.1 147.87,73.04 v1(147.81,73.1) 147.13,73.78 v2(147.13,73.87)
  L3 w0.102: v2(147.13,73.87) 147.13,73.97 146.53,74.56 145.92,74.56 145.26,75.23 132.44,75.23 132.2,75.47 131.55,75.47 131.29,75.74 131.29,76.78 131.68,77.17 v2(131.68,77.2)
  BOTTOM w0.102: CPU1.AR7 132,76.87 v2(131.68,77.2)
GPP_B23/SML1ALERT#: length 30.3
  TOP w0.102: v2(132.59,79.15) 133.22,78.52 133.22,78.17 v1(134.58,76.8) 135.76,75.63 137.31,75.63 138.31,74.64 143.59,74.64 146.52,77.56 146.52,79.88 147.27,80.63 149.02,80.63 v2(149.47,81.08)
  BOTTOM w0.102: v2(149.47,81.08) 149.05,80.66 147.66,80.66 146.86,81.46 146.41,81.46 146.06,81.81 146.06,82.68 146.49,83.11 R1820.2 ; v2(132.59,79.15) 132.47,79.15 CPU1.AM7
GPP_C2/SMBALERT#: length 30.4
  TOP w0.102: v2(148.13,90.37) 147.42,89.66 v1(147.11,89.66) 147.07,89.62 138.37,89.62 137.72,88.97 135.62,88.97 133.63,86.97 130.49,86.97 v2(130.08,86.56)
  L4 w0.102: v2(148.13,90.37) 148.26,90.24 148.26,89.98 148.53,89.71 148.53,88.97 148.54,88.96 148.54,84.4 148.24,84.1 146.63,82.5 v2(146.63,82.46)
  BOTTOM w0.102: CPU1.R10 130.08,86.8 v2(130.08,86.56) ; v2(146.63,82.46) 147.14,81.96 R1821.1
GPP_C5/SML0ALERT#: length 15.7
  TOP w0.102: R1823.1 139.88,84.58 v1(138.32,84.58) 136.52,84.58 v2(136.27,84.83)
  L4 w0.102: v2(136.27,84.83) 136.92,85.49 140.71,85.49 141.67,84.52 144.49,84.52 145.3,83.71 v2(145.43,83.71)
  BOTTOM w0.102: v2(145.43,83.71) 145.46,83.74 R1822.2 ; CPU1.W1 136.15,84.94 136.26,84.83 v2(136.27,84.83)
GPP_E0/SATAXPCIE0/SATAGP0: length 5.9
  BOTTOM w0.089: CPU1.H2 134.96,91.13 135.2,91.13 135.29,91.17 135.49,91.17 135.58,91.13 136,91.13 136.08,91.22
  BOTTOM w0.102: 136.08,91.22 136.99,92.12 137.68,92.12 139.32,93.77 TP1601.1
GPP_E1/SATAXPCIE1/SATAGP1: length 5.6
  BOTTOM w0.089: CPU1.H3 134.35,90.65 134.84,90.65 134.93,90.69 135.2,90.69 135.29,90.65 135.49,90.65 135.58,90.69 136.14,90.69 137.2,91.74
  BOTTOM w0.102: TP1602.1 138.98,91.74 137.2,91.74
GPP_E2/SATAXPCIE2/SATAGP2: length 8.7
  BOTTOM w0.089: CPU1.G4 134.02,91.31 135.16,91.31 135.25,91.35 135.52,91.35 135.61,91.31 135.91,91.31 136.34,91.75
  BOTTOM w0.102: 136.34,91.75 136.92,92.33 137.61,92.33 138.93,93.65 138.93,94.06 139.26,94.38 140.13,94.38 TP1603.1
GPP_E3/CPU_GP0: length 8.1
  BOTTOM w0.102: TP403.1 138.67,98.21 138,97.54 136.66,97.54 135.84,96.73 134.14,96.73 132.94,95.52 132.94,94.83 CPU1.A6
GPU_CLKREQ#: length 20.5
  BOTTOM w0.127: Q7301.S 178.26,128.51 176.72,130.05 R7305.2 174.65,130.05 174.51,130.18 174.51,130.97 v1(174.92,131.38) 175.1,131.56 175.58,131.56 175.73,131.41 R7303.1 176.89,131.88 177.71,131.88 178.36,131.23 179.97,131.23 181.91,133.17 182.98,133.17 183.23,133.41 183.23,133.69 183.49,133.95 183.73,133.95 184.03,134.25 184.03,134.45 184.33,134.75 185.33,134.75 185.66,135.07 185.66,135.49 185.25,135.9 GPU1.AC6
GPU_EVENT#: length 145.3
  TOP w0.127: R7648.1 211.55,134.3 211.46,134.21 Q7606.D 210.65,133.17 210.84,132.98 210.84,131.64 R7644.1 207.43,128.22 v1(206.88,128.22) 205.63,128.22 205.54,128.13 201.41,128.13 198.87,125.59 197.43,125.59 196.57,124.73 194.77,124.73 193.95,123.91 193.95,123.39 192.34,121.78 189.71,121.78 189.29,121.36 185.31,117.37 v2(185.31,117.3)
  L3 w0.127: v2(146.19,74.12) 146.89,73.42 147.31,73.42 147.45,73.56 148.92,73.56 149.37,73.11 150.16,73.11 151.08,72.19 154.23,72.19 155.5,73.46 158.44,73.46 159.61,72.29 160.5,72.29 161.97,73.76 168.69,73.76 169.65,72.8 171.01,72.8 171.33,73.11 174.99,73.11 175.79,72.31 175.79,72.02 175.79,72.01 175.79,71.92 176.05,71.66 176.14,71.66 176.23,71.58 180.52,71.58 181.06,72.11 181.81,72.11 182.2,71.72 183.07,71.72 183.3,71.95 184.14,71.95 184.53,71.56 186.69,71.56 187.29,70.96 190.91,70.96 191.58,71.63 193.48,71.63 197.23,75.38 197.23,83.03 196.19,84.07 196.19,86.3 197.23,87.34 197.23,89.86 197.04,90.05 197.04,90.05 192.79,94.3 191.83,94.3 189.12,97.01 189.12,98.38 186.32,101.19 v2(186.22,101.19)
  L4 w0.127: v2(185.31,117.3) 185.31,116.1 186.74,114.67 186.74,101.7 v2(186.22,101.19)
  BOTTOM w0.127: R2003.1 143.87,75.17 145.3,75.17 146.19,74.28 v2(146.19,74.12)
GPU_EVENT_GPU#: length 9
  TOP w0.127: R7644.2 R7649.1 209.5,132.47 Q7606.S 207.61,134.36 v1(207.01,134.36) 206.47,134.36 v2(205.73,133.62)
  BOTTOM w0.127: GPU1.A4 203.88,134.37 205,133.25 205.36,133.25 v2(205.73,133.62)
GPU_EVENT_MCP#: length 15.9
  TOP w0.127: v1(141.73,76.51) v2(141.73,75.88)
  L4 w0.102: v2(131.68,78.5) 132.13,78.05 132.13,75.81 132.43,75.5 133.04,75.5
  L4 w0.127: 133.04,75.5 133.55,76.02 137.62,76.02 138.13,75.5 141.35,75.5 v2(141.73,75.88)
  BOTTOM w0.127: CPU1.AN8 131.36,78.17 v2(131.68,78.5) ; v2(141.73,75.88) 141.94,75.67 142.36,75.67 142.88,75.15 R2003.2
GPU_PEX_RST#: length 29.2
  BOTTOM w0.127: GPU1.AC7 185.25,136.57 185.61,136.22 185.61,136.01 186.09,135.53 186.3,135.53 186.51,135.32 186.51,135.02 186.3,134.81 186.09,134.81 185.67,134.39 185.67,132.24 185.21,131.78 185.21,130.34 185.59,129.97 187.89,129.97 188.76,129.1 191.66,129.1 192.22,128.53 192.22,127.03 192.06,126.87 Q7602.5 190.01,126.87 R7613.1 v1(188.92,126.9) 188.16,126.9 187.83,127.23 R7312.2 187.01,127.67 R7308.1 187,127.32 186.84,127.16 186.14,127.16 185,126.01 183.26,126.01 182.3,125.06 R7313.2
GPU_PEX_RST_D#: length 2.8
  BOTTOM w0.127: v1(186.11,128.71) R7308.2 185.29,126.84 D7301.3
GPU_PEX_RST_HOLD: length 25.9
  TOP w0.127: v2(197.67,127.19) 198.83,127.19 201.18,129.54 201.18,132.81 201.92,133.56 202.6,133.56 R7631.2 203.92,133.05 R7630.2
  BOTTOM w0.127: D7301.1 186.41,124.93 188.75,122.6 193.08,122.6 v1(195.74,125.26) v2(197.67,127.19)
GPU_PEX_RST_HOLD_GPU#: length 2.3
  TOP w0.127: v2(202.26,133.99) v1(202.97,133.99) 203.27,133.99 203.31,133.95 R7630.1
  BOTTOM w0.127: v2(202.26,133.99) 202.23,133.99 GPU1.C4
GPU_PLL_VDD: length 4.8
  TOP w0.508: v1(198.1,133.76) L7601.2 196.7,133.76 196.32,134.15 C7606.1 C7605.1 195.72,135.63 v2(195.64,135.55)
  BOTTOM w0.305: GPU1.L6 195.23,135.96 v2(195.64,135.55)
H_CATERR#: length 6.7
  BOTTOM w0.089: 100.75,96.26 100.67,96.19 100.52,96.19 100.26,95.93 100.26,95.61 100.41,95.46 100.41,95.38 100.42,95.38 100.42,94.93 100.41,94.92 100.38,94.84 100.38,94.68 100.41,94.59 100.41,94.55 100.42,94.54 100.42,94.32 100.39,94.25 100.36,94.12 100.32,93.98 100.33,93.78 100.33,93.64 100.2,93.46 CPU1.D63
  BOTTOM w0.102: 100.75,96.26 100.99,96.5 100.99,98.13 101.37,98.51 TP401.1
H_CPU_SVIDALRT#: length 3.9
  BOTTOM w0.114: 99.69,97.21 99.69,94.92 99.98,94.63 CPU1.B63
  BOTTOM w0.14: R728.2 99.63,97.59 99.69,97.53 99.69,97.21
H_CPU_SVIDCLK: length 5.1
  BOTTOM w0.114: CPU1.A63 99.9,95.17 99.9,96.11 100.03,96.24 100.03,96.69
  BOTTOM w0.14: 100.03,96.69 100.03,97.04 v1(100.33,97.34) 100.46,97.47 100.46,99.23 100.48,99.25 R732.1
H_CPU_SVIDDAT: length 7.8
  BOTTOM w0.114: v1(99.03,97.29) 99.49,96.83 99.49,94.48 99.74,94.23 99.74,94.08 99.63,93.88 99.41,93.66 CPU1.D64
  BOTTOM w0.14: R709.1 98.88,99.66 98.88,98.9 R726.2 98.39,97.92 v1(99.03,97.29)
H_CPUPWRGD: length 12.6
  BOTTOM w0.127: R1710.2 85.92,94.65 EC1710.2 85.99,95.51 87.76,95.51 v1(88.11,95.16) 88.19,95.08 89.94,95.08 90.01,95.01 90.73,95.01 90.82,95.1 91.12,95.1 91.55,95.53 R405.1 91.85,95.33 93.7,95.33 93.79,95.41 93.8,95.41 94.02,95.63 96.3,95.63 CPU1.A68
H_PECI: length 231.2
  TOP w0.14: R2437.2 169.9,68.83 v2(169.5,68.44)
  L3 w0.127: v2(162.85,41.09) 161.43,41.09 160.11,39.77 159,39.77 158.36,40.4 155.02,40.4 153.13,38.52 151.88,38.52 150.62,37.26 148.13,37.26 146.86,38.52 144.22,38.52 v2(144.15,38.44) ; v2(64.38,77.69) 64.38,79.88 65.1,80.6 65.76,80.6 80.92,95.77 86.01,95.77 88.08,97.84 88.9,97.84 90.95,99.89 90.95,102.54 90.74,102.74 90.74,103.2 91.06,103.52 91.34,103.52 92.23,104.41 92.23,105.71 90.95,106.99 90.95,109 v2(91.48,109.53)
  BOTTOM w0.089: 106.92,97.74 106.92,97.31 106.56,96.96 106.23,96.96 105.84,96.56 105.84,96.51 105.57,96.25 105.33,96.25 104.93,95.85 CPU1.A54
  BOTTOM w0.14: v2(169.5,68.44) 170.3,67.64 170.3,66.4 169.59,65.69 169.59,61.85 168.65,60.91 166.82,60.91 165.71,59.8 165.71,59.18 165.31,58.77 165.31,58.03 165.43,57.91 165.43,56.5 165.43,56.5 165.43,52.86 165.43,52.86 165.43,50.2 164.55,49.32 164.55,45.05 163.99,44.49 163.99,42.23 v2(162.85,41.09) ; v2(91.48,109.53) 92.84,108.16 96.65,108.16 97.88,106.93 102.24,106.93 102.91,106.26 106.82,106.26 107.82,105.27 107.82,101.85 107.34,101.37 107.34,100.06 106.92,99.64 106.92,97.74 ; v2(144.15,38.44) 143.87,38.44 143.61,38.19 v1(142.77,38.19) 139.41,38.19 130.65,46.95 130.65,48.7 128.55,50.8 88.47,50.8 64.38,74.9 v2(64.38,77.69)
H_PROCHOT#: length 348.5
  TOP w0.14: PR4455.2 121.22,170.15 120.64,170.72 v2(120.64,170.97) 119.9,171.72 119.9,172.35 118.79,173.46 PQ4303.3 ; v2(161.18,71.94) 161.1,72.03 C2403.1 161.95,72.84 R2416.2 ; v2(121.4,145.37) 121.4,144.96 120.85,144.4 PR4668.2
  L3 w0.127: v2(89.81,101.48) 89.81,101.84 89.54,102.12 89.54,112.1 89.86,112.42 89.86,112.45 95.83,118.42 95.83,122.48 97.74,124.39 97.74,131.27 94.03,134.98 94.03,140.68 94.33,140.98 v2(94.33,141) 94.35,141 96.56,143.21 100.9,143.21 101.22,143.53 102.64,143.53 104.09,144.98 105.96,144.98 108.03,147.05 108.91,147.05 110.11,148.25 112.21,148.25 112.93,147.53 114.76,147.53 115.06,147.83 116.1,147.83 116.69,147.24 118.62,147.24 120.48,145.37 v2(121.4,145.37) ; v2(161.18,71.94) 160.99,71.94 160.76,71.71 159.38,71.71 158.2,72.89 155.73,72.89 154.47,71.62 150.84,71.62 150.51,71.95 149.93,72.53 149.45,72.53 149.14,72.53 148.68,72.99 147.96,72.99 147.82,72.85 146.6,72.85 144.77,74.67 137.75,74.67 v2(137.3,74.23)
  L4 w0.127: v2(143.47,38.87) 143.47,45.53 140.88,48.12 140.88,48.6 141.02,48.74 141.02,53.35 141.51,53.84 141.51,54.76 141.15,55.12 141.15,55.62 141.45,55.92 141.45,59.09 140.25,60.28 140.25,62.44 139.44,63.25 139.44,63.89 139.19,64.14 139.19,65.86 137.86,67.19 136.43,67.19 136.17,67.45 136.17,67.9 136.47,68.2 136.47,69.57 135.3,70.74 135.3,73.75 135.73,74.19 137.26,74.19 v2(137.3,74.23) ; v2(120.64,170.97) 120.6,171.02 120.26,171.35 116.13,171.35 115.94,171.55 115.02,172.47 108.73,172.47 108.25,171.99 107.11,171.99 104.81,169.69 103.62,169.69 102.27,171.04 99.07,171.04 95.77,167.74 v2(95.77,165.57) 95.77,160.75 94.94,159.92 94.94,144.25 94.33,143.64 v2(94.33,141)
  BOTTOM w0.14: v2(95.77,165.57) 96.37,164.97 96.97,164.97 97.87,164.07 97.87,161.16 99.49,159.54 PR4418.1 ; R404.1 90.57,100.72 v2(89.81,101.48) 89.15,102.14 88.09,102.14 84.06,98.11 84.06,91.67 71.87,79.47 71.87,68.24 83.46,56.64 88.15,56.64 93.4,51.39 128.79,51.39 131.24,48.94 131.24,47.19 v1(136.08,42.34) 139.65,38.77 143.37,38.77 v2(143.47,38.87) ; PR4624.2 PR4669.2 121.58,145.19 v2(121.4,145.37)
H_PROCHOT#_EC: length 4.6
  TOP w0.14: Q2408.D 161.95,74.21 R2416.1 162.37,73.73 162.63,73.99 v1(163.44,73.99) 164.38,73.99 R2418.2
H_PROCHOT#_R: length 11.3
  BOTTOM w0.089: 97.58,96.93 97.96,96.55 98.31,96.55 98.76,96.1 98.76,95.42 98.59,95.25 98.59,94.98 98.63,94.89 98.63,94.62 98.59,94.53 98.59,94.33 98.64,94.2 98.64,93.99 CPU1.C65
  BOTTOM w0.14: R403.2 v1(91.66,97.99) 92.3,97.99 92.48,97.81 92.89,97.81 93.67,97.03 97.48,97.03 97.58,96.93
H_PROCHOT#_R_R: length 4.6
  BOTTOM w0.14: R404.2 91.01,99.51 R401.2 90.65,98.9 90.49,99.06 v1(89.72,99.06) 89.26,99.06 89.09,98.9 89.09,98.31 89.41,97.99 R403.1
H_THERMTRIP#: length 108.7
  TOP w0.102: Q4002.E 30.12,54.99 29.63,55.48 29.63,59.79 30.86,61.02 v2(31.11,61.02)
  L3 w0.102: v2(65.28,79.17) 65.35,79.17 79.89,93.72 86.68,93.72 87.46,94.5 87.46,95.57 91.45,99.55 91.45,100.13 93.08,101.75 93.08,106.26 91.48,107.85 v2(91.48,108.77)
  L4 w0.102: v2(30.86,70.59) 31.84,71.58 50.97,71.58 51.35,71.2 51.87,71.2 55.14,74.47 60.09,74.47 64.79,79.17 v2(65.28,79.17)
  BOTTOM w0.102: R420.2 96.39,107.66 92.59,107.66 v2(91.48,108.77) ; v2(31.11,61.02) 30.86,61.27 v1(30.86,69.83) v2(30.86,70.59)
H_THERMTRIP_EN: length 92.8
  TOP w0.102: C4003.1 R4007.2 32.17,55.64 R4003.1 31.75,54.41 30.96,54.41 30.73,54.18 30.73,53.07 Q4002.B 30.78,53.01 31.72,53.01 v2(31.8,53.09)
  L3 w0.102: v2(65.24,80.04) 65.91,80.04 80.42,94.55 86.21,94.55 v2(86.54,94.21)
  L4 w0.102: v2(65.24,80.04) 65.24,79.81 65.15,79.73 64.93,79.73 59.88,74.68 55.06,74.68 51.79,71.41 51.43,71.41 51.02,71.82 49.77,71.82 49.06,72.53 48.59,72.53 47.84,71.78 31.36,71.78 v2(30.14,70.57)
  BOTTOM w0.102: v2(31.8,53.09) 31.8,53.25 32.6,54.05 32.6,57.95 30.65,59.89 30.65,68.05 v1(30.34,68.36) 30.14,68.56 v2(30.14,70.57) ; R1710.1 86.09,93.76 v2(86.54,94.21)
H_VCCST_PWRGD: length 9.1
  BOTTOM w0.089: CPU1.B65 99.12,94.7 99.12,96.28 98.6,96.8
  BOTTOM w0.127: v1(94.52,99.17) 93.95,98.61 R1734.2 94.68,97.5 97.75,97.5 98.22,97.03 98.37,97.03 98.6,96.8
H_VCCST_PWRGD_R: length 6.4
  BOTTOM w0.127: R1734.1 R1719.1 EC1708.1 95.66,99.81 R1722.2 95.85,100.03 R1716.2 95.82,100.86 v1(95.93,100.97) 95.61,101.29 U1701.4
HDA_BITCLK: length 33.1
  BOTTOM w0.089: 124.53,69.46 124.53,69.81 124.45,69.89 124.45,71.58 123.95,72.08 123.95,72.47 123.64,72.78 123.46,72.78 123.29,72.96 123.29,73.49 CPU1.AY22
  BOTTOM w0.14: 124.53,69.46 124.53,67.01 124.61,66.93 v1(124.61,66.17) 124.61,65.39 124.83,65.17 124.83,57.06 126.07,55.83 131.01,50.89 132.57,49.32 132.57,48 134.81,45.76 R1907.2
HDA_CODEC_BITCLK: length 166.2
  TOP w0.14: R2720.1 34.45,16.35 34.82,16.72 35.61,16.72 35.62,16.73 EC2709.1 v2(35.94,16.03)
  L3 w0.127: v2(148.43,11.88) 139.44,2.9 91.8,2.9 89.63,5.06 71.38,5.06 68.2,8.24 54.61,8.24 53.65,9.2 48.33,9.2 47.91,9.62 45.9,9.62 39.53,15.99 36.19,15.99 36.14,16.03 v2(35.94,16.03)
  BOTTOM w0.14: v2(148.43,11.88) 148.67,12.13 148.67,14.63 149.04,15.01 v1(149.04,17.24) 149.04,22.6 147.88,23.76 147.88,35.78 147.38,36.28 147.38,37.45 144.33,40.5 143.23,40.5 142.69,41.04 142.21,41.04 140.85,41.04 136.51,45.37 EC1901.2 R1907.1
HDA_CODEC_RST#: length 171.9
  TOP w0.14: R2721.1 32.91,22.51 v2(33.57,21.85)
  L3 w0.127: v2(150.19,13.99) 147.52,13.99 138.45,4.91 93.02,4.91 90.26,7.68 72.58,7.68 72.26,8 70,10.26 58.92,10.26 57.97,11.22 49.17,11.22 48.75,11.64 47.18,11.64 44.16,14.66 44.16,16.39 43.23,17.32 41.18,17.32 39.59,18.91 38.21,18.91 38,19.12 35.27,21.85 v2(33.57,21.85)
  BOTTOM w0.14: R1911.1 135.69,47.55 EC1902.1 136.51,47.48 137.13,46.85 138.4,46.85 143.67,41.58 144.78,41.58 147.4,38.96 148.52,38.96 148.96,38.52 148.96,24.58 150.12,23.42 v1(150.12,22.52) 150.12,14.14 150.19,14.07 v2(150.19,13.99)
HDA_CODEC_RST#_R: length 5.6
  TOP w0.14: HDA27.11 30.84,17.67 31.16,17.99 31.16,18.17 30.78,18.56 30.78,19.85 31.24,20.32 31.54,20.32 31.86,20.64 31.86,21.11 32.37,21.62 R2721.2
HDA_CODEC_SDIN0: length 4.1
  TOP w0.14: HDA27.8 31.58,16.47 32.1,16.99 v1(32.1,16.99) 32.51,17.39 32.51,17.56 33.44,18.49 R2718.2
HDA_CODEC_SDOUT: length 165.3
  TOP w0.14: EC2708.1 R2719.1 35.23,20.21 v2(34.89,20.56)
  L3 w0.127: v2(34.89,20.56) 35.2,20.56 37.16,18.59 37.62,18.14 37.62,18.13 38.64,17.1 39.91,17.1 46.34,10.67 48.35,10.67 48.77,10.25 57.51,10.25 58.47,9.3 69.6,9.3 71.29,7.6 72.18,6.71 89.86,6.71 92.62,3.95 138.89,3.95 141.92,6.99 147.92,12.98 v2(148.08,12.98)
  BOTTOM w0.14: R1912.1 136.22,44.84 140.6,40.45 142.45,40.45 142.98,39.91 144.09,39.91 146.8,37.21 146.8,36.03 147.3,35.53 147.3,23.38 148.46,22.22 v1(148.46,20.24) 148.46,17.24 147.51,16.29 147.51,14.82 148.08,14.24 v2(148.08,12.98)
