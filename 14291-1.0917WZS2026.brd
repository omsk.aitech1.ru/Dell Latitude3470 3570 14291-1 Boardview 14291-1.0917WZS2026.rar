# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0.85A_VID0: length 1.2
  TOP w0.254: TP2101.1 129.96,78.5 v2(129.85,78.5)
  BOTTOM w0.254: CPU1.AN11 129.72,78.5 v2(129.85,78.5)
V0.85A_VID1: length 2.4
  TOP w0.152: TP2102.1 129.4,78.04 v2(128.94,78.5)
  BOTTOM w0.254: v2(128.94,78.5) 128.81,78.5 CPU1.AN13
V3D3_STB: length 8.6
  TOP w0.203: 26.45,19.98 26.75,19.68 HDA27.20
  TOP w0.305: 26.45,19.98 v1(26.1,20.34) 25.63,20.81 25.14,20.81 24.24,21.7 24.24,23.3 22.49,25.05 R2712.1
VCC1R05VIDEO_PEX_PLLVDD: length 7
  TOP w0.508: L7301.1 C7317.1 184.6,145.57 184.83,145.34 C7319.1 184.83,143.79 C7318.1 184.84,143.77 v1(185.84,143.77) 186.49,143.12 v2(186.49,143.09)
  BOTTOM w0.305: GPU1.AA14 186.89,142.69 v2(186.49,143.09) 186.89,143.49 GPU1.AA15
VCC_CORE: length 4.5
  BOTTOM w0.127: CPU1.A44 110.56,95.71 v2(110.51,95.77)
  BOTTOM w0.203: CPU1.A39 112.73,95.08 112.73,95.86 v2(113.12,96.25) ; v2(118.15,95.29) 118,95.14 CPU1.A30
  BOTTOM w0.254: v2(115.21,95.72) 115.21,95.07 CPU1.A34
  vias: v1(115.23,80.95) v1(116.26,87.71) v1(118.47,94.37) v1(120.76,108.49) v1(121.93,109.03) v1(126.38,108.9) v1(127.55,111.46) v1(128.77,107.72) v2(111.27,89.4) v2(111.28,88.74) v2(111.84,88.31) v2(112.34,89.72) v2(112.46,92.63) v2(112.58,89.04) v2(113.4,80) v2(114.33,91.35) v2(114.3,89.82) v2(114.31,78.5) v2(115.21,91.33) v2(115.22,79.99) v2(115.22,78.55) v2(116.13,91.36) v2(116.15,89.76) v2(116.14,78.5) v2(117.01,80.17) v2(117.02,78.52) v2(117.96,89.78) v3(111.71,84.89) v3(111.77,82.82) v3(112.55,84.89) v3(112.6,86.2) v3(112.6,82.82) v3(114.07,97.46) v3(114.12,96.4) v3(114.43,82.82) v3(114.94,97.46) v3(115.28,96.55) v3(115.27,82.82) v3(115.43,84.89) v3(115.59,86.2) v3(115.82,97.48) v3(116.22,96.57) v3(116.71,97.5) v3(121,120.56) v3(121.71,116.06) v3(121.66,114.9) v3(121.66,113.56) v3(122.1,112.44) v3(122.65,116.39) v3(123.13,112.38) v3(123.52,116.41) v3(124.06,112.35) v3(124.44,116.39) v3(125.61,116.52) v3(125.66,115.67) v3(125.66,114.78) v3(125.67,113.93) v3(125.84,119.12) v3(125.84,118.23) v3(125.84,117.35) v3(125.86,113.1) v3(126.31,119.87) v3(126.61,115.68) v3(126.61,114.79) v3(126.68,113.95) v3(126.77,113.1) v3(126.85,119.12) v3(126.85,118.23) v3(126.85,117.35) v3(127.39,119.84) v3(127.64,116.52) v3(127.62,115.68) v3(127.62,114.79) v3(127.62,113.81) v3(127.87,119.12) v3(127.87,118.23) v3(127.87,117.35)
VCC_OPC_1P8_H63: length 4.9
  TOP w0.102: v2(101.51,91.38) 101.51,91.38 TP708.1 ; v2(101.43,89.71) 101.41,89.73 TP704.1
  BOTTOM w0.102: v2(101.51,91.38) 101.18,91.06 CPU1.G61 101.05,90.61 101.39,90.27 101.39,89.75 ; 101.39,89.75 100.85,89.75 100.13,90.47 CPU1.H63 ; 101.39,89.75 v2(101.43,89.71)
VCC_SENSE: length 110.3
  TOP w0.14: PR4648.1 122.46,139.62 128.47,139.62 130,141.14 142.47,141.14 144.74,138.87 148.51,138.87 153.01,134.37 153.01,129.18 154.51,127.69 155.85,127.69 ; 155.85,127.69 v1(155.85,127.51) ; 155.85,127.69 156.83,127.69 157.61,126.91 157.61,124.69 154.55,121.63 154.55,119.02 153.81,118.27 150.2,118.27 140.61,108.68 140.61,107.77 v2(140.37,107.53) ; R719.2 117.32,92.32 v2(117.01,92.01)
  L4 w0.127: v2(140.37,107.53) 140.14,107.76 139.45,107.76 139.31,107.62 130.36,107.62 128.6,105.85 126.93,105.85 125.29,104.21 125.29,102.59 124.37,101.67 122.88,101.67 122.37,101.16 120.53,101.16 117.65,98.29 117.65,92.65 v2(117.01,92.01)
  BOTTOM w0.14: v2(117.01,92.01) 117.36,92.36 CPU1.E32
VCCGT_SENSE: length 92.3
  TOP w0.14: v2(99.66,146.45) 99.89,146.22 100.3,146.22 100.78,146.7 100.78,147.24 101.55,148.01 104.79,148.01 PR4617.1
  L3 w0.127: v2(99.66,146.45) 99.28,146.07 99.08,146.07 98.44,146.71 96.35,146.71 91.55,141.92 91.55,133.84 94.94,130.46 94.94,127.31 94.28,126.65 94.28,124.08 94.89,123.47 94.89,118.78 87.9,111.79 87.9,101.45 88.48,100.87 88.96,100.87 89.09,100.74 v2(89.09,100.48)
  BOTTOM w0.089: CPU1.J70 95.74,90.12 95.64,90.03 95.47,90.03 95.1,89.91 94.03,89.91 93.4,89.28 93.4,89.01 93.36,88.97 93.36,88.95
  BOTTOM w0.14: 85.22,92.46 85.22,97.38 88.69,100.85 88.99,100.85 89.09,100.75 v2(89.09,100.48) ; 85.22,92.46 v1(85.36,92.46) ; 85.22,92.46 85.22,89.77 86.54,88.46 86.54,87.23 86.97,86.8 87.33,86.8 87.61,87.08 R721.2 88.08,87.08 88.3,86.86 88.9,86.86 89.8,87.76 92.37,87.76 93.36,88.76 93.36,88.95
VCCIO_VR_FB: length 2.2
  TOP w0.254: R733.2 120.93,79.09 v1(121.18,78.85) 121.53,78.5 v2(121.63,78.5)
  BOTTOM w0.254: CPU1.AM23 121.95,78.82 v2(121.63,78.5)
VCCPRIM_CORE:
  vias: v1(151.58,119.21)
VCCRTCEXT: length 12.5
  BOTTOM w0.114: CPU1.BB10 130.15,71.89 130.16,71.89 130.41,71.64 130.41,70.81 131.8,69.42 v1(131.8,69.05) 131.8,68.4
  BOTTOM w0.254: 131.8,68.4 132.24,67.96 133.94,67.96 135.05,66.85 135.4,66.85 136.14,66.11 136.14,65.92 136.43,65.63 136.65,65.63 C2112.1
VCCSA_SENSE: length 124
  TOP w0.254: PR4607.1 111.47,153.27 112.06,153.86 119,153.86 120.07,152.8 129.69,152.8 v1(135.24,147.25) 137.96,144.52 143.52,144.52 144.5,143.54 146.56,143.54 v2(147.22,142.89)
  L3 w0.254: v2(147.22,142.89) 148.11,142.89 148.17,142.83 148.92,142.83 149.62,142.13 149.62,141.4 151.47,139.55 151.47,138.93 153.67,136.73 153.67,135.18 153.43,134.94 153.43,127.63 153.62,127.44 153.62,124.07 155.36,122.32 155.36,117.58 144.09,106.31 140.78,106.31 140.53,106.05 133.76,106.05 v2(131.66,103.96)
  L4 w0.254: v2(124.37,90.73) 124.29,90.73 123.55,91.47 123.35,91.47 122.7,92.12 122.7,93.33 120.61,95.41 120.61,97.17 122.3,98.86 v2(122.79,98.86) 124.73,98.86 127.51,101.64 129.34,101.64 v2(131.66,103.96)
  BOTTOM w0.254: v2(124.37,90.73) 124.69,90.41 CPU1.H20 ; R735.2 122.43,98.49 v2(122.79,98.86)
VCCSTG_EN: length 24.4
  L3 w0.127: v2(155.03,130.41) 155.05,130.41 155.37,130.1 155.37,129.94 158.29,127.02 159.4,127.02 163.26,123.15 163.26,122.51 163.75,122.02 v2(164.32,122.02)
  BOTTOM w0.127: R4019.1 151.04,130.1 v1(150.73,130.41) ; R4019.1 151.65,129.3 R4022.2 151.72,129.35 U4003.4 154.08,130.41 v2(155.03,130.41) ; R4019.1 152.5,130.95 153.14,130.95 R4012.1 ; R4008.2 165.84,121.66 165.49,122.02 v2(164.32,122.02)
VCCSTG_EN_D: length 3.6
  BOTTOM w0.127: v1(165.33,116.89) 165.05,117.17 D4004.A 165.84,119.32 R4008.1
VCCSTG_EN_R: length 15.9
  TOP w0.127: v1(164.16,123.68) 164.28,123.56 164.28,122.72 v2(164.21,122.65)
  L3 w0.127: v2(154.99,131.05) 155.02,131.05 155.82,130.24 155.82,129.85 157.68,127.99 158.4,127.27 159.5,127.27 163.25,123.52 163.33,123.52 v2(164.21,122.65)
  BOTTOM w0.127: v2(154.99,131.05) 154.85,131.2 154.85,131.76 R4012.2 ; U4002.2 163.79,122.23 163.82,122.26 163.83,122.26 164.11,122.55 164.11,122.55 164.21,122.64 v2(164.21,122.65)
VCCSTU_EN: length 17.8
  TOP w0.127: v1(156.5,124.61) 156.76,124.87 v2(156.76,125.17)
  L4 w0.127: v2(156.76,125.17) 156.76,117.91 v2(157.53,117.13)
  BOTTOM w0.127: R4024.1 158.03,116.63 v2(157.53,117.13) ; v2(156.76,125.17) 156.49,125.44 R4023.2 155.88,125.97 155.57,126.28 155.57,128.76 U4005.4 156.19,130.14 155.77,130.56 EC4001.1 R4026.2
VCCSTU_EN_D: length 5.3
  BOTTOM w0.127: v1(154.64,112.24) 155.21,112.24 156.01,113.05 D4005.A 157.43,114.83 157.43,115.3 157.82,115.69 R4013.1
VCCSTU_EN_R: length 3.8
  BOTTOM w0.127: v1(158.7,117.49) 158.92,117.27 R4024.2 158.92,115.7 R4013.2 159.72,114.88 U4006.2
VDD10: length 9.3
  TOP w0.203: LOM31.8 43.86,167.57 43.32,167.03 v2(43.32,166.94) ; LOM31.3 43.53,169.57 43.27,169.83 v2(43.15,169.83) ; LOM31.22 49.53,169.57 v2(49.53,169.57) ; LOM31.30 45.93,171.98 v2(45.51,172.4) 45.17,172.4 44.76,172.81
  TOP w0.508: C3116.1 42.99,173.76 43.82,173.76 v1(43.99,173.58) 44.76,172.81 ; C3115.1 42.4,169.83 v2(43.15,169.83)
  vias: v3(50.33,176.38) v3(50.33,175.54) v3(50.36,169.37) v3(51.22,176.38) v3(51.22,175.54)
VDDREG:
  vias: v1(51.56,170.44)
VSS_AY71: length 10.8
  BOTTOM w0.127: 93,72.43 93.17,72.61 93.41,72.61 93.95,73.15 94.55,73.15 94.96,73.57 CPU1.AY71
  BOTTOM w0.254: R602.1 89.53,67.34 91.71,69.52 91.71,71.15 93,72.43
VSS_SENSE: length 110.3
  TOP w0.14: PR4645.1 122.46,139.88 128.36,139.88 129.88,141.41 142.58,141.41 144.85,139.14 148.62,139.14 153.28,134.48 153.28,129.29 154.62,127.96 156.94,127.96 157.87,127.02 157.87,125.18 ; v2(141.06,107.97) 140.88,108.16 140.88,108.57 150.31,118.01 153.92,118.01 154.82,118.91 154.82,121.52 157.87,124.58 157.87,125.18 ; 157.87,125.18 v1(158.03,125.18) ; R720.1 116.5,93.16 v2(116.9,92.77)
  L4 w0.127: v2(141.06,107.97) 141.01,108.02 139.35,108.02 139.2,107.87 130.26,107.87 128.49,106.11 126.83,106.11 125.04,104.32 125.04,102.7 124.27,101.93 122.77,101.93 122.26,101.41 120.42,101.41 117.4,98.39 117.4,92.76 117.24,92.6 117.07,92.6 v2(116.9,92.77)
  BOTTOM w0.14: CPU1.E33 116.55,92.4 116.55,92.63 116.69,92.77 v2(116.9,92.77)
VSSGT_SENSE: length 92.3
  TOP w0.14: PR4618.1 101.66,147.74 101.05,147.13 101.05,146.59 100.42,145.96 99.8,145.96 v2(99.66,145.82)
  L3 w0.127: v2(99.66,145.82) 98.98,145.82 98.33,146.46 96.46,146.46 91.81,141.81 91.81,133.95 95.19,130.56 95.19,127.2 94.53,126.54 94.53,124.19 95.14,123.58 95.14,118.67 88.16,111.69 88.16,101.55 88.59,101.12 88.9,101.12 v2(89.09,101.32)
  BOTTOM w0.089: 93.63,88.95 93.63,88.97 93.59,89.01 93.59,89.2 94.11,89.72 95.13,89.72 95.34,89.79 95.49,89.83 96.02,89.83 CPU1.J69
  BOTTOM w0.14: 84.96,90.83 84.96,89.66 86.27,88.35 86.27,87.12 86.86,86.53 87.36,86.53 87.61,86.29 R722.1 87.99,86.29 88.3,86.6 89.01,86.6 89.91,87.5 92.48,87.5 92.63,87.65 93.63,88.64 93.63,88.95 ; 84.96,90.83 v1(84.83,90.83) ; 84.96,90.83 84.96,97.49 88.58,101.11 88.89,101.11 v2(89.09,101.32)
VSSIO_VR_FB: length 4.3
  TOP w0.254: v2(123.25,79.32) 121.72,79.32 121.46,79.58 v1(121.46,80.04) 121.46,80.56 120.95,81.07 R730.1
  BOTTOM w0.254: CPU1.AM22 123,79.06 v2(123.25,79.32)
VSSSA_SENSE: length 123.6
  TOP w0.254: PR4604.1 111.97,152.76 111.97,153.06 112.27,153.36 118.79,153.36 119.86,152.29 129.48,152.29 v1(133.25,148.52) 137.75,144.01 143.31,144.01 144.29,143.04 146.35,143.04 147.09,142.29 v2(147.09,142.07)
  L3 w0.254: v2(131.65,104.68) 133.58,106.61 140.36,106.61 140.57,106.82 143.86,106.82 154.86,117.81 154.86,122.11 153.1,123.87 153.1,127.24 152.92,127.42 152.92,135.15 153.16,135.39 153.16,136.52 150.96,138.72 150.96,139.34 149.12,141.19 149.12,141.92 148.71,142.33 147.96,142.33 147.9,142.38 147.22,142.38 147.09,142.25 v2(147.09,142.07)
  L4 w0.254: v2(131.65,104.68) 129.2,102.23 127.36,102.23 124.5,99.37 121.96,99.37 120.11,97.51 v2(120.11,96.9) 120.11,95.14 122.14,93.11 122.14,91.61 123.04,90.71 v2(123.46,90.71)
  BOTTOM w0.254: CPU1.H21 123.88,90.38 123.61,90.38 123.46,90.53 v2(123.46,90.71) ; R734.1 120.12,96.91 v2(120.11,96.9)
0D675V_S0: length 14.1
  TOP w0.508: C1215.1 C1214.1 126.25,35.16 C1216.1 126.25,33.45 v2(125.69,32.89) ; v2(141.3,26.06) 141.26,26.06 141.14,26.18 C1307.1
  L4 w0.508: v2(141.3,26.06) 141.5,26.06 142.3,25.27 142.3,22.42 141.31,21.43 v3(141.31,19.47) v3(141.31,18.63)
  BOTTOM w0.305: DM2.203 140.75,25.3 141.3,25.85 v2(141.3,26.06)
  vias: v1(42.29,20.35) v3(42.98,20.46) v3(44.14,21.08) v3(44.16,20.2) v3(137.38,15.07) v3(138.22,15.07) v3(139.06,15.07)
1D0V_PWR: length 13.1
  L4 w0.508: v2(152.65,136.3) 152.39,136.3 150.49,134.4 150.49,126.33 149.79,125.64 148.72,125.64 v2(148.71,125.65)
  vias: v1(144.92,119.81) v1(147.87,118.74)
1D0V_S5: length 52.6
  TOP w0.508: v2(172.48,66.91) 172.48,65.77 172.02,65.32 R2402.1 ; v2(171.87,80.84) 171.2,81.5 171.2,86.52 169.83,87.9 169.15,87.9 v1(167.77,89.28) 167.16,89.89 166.99,89.89 166.98,89.91 v2(166.94,89.91)
  L4 w0.508: v2(170.61,74.04) 171.11,73.54 171.11,68.28 v2(172.48,66.91) ; v2(166.94,89.91) 166.98,89.95 166.98,90.07 166.76,90.29 166.76,91.21 165.79,92.18 165.79,94.05 165.8,94.06 165.8,96.63 165.79,96.64 165.79,101.35 v2(165.25,101.88)
  BOTTOM w0.508: v2(165.25,101.88) 165.25,102.39 v1(163.8,103.85) 160.96,106.69 159.78,106.69 159.36,107.11 159.36,108.05 159.85,108.54 159.85,109.52 ; v2(171.87,80.84) 171.87,78.9 171.84,78.88 171.84,78.35 171.87,78.32 171.87,77.95 171.12,77.2 171.12,74.55 v2(170.61,74.04)
  vias: v1(146.05,114.39) v1(159.34,110.39)
1D0V_S5_PWRGD: length 37.1
  TOP w0.127: R4029.1 128.65,149.18 v1(130.14,147.69) 132.11,145.72 132.11,145.14 132.11,145.14 v2(132.11,145.09)
  L3 w0.127: v2(132.11,145.09) 132.73,144.47 134.06,144.47 135.2,145.61 148.05,145.61 152.05,141.61 152.05,141.57 154.99,138.63 154.99,134.72 v2(155.19,134.52)
  BOTTOM w0.127: v2(155.19,134.52) 155.14,134.57 PR5310.1
1D5V_PWR:
  vias: v1(36.55,15.78)
1D05V_PWR: length 16
  TOP w0.254: v2(155.72,152.99) 154.5,151.77 v1(146.04,151.77) 144.62,151.77 v2(142.74,149.89)
  BOTTOM w0.254: PR8303.1 143.49,149.89 v2(142.74,149.89) 142.74,150.57 PC8305.1
1D5V_S0: length 14.7
  TOP w0.508: v2(27.99,6.94) 25.49,6.94 25.15,7.28 R2705.1
  L4 w0.508: v2(27.99,6.94) 29.01,7.96 31.22,7.96 32.53,9.27 32.53,12.42 33.42,13.32 v3(34.87,13.32)
  vias: v1(35.98,13.28)
1D05V_VGA_EN: length 37.3
  TOP w0.127: PQ8301.2 177.77,144.79 177.34,145.22 174.87,145.22 174.14,145.95 170.07,145.95 R8302.2 169.88,146.15 167.77,146.15 167.48,145.86 166.31,145.86 165,147.17 162.32,147.17 158.29,151.2 158.28,151.2 158.03,151.45 v1(155.7,151.45) 147.95,151.45 v2(147.02,150.53)
  BOTTOM w0.127: PR8305.1 145.41,151.52 C8303.2 PR8308.2 146.86,150.68 v2(147.02,150.53)
1D05V_VGA_EN#: length 4.5
  TOP w0.127: PQ8301.6 179.63,145.44 179.48,145.29 179.48,144.9 179.59,144.79 PQ8301.5 181.49,144.79 v1(181.6,144.68) 181.87,144.41 PR8307.2
1D05V_VGA_S0:
  vias: v1(156.39,159.89) v1(157.51,158.78) v1(173.39,147.11) v1(176.46,149.68) v1(178.78,151.29) v1(181.12,147.96) v1(192.11,129.84) v1(197.4,130.94) v2(184.88,150.61) v2(185.66,149.66) v2(186.01,131.38) v2(186.04,130.49) v2(186.51,148.04) v2(186.52,147.23) v2(186.49,146.39) v2(186.49,141.46) v2(186.48,140.59) v2(186.49,139.73) v2(196.87,131.22) v2(197.4,131.63) v3(156.18,158.07) v3(157.02,158.07) v3(157.96,158.05) v3(177.39,148.52) v3(178.25,148.52) v3(179.09,148.52)
1D05V_VGA_S0_DISCHG: length 5.8
  TOP w0.102: PR8306.2 181.32,145.71 180.32,146.71 v1(179.89,146.71) 179.63,146.71 179.24,146.32 179.24,144.32 179.05,144.14 PQ8301.3
1D05V_VGA_S0_PWRGD: length 153.9
  TOP w0.127: R8303.1 151.28,38.83 149.48,40.63 D8301.2 149.05,41.8 149.43,42.17 v1(149.74,42.17) v2(150.53,42.17)
  L3 w0.127: v2(164.59,75.14) 164.66,75.21 165.81,75.21 165.81,75.21 168.67,75.21 169.2,75.74 170.14,75.74 v2(170.21,75.67) ; v2(171.31,43.48) 170.27,42.44 165.48,42.44 164.69,43.22 157.47,43.22 156.12,41.88 153.09,41.88 152.8,41.59 151.12,41.59 v2(150.53,42.17)
  L4 w0.127: v2(149.6,149.38) 149.6,145.21 155.32,139.48 155.32,136.76 154.64,136.07 154.64,134.58 154.22,134.16 154.22,128.6 155.62,127.2 157.2,127.2 157.56,126.84 157.56,121.36 159.03,119.89 159.03,109.5 159.42,109.11 159.42,108.39 158.92,107.9 158.92,104.36 158.74,104.17 158.74,101.15 158.99,100.91 158.99,99.89 158.28,99.19 158.28,94.99 158.77,94.51 158.77,88.12 160.42,86.47 160.42,84.78 162.65,82.55 162.65,82.22 162.82,82.05 162.82,79.31 163.04,79.08 163.04,78.35 163.72,77.67 163.72,76 v2(164.59,75.14)
  BOTTOM w0.127: v2(170.21,75.67) 170.67,75.21 170.67,74.81 170.09,74.23 170.09,73.9 169.93,73.75 169.93,73.15 170.31,72.78 170.33,72.78 170.92,72.18 170.92,72.17 170.92,72.17 170.92,71.59 171.14,71.38 171.14,65.6 171.37,65.37 171.37,59.9 170.78,59.31 170.78,44 v2(171.31,43.48) ; PR8320.2 149.91,149.7 v2(149.6,149.38)
1D8A_EN#: length 6.5
  BOTTOM w0.127: R4039.2 R4040.1 167.09,116.69 168.36,117.96 Q4004.D 170.52,116.75 v1(170.32,116.55)
1D8A_EN_R#: length 19.6
  L4 w0.127: v2(168.29,117.23) 168.29,116.17 166.56,114.43 v2(166.56,110.41)
  BOTTOM w0.127: v2(166.56,110.41) 165.23,109.08 v1(165.23,108.06) 165.23,103.06 165.99,102.29 C4018.2 166.61,101.8 Q4003.G ; v2(168.29,117.23) 168.29,116.86 R4040.2
1D8V_EN#: length 4.3
  BOTTOM w0.127: Q4009.D 48.85,11.1 v1(48.53,10.78) 48.33,10.58 R4047.1 48.33,8.97 R4046.2
1D8V_EN_R#: length 3.3
  BOTTOM w0.127: Q4008.G v1(46.48,10) 47.27,10 R4047.2 47.44,9.01 C4028.2
1D8V_PWR:
  vias: v1(167.99,106.85)
1D8V_S0: length 28.1
  TOP w0.508: v2(23.43,6.8) 23.3,6.8 22.71,7.39 R2726.1
  BOTTOM w0.508: Q4008.D 42.61,8.48 C4030.1 40.67,8.48 v1(40.58,8.56) 33.7,8.56 32.87,7.73 27.82,7.73 26.29,6.2 24.02,6.2 23.62,6.6 23.62,6.61 v2(23.43,6.8) 21.62,6.8 21.35,7.08 21.11,7.32 21.11,7.95 21.69,8.52 R2713.1
1D8V_S5: length 300.5
  TOP w0.508: v2(196.92,95.3) 196.92,94.56 193.59,91.23 192.75,91.23 v2(192.21,90.69) ; v2(199.53,79.26) 199.53,77.7 196.22,74.39 196.22,73.01 197.02,72.21 198,72.21 198.57,71.63 v2(198.57,69.25)
  L3 w0.508: v3(169.82,99.42) 170.94,99.42 171.85,98.51 174.18,98.51 174.76,99.09 176.18,99.09 178.97,96.3 184.96,96.3 190.56,90.69 v2(192.21,90.69) ; v2(190.54,19.76) 174.15,3.37 144.93,3.37 143.46,1.91 90.94,1.91 88.97,3.87 72.7,3.87 72.19,3.37 70.96,3.37 67.72,6.62 46.4,6.62 v2(46.05,6.96)
  L4 w0.508: v2(167.98,114.67) 167.4,114.09 167.4,109.64 168.98,108.06 v3(168.98,99.42)
  BOTTOM w0.508: R4039.1 v2(167.98,114.67) ; v2(199.53,79.26) 199.53,82.28 198.74,83.07 198.74,88.59 197.49,89.84 v1(197.49,90.48) 197.49,94.73 v2(196.92,95.3) ; v2(190.54,19.76) 195.49,19.76 197.53,21.79 197.53,25.39 197.95,25.81 197.95,40.41 191.87,46.49 191.87,58.05 198.58,64.76 198.58,69.24 v2(198.57,69.25) ; R4046.1 47.51,8.06 C4028.1 C4029.1 46.67,7.58 v2(46.05,6.96) 46.05,6.96 45.91,6.96 45.04,7.83 Q4008.S
  vias: v1(169.47,100.49)
1D8V_S5_PWROK: length 77.1
  TOP w0.127: R4030.1 127.76,148.6 127.77,148.58 127.77,148.56 v1(128.65,147.68) v2(131.24,145.09)
  L3 w0.127: v2(131.24,145.09) 132.11,144.22 134.17,144.22 135.31,145.36 147.64,145.36 v2(148.75,144.25)
  BOTTOM w0.127: PR5408.1 172.98,113.24 172.98,115.05 172.01,116.03 172.01,117.98 171.21,118.78 168.96,118.78 168.39,119.36 166.92,119.36 166.82,119.46 166.82,119.46 166.56,119.72 166.56,121.35 166.84,121.63 167.95,121.63 168.52,122.2 168.52,125.1 168.32,125.3 167.02,125.3 166.69,125.62 166.69,128.82 166,129.51 166,134.69 162.74,137.95 162.74,140.91 159.4,144.25 v2(148.75,144.25)
1D35V_ENABLE: length 5.3
  TOP w0.127: R8305.2 154.44,36.11 v1(153.55,36.11) PR8312.1 PR8310.1 153.01,37.47 PQ8303.3
1D35V_ENABLE_RC: length 4.4
  TOP w0.127: R8305.1 PC8308.1 156.24,35.49 156.43,35.3 156.43,34.31 PQ8304.4 157.75,34.31 v1(157.98,34.09)
1D35V_ENABLE_TP: length 1.4
  TOP w0.127: TP8301.1 150.27,37 PR8310.2
1D35V_S3: length 139.3
  TOP w0.203: v3(45.1,23.04) 45.49,22.66 PU5101.2
  TOP w0.508: R505.1 149.12,66.08 149.18,66.02 149.18,65.15 147.49,63.46 147.49,62.24 144.23,58.99 v2(142.25,58.99) ; R4201.1 v2(58.94,46) ; R4206.1 v2(56.35,36.68) ; R4216.1 v2(58.2,42.22)
  L3 w1.016: v3(65.66,18.28) 65.66,17.22 62.72,14.28 52.57,14.28 51.7,15.16 49.81,15.16 45.64,19.33 45.64,20.71 46.07,21.14 46.07,22.08 v3(45.1,23.04)
  L4 w0.508: v2(142.25,58.99) 142.85,58.39 142.85,57.78 143.45,57.18 143.45,51.06 145.67,48.84 145.67,42.76 145.98,42.44 145.98,42.43 146.43,41.98 146.45,41.98 v2(146.58,41.84)
  L4 w1.016: v3(65.15,24) 65.13,24.02 65.13,25.81 63.72,27.21 62.5,27.21 61.03,28.68 57.4,28.68 55.52,30.56 55.52,32.36 56.08,32.92 56.08,35.87 56.35,36.14 v2(56.35,36.68)
  BOTTOM w0.127: CPU1.BB47 109.26,72.76 109.26,71.49 v2(109.11,71.35) ; CPU1.BB51 106.64,72.61 106.64,70.48 105.53,69.37 v2(105.53,69.05) ; v2(117.96,71.73) 117.91,71.78 117.91,72.83 CPU1.BB32
  BOTTOM w0.203: CPU1.BB23 122.87,72.83 123.14,72.56 v2(123.14,72.02)
  BOTTOM w0.254: CPU1.AL23 v2(122.54,78.5) ; CPU1.AU23 122.41,75.25 v2(122.54,75.25) ; v2(112.62,70.42) 112.76,70.57 112.76,71.47 112.82,71.53 112.82,72.76 CPU1.BB41
  BOTTOM w0.305: v2(102.47,39.58) 102.25,39.36 DM1.123 ; v2(93.35,39.75) 93.25,39.64 DM1.93 ; DM1.99 95.05,39.71 v2(95,39.77) ; v2(91.61,39.78) 91.45,39.62 DM1.87 ; DM1.105 96.85,39.6 v2(96.71,39.75) ; v2(97.82,39.8) 98.36,39.8 98.65,39.51 DM1.111 ; v2(100.24,39.79) 100.45,39.58 DM1.117 ; DM1.81 89.65,39.58 v2(89.4,39.83) ; v2(118.87,75.24) 119.21,75.57 CPU1.AU28 ; DM1.75 87.85,39.77 88.87,40.79 v2(89.39,40.79) ; v2(111.58,75.24) 111.91,75.57 CPU1.AU42 ; v2(115.21,75.9) 115.54,75.57 CPU1.AU35
  BOTTOM w0.33: v2(106.25,15.49) 106.25,15.49 DM2.88 ; v2(108.05,15.49) 108.05,15.49 DM2.94 ; DM2.100 109.85,15.49 v2(109.85,15.49) ; v2(104.45,15.49) 104.45,15.49 DM2.82 ; DM2.76 102.65,15.49 v2(102.65,15.49) ; v2(115.25,15.49) 115.25,15.49 DM2.118 ; DM2.106 111.65,15.49 v2(111.65,15.49) ; 102.55,28.71 DM1.124 ; DM2.124 117.05,15.49 v2(117.05,15.49) ; v2(113.48,15.4) 113.48,15.49 113.45,15.52 DM2.112
  BOTTOM w0.508: v3(45.1,23.04) 46.01,23.95 PC5104.1
  BOTTOM w1.016: v2(56.35,36.68) 56.35,39.14 58.2,40.99 v2(58.2,42.22) 57.83,42.58 57.83,44.89 v2(58.94,46)
  vias: v1(68.88,24.21) v1(89.32,29.59) v1(98.6,54.28) v1(102.66,16.54) v1(103.9,43.97) v1(118.31,70.45) v1(145.9,35.43) v1(152.9,27.44) v2(88.15,28.38) v2(89.95,28.38) v2(91.75,28.38) v2(95.56,28.69) v2(99.5,28.55) v2(101.05,28.69) v2(102.06,28.43) v2(103.16,26.66) v2(104.26,26.38) v2(105.89,26.28) v2(108.91,28.15) v2(110.04,27.11) v2(110.04,26.37) v2(113.12,27.02) v2(113.12,26.31) v2(114.86,26.26) v2(117.04,26.26) v3(65.55,19.45) v3(66.39,19.45) v3(67.14,18.42) v3(67.23,19.45) v3(68.13,22.05) v3(68.13,21.21) v3(68.13,20.37) v3(68.13,19.54) v3(68.13,18.7) v3(68.96,21.21) v3(68.96,20.37) v3(68.96,19.54) v3(68.96,18.7)
1D35V_VGA_EN: length 5.2
  TOP w0.127: D8301.3 150.82,37.94 v1(151.53,37.94) R8303.2 R8304.1 154.09,37.94 154.27,38.12 PQ8303.2
1D35V_VGA_EN#: length 9.6
  TOP w0.127: PQ8303.5 157.32,38.12 157.53,38.33 157.53,38.61 157.36,38.77 PQ8303.6 156.74,39.34 156.39,39.69 PR8314.2 PR8311.2 158.41,40.12 v1(158.52,40.01) 158.67,39.86 158.67,38.72 160.47,36.91 PQ8302.G
1D35V_VGA_S0: length 59.8
  TOP w0.254: VRAM3.G7 202.94,166.92 v2(202.54,166.52)
  TOP w0.305: v2(174.53,172.29) 174.35,172.11 VRAM4.C9 ; v2(197.92,172.99) 198.15,172.76 VRAM3.N1 ; v2(208.33,171.87) 208.18,171.72 VRAM3.A1 VRAM3.B2 ; VRAM4.F1 176.75,165.11 v2(177.13,164.74) ; 172.26,171.1 172.44,170.92 VRAM4.A8 ; v2(197.04,173.3) 196.55,172.81 VRAM3.R1 ; VRAM4.B2 173.3,166.37 173.3,166.38 v2(173.15,166.53) ; VRAM4.N1 182.35,165.36 v2(182.74,165.75) ; VRAM4.E9 175.95,171.94 v2(176.33,172.32) ; v2(175.28,172.32) 175.28,172.2 175.15,172.07 VRAM4.D9 ; VRAM3.F1 203.53,171.94 203.52,171.94 v2(203.3,172.15) ; VRAM4.R9 183.95,172.42 v2(183.09,173.28) ; v2(177.95,170.48) 177.77,170.29 177.72,170.29 VRAM4.G7 ; VRAM4.K8 v2(179.57,171.3) ; v2(206.15,172.45) VRAM3.C1 VRAM3.D2 ; VRAM4.N9 182.35,172.36 v2(182.32,172.38) ; VRAM4.H2 178.35,166.16 v2(177.99,166.52) ; VRAM4.K2 179.57,165.74 v2(179.56,165.74) ; VRAM3.H2 202.18,170.92 v2(202.58,170.52) ; VRAM4.D2 VRAM4.C1 174.31,165.28 v2(174.31,163.93) 174.56,163.93 v2(175.51,164.88) ; v2(179.15,172.32) 178.95,172.32 VRAM4.H9
  TOP w0.356: v2(200.94,171.29) 200.92,171.29 VRAM3.K2 ; 172.26,171.1 171.72,171.1 171.52,171.3 171.52,172.08 v2(171.72,172.29) ; v2(183.95,164.74) 183.95,164.83 VRAM4.R1 ; VRAM3.N9 197.97,165.14 197.97,164.57 v2(197.43,164.02)
  L3 w0.305: v2(200.94,165.72) 201.74,165.72 v2(202.54,166.52)
  L4 w0.305: v2(179.57,171.3) 178.75,170.48 v2(177.95,170.48)
  BOTTOM w0.203: v2(202.54,166.52) 203.09,166.52 203.34,166.27 203.34,165.97 203.75,165.56 VRAM1.F1
  BOTTOM w0.254: VRAM1.A8 207.75,171.07 208.32,171.64 208.32,171.87 v2(208.33,171.87)
  BOTTOM w0.305: GPU1.L24 195.21,150.97 194.85,150.61 v2(194.85,150.58) ; VRAM2.H9 178.35,165.05 v2(178.09,164.8) ; VRAM2.A8 172.75,166.13 v2(173.15,166.53) ; VRAM3.N1 198.15,172.76 v2(197.92,172.99) ; GPU1.E26 200.2,153.28 v2(200.2,153.28) ; v2(197.04,173.3) 196.55,172.81 VRAM3.R1 ; VRAM3.N9 197.96,165.13 197.96,164.55 v2(197.43,164.02) ; VRAM2.D9 175.3,165.17 175.3,165.1 v2(175.51,164.88) 175.75,165.12 175.75,165.12 VRAM2.E9 ; VRAM1.H2 202.15,166.13 v2(202.54,166.52) ; v2(176.33,172.32) 176.33,172.14 VRAM2.F1 ; VRAM3.R9 196.55,164.68 v2(196.44,164.57) ; VRAM2.H2 177.95,170.52 v2(177.95,170.48) ; v2(179.56,165.74) 179.73,165.91 179.74,165.91 VRAM4.K2 ; v2(177.99,166.52) 177.59,166.92 VRAM2.G7 ; VRAM1.A1 207.73,165.32 v2(207.34,165.71) 206.95,166.1 VRAM1.B2 ; v2(200.94,165.72) 200.93,165.71 200.55,166.09 VRAM3.K8 ; VRAM4.R9 183.95,172.42 v2(183.09,173.28) ; VRAM3.K2 200.71,171.08 200.74,171.08 v2(200.94,171.29) ; VRAM4.N1 182.74,165.71 v2(182.74,165.75) ; VRAM4.N9 182.35,172.36 v2(182.32,172.38)
  BOTTOM w0.356: v2(197.29,152.12) 197.29,152.15 197.71,152.57 GPU1.H26 ; GPU1.H24 197.71,150.92 197.34,150.55 v2(197.32,150.55) ; v2(195.62,152.95) 195.61,152.95 195.57,152.92 195.56,152.92 195.23,152.59 GPU1.L26 ; v2(183.95,164.74) 183.95,164.83 VRAM4.R1 ; v2(203.12,153.04) 202.65,152.57 GPU1.B26 GPU1.C25 ; VRAM4.C1 174.35,163.97 v2(174.31,163.93) ; v2(199.8,149.65) 199.8,149.72 GPU1.E23
  BOTTOM w0.508: v2(177.13,164.74) 178.03,164.74 v2(178.09,164.8)
  vias: v1(160.62,31.32) v1(174.3,153.63) v1(181.46,158.38) v1(186.92,155.19) v1(188.32,163.46) v1(190.56,172.99) v1(198.52,48.29) v1(202.67,158.45) v2(168.67,173.26) v2(170.93,173.28) v2(171.79,173.28) v2(172.66,173.28) v2(173.59,173.26) v2(174.64,173.34) v2(183.99,173.58) v2(188.04,148.2) v2(188.92,148.07) v2(189.79,148.08) v2(192.32,148.14) v2(193.97,148.11) v2(194.89,148.11) v2(195.68,148.09) v2(196.49,148.06) v2(198.06,148.09) v2(198.11,147.22) v2(198.11,146.38) v2(198.08,144.51) v2(198.09,143.82) v2(198.19,143.11) v2(199,143.11) v2(204.93,172.35) v2(205.49,173.01) v2(205.76,164.88) v3(169.59,151.85) v3(169.84,152.83) v3(170.22,151.22) v3(170.47,152.2) v3(170.86,150.58) v3(171.11,151.56) v3(171.49,174.77) v3(171.74,150.93) v3(172.76,174.76) v3(173.97,174.78) v3(183.28,174.64) v3(184.67,174.63) v3(186.1,174.64) v3(187.23,177.53) v3(190.44,177.55) v3(192.45,177.53) v3(194.13,177.27) v3(196.42,174.49) v3(197.59,174.5) v3(198.31,61.26) v3(198.31,60.37) v3(198.41,51.91) v3(198.41,51.02) v3(198.44,50.16) v3(198.44,49.27) v3(199.2,61.26) v3(199.2,60.37) v3(199.29,51.91) v3(199.29,51.02) v3(199.32,50.16) v3(199.32,49.27) v3(202.44,174.76) v3(204.72,174.57) v3(206.46,174.56) v3(208.02,174.52) v3(209.9,175.09) v3(210.99,173.77)
1D35V_VTT_PWRGD: length 320.7
  TOP w0.127: R4011.1 129.45,151.29 132.32,148.42 132.32,147.64 136.39,143.57 143.12,143.57 144.1,142.59 145.84,142.59 146.83,141.6 147.19,141.6 148.33,140.46 148.85,140.46 149.09,140.69 154.18,140.69 v1(155.92,138.96) 157.06,137.82 v2(159.66,137.82) ; v2(44.53,27.05) 44.53,26.85 PR5104.2 45.25,25.57 46.36,24.46 46.88,24.46 47.07,24.27 PU5101.20
  L3 w0.127: v2(44.53,27.05) 46.99,27.05 47.78,27.83 47.78,28.11 48.43,28.76 48.93,28.76 49.12,28.58 50.73,28.58 51.46,29.3 61.85,29.3 62.86,28.29 64.09,28.29 70.19,22.19 70.19,18.75 76.72,12.22 85.33,12.22 86.96,10.58 87.45,10.1 90.85,10.1 94.03,6.92 134.69,6.92 138.51,10.75 140.08,10.75 142.77,13.43 142.77,14.05 149.33,20.61 168.77,20.61 169.35,20.04 172.32,20.04 v2(172.51,20.23)
  L4 w0.127: v2(159.66,137.82) 160.34,137.14 160.34,131.71 162.08,129.97 162.08,119.93 161.47,119.33 161.47,109.42 162.14,108.76 162.14,103.4 161.45,102.71 161.45,101.71 160.68,100.94 160.68,99.58 161.15,99.12 161.15,92.95 161.2,92.9 161.2,91.6 160.52,90.93 160.52,89.57 163.11,86.97 163.11,86.45 163.11,84.57 164.49,83.19 164.49,83.13 164.64,82.98 164.64,80.68 164.83,80.48 164.83,75.99 165.38,75.45 165.38,72.75 165.61,72.52 165.61,70.78 165.38,70.55 165.38,69.35 165.13,69.1 165.13,68.73 165.61,68.25 165.61,67.51 164.92,66.83 164.92,65.44 163.68,64.2 163.68,62.77 165.04,61.41 165.04,60.26 164.38,59.6 164.38,58.07 164.84,57.62 164.84,57.58 164.84,57.57 164.84,57.01 164.84,57 164.84,56.41 165.43,55.82 165.43,50.86 164.64,50.07 164.64,48.34 163.99,47.69 163.99,42.12 165.35,40.76 165.35,38.8 172.71,31.43 172.71,28.56 173.53,27.75 173.53,24.96 174.16,24.32 174.16,23.08 174.11,23.03 174.11,22.66 174.02,22.56 174.02,21.74 v2(172.51,20.23)
3D3V_AUX_KBC_33: length 8.4
  TOP w0.203: KBC24.54 179.28,83.69 v1(178.81,84.16)
  TOP w0.508: v1(178.81,84.16) 178.14,84.83 178.14,85.44 177.89,85.69 177.89,88.38 178.24,88.81 C2423.1 R2462.1
3D3V_AUX_KBC_R: length 4.4
  BOTTOM w0.305: DB3.1 155.84,15.02 155.18,15.69
  BOTTOM w0.508: R2476.1 154.98,17.69 154.31,17.02 v1(154.31,16.81) 154.31,16.56 155.18,15.69
3D3V_AUX_S5: length 637.9
  TOP w0.508: PR8307.1 182.76,143.52 182.37,143.13 v2(182.37,143.03) ; v2(199.08,97.75) 198.43,97.11 198.43,94.82 195.09,91.48 195.09,87.9 195.21,87.79 195.21,87.43 196.56,86.08 v2(196.99,86.08) ; v2(87.85,13.95) 87.85,10.32 87.52,9.98 87.52,9.96 83.9,6.35 79.41,6.35 77.77,4.71 v2(66.95,4.71) ; R2472.2 181.47,53.85 181.15,54.18 180.67,54.18 180.63,54.22 180.06,54.79 v2(180.06,55.56) ; v2(35.02,60.09) 34.9,59.97 PR4501.1 ; v2(158.35,135.99) 158.72,135.99 161.29,138.56 163.12,138.56 165.8,141.24 166.25,141.24 166.82,141.8 167.79,141.8 168.66,142.67 168.66,143.52 169.32,144.18 171.24,144.18 171.52,144.46 v2(171.52,144.48) ; v2(157.25,41.82) 157.58,41.49 PR8311.1 ; v2(176.18,116.2) 176.18,115.87 175.75,115.44 172.5,115.44 171.85,116.09 168.17,116.09 162.64,110.57 v2(162.64,110.46) 161.44,109.26 161.44,107.73 160.13,106.42 v2(160.13,105.12) ; v2(157.26,56.45) 156.81,56 154.57,56 153.33,54.77 R6102.1 ; v2(158.39,22.79) 158.39,24.38 159.2,25.19 R6003.1
  L3 w0.305: v2(152.6,68.13) 152.95,68.13 153.33,67.75 159.13,67.75 159.53,67.34 v2(159.56,67.34)
  L3 w0.508: v2(158.39,22.79) 155.67,22.79 154.77,23.69 149.06,23.69 138.53,13.16 134.61,13.16 130.72,9.27 95.51,9.27 92.11,12.67 88.84,12.67 87.85,13.65 v2(87.85,13.95) ; v2(182.37,143.03) 182.34,143.03 182.27,143.1 173,143.1 171.62,144.48 v2(171.52,144.48) 171.52,144.57 168.88,147.21 165.99,147.21 163.52,149.69 161.9,149.69 160.16,151.43 160.16,157.46 158.05,159.57 156.51,159.57 146.7,169.38 138.13,169.38 135.74,166.99 130.43,166.99 130.24,167.18 126.13,167.18 125.99,167.04 125.03,167.04 123.93,168.14 113.5,168.14 111.73,166.38 109.4,166.38 108.83,165.81 v2(108.83,165.38) ; v2(35.02,60.09) 40.46,60.09 40.9,59.64 43.02,59.64 44.47,61.09 47.36,61.09 52.81,55.65 v2(52.81,36.45) ; v2(157.26,56.45) 158.51,55.2 163.05,55.2 163.98,54.27 167.33,54.27 168.36,55.31 170.67,55.31 171.49,56.13 174.45,56.13 175,55.57 180.05,55.57 v2(180.06,55.56) 180.07,55.57 180.28,55.57 180.45,55.74 180.79,55.74 181.77,55.74 182.27,55.24 186.53,55.24 v2(186.55,55.26) 187.14,55.86 190.25,55.86 196.66,62.27 v2(196.66,65.21) ; v2(216.99,95.05) 216.99,94.02 215.01,92.04 213.8,92.04 212.75,93.08 204.36,93.08 202.89,94.56 200.52,94.56 199.08,96 v2(199.08,97.75) 196.97,97.75 191.32,103.39 191.17,103.39 179.73,114.84 179.73,115.61 179.15,116.19 176.19,116.19 v2(176.18,116.2)
  L4 w0.508: v2(52.81,36.45) 52.89,36.45 54.29,37.85 56.81,37.85 57.63,37.04 57.63,35.79 57.24,35.41 57.24,32.39 56.71,31.86 56.71,31 57.86,29.85 58.16,29.85 58.16,29.85 61.51,29.85 62.94,28.43 64.13,28.43 70.4,22.15 70.4,18.9 72.05,17.25 73.17,17.25 74.16,16.26 76.78,16.26 78.2,14.84 87.18,14.84 87.85,14.16 v2(87.85,13.95) ; v2(108.83,165.38) 105.93,165.38 105.16,164.62 102.03,164.62 100.91,163.5 v2(100.59,163.5) ; v2(152.6,68.13) 152.61,68.12 152.61,66.13 155.81,62.94 155.81,60.18 157,58.98 157,56.7 v2(157.26,56.45) 157.4,56.31 157.4,43.49 157.22,43.31 157.22,42.36 157.25,42.33 v2(157.25,41.82) 157.25,38.25 158.46,37.04 158.46,32.74 159.6,31.6 159.6,28.22 159.03,27.65 159.03,23.42 158.39,22.79 v2(158.39,22.79) ; v2(163.39,128.25) 163.27,128.12 163.27,119.49 162.64,118.86 v2(162.64,110.46)
  BOTTOM w0.508: v2(171.52,144.48) 171.62,144.48 172.95,143.15 PR8317.2 172.95,140.41 PR8319.2 ; v2(158.35,135.99) 158.67,135.67 158.67,131.02 161.44,128.25 v2(163.39,128.25) ; PR4532.2 37.25,58.56 v1(36.29,59.52) 35.72,60.09 v2(35.02,60.09) ; R1737.1 158.89,67.98 159.5,67.37 159.53,67.37 v2(159.56,67.34) ; v2(52.81,36.45) 52.81,35.19 55.76,32.24 55.76,31.12 54.78,30.13 R4004.1 ; v2(216.99,95.05) 217,95.07 PR8315.2 ; PR4421.1 101.3,163.58 PR4420.1 100.7,163.61 v2(100.59,163.5) ; v2(196.66,65.21) 196.66,65.58 197.81,66.72 197.81,69.49 199.34,71.02 199.34,78.36 198.82,78.88 198.82,81.87 198.08,82.61 198.08,83.45 198.05,83.48 198.05,85.62 197.59,86.08 v2(196.99,86.08) ; v2(152.6,68.13) 152.61,68.14 152.61,68.6 152.56,68.65 152.56,69.13 152.65,69.22 152.65,69.84 152.46,70.03 R1726.2 152.42,70.59 151.82,71.2 R1727.1 ; v2(66.95,4.71) 66.41,5.25 66.41,6.04 64.94,7.5 52.69,7.5 D2501.1 ; v2(186.55,55.26) 186.55,64.73 185.52,65.76 R2467.1 ; R2609.1 155.63,100.07 157.57,102.01 157.57,102.2 160.1,104.74 160.1,105.1 v2(160.13,105.12)
3D3V_CAMERA_S0: length 0.9
  TOP w0.305: v2(77.17,161.82) 77.18,161.82 LCD1.32
  vias: v1(78.48,161.12)
3D3V_LAN_S5: length 2.3
  TOP w0.203: 44.77,165.21 45.08,165.21 45.93,166.06 LOM31.11
  vias: v1(43.26,165.1) v1(52.33,163.72) v2(43.73,172.08) v3(41.45,165.19) v3(42.27,165.04) v3(53.16,162.91) v3(54.08,174.22) v3(54.08,173.34) v3(54.07,163.46)
3D3V_PWR_2: length 4.3
  TOP w0.203: v2(39.12,57.54) 39.14,57.52 PU4503.3
  TOP w0.356: v1(38.59,58.47) 39.12,57.94 v2(39.12,57.54)
  BOTTOM w0.508: PC4526.1 39.57,58.69 PR4532.1 39.44,58.09 39.12,57.77 v2(39.12,57.54)
3D3V_RUN_FFS: length 4.2
  BOTTOM w0.203: U6701.9 172.86,93.51 ; U6701.2 169.57,93.51 C6701.1 ; U6701.10 172.89,92.95 ; C6702.1 169.36,94.01 U6701.3
  vias: v1(171.78,96.93)
3D3V_S0: length 595.2
  TOP w0.305: v2(196.47,76.81) 196.47,76.53 195.96,76.02 VGABD1.2
  TOP w0.381: 146.32,100.93 Q1801.2 ; v2(141.13,91.58) 141.21,91.58 141.29,91.66 R1609.1 142.81,91.66 R803.1 ; 157.14,76.49 156.87,76.76 156.87,79.6 157.65,80.38 158.33,80.38 ; 157.14,76.49 Q2601.5 ; 157.14,76.49 156.95,76.3 156.95,75.72 159.86,72.8 160.31,72.8 160.34,72.83 ; Q2601.2 160.77,76.49 161.07,76.19 161.07,75.46 160.37,74.76 160.37,72.86 160.34,72.83 ; v2(18.46,69.8) 18.16,69.5 Q5402.5 ; 160.34,72.83 v2(160.37,72.8) ; Q5402.2 v2(14.3,69.5)
  TOP w0.508: v2(157.64,105.74) v1(156.58,104.68) 156.3,104.41 155.2,103.31 151,103.31 150.3,104.01 149.65,104.01 148.9,103.26 147.48,103.26 146.18,101.96 146.18,101.07 146.32,100.93 ; PR4614.1 119.67,150.88 v2(119.8,151.01) ; v2(141.37,23.93) 140.85,24.44 C1311.1 139.52,24.45 R1302.1 ; IOBD1.16 184.86,39.77 183.74,40.9 v3(181.32,40.9) ; v2(190.67,85.75) v1(189.47,85.75) 187.96,85.75 187.09,84.88 R2429.2 187.08,84.73 R2430.2 ; R4005.1 120.77,150.54 v2(120.82,150.59) ; R1818.2 133.82,63.86 133.82,63.15 v2(133.83,63.13) ; R3106.1 53.15,167.98 53.83,168.66 56.68,168.66 59.99,165.36 v1(62.19,165.36) 67.61,165.36 71.77,169.53 v2(75.5,169.53) ; R1831.1 137.19,63.36 v2(136.96,63.13) ; R5529.2 v2(80.55,172.17) ; v2(175.18,96.51) 175.73,97.06 175.73,100.51 174.38,101.86 174.38,105.75 174.48,105.86 v2(174.48,106.79) 174.48,108.48 174.26,108.71 174.26,109.67 174.58,109.99 175.79,109.99 178.59,112.79 178.59,113.34 v2(179,113.76) 182.8,113.76 183.19,113.37 187.1,113.37 188.46,114.73 v2(188.46,116.06) ; R2725.1 R2710.1 24.34,6.94 v2(24.26,6.86) ; R2023.1 149.13,74.05 149.44,73.74 v2(149.44,73.68) ; v2(125.5,36.69) 125.6,36.8 C1203.1 127.14,37.63 v2(127.94,36.83) ; R1832.1 139.37,63.91 138.87,64.41 138.87,66.04 138.47,66.44 138.47,67.05 136.22,69.3 134.89,69.3 134.51,68.92 v2(134.51,68.69) ; R7648.2 211.69,133.06 211.69,131.41 207.64,127.36 206.92,127.36 206.64,127.08 203.46,127.08 202.84,127.69 201.6,127.69 198.8,124.89 197.36,124.89 196.76,124.29 194.96,124.29 194.4,123.73 194.4,123.21 192.5,121.31 189.87,121.31 186.72,118.16 v2(186.72,118.01) ; v2(145.12,88.3) 145.12,88.09 144.72,87.69 143.69,87.69 R2047.1 143.59,88.6 R2044.1 ; v2(146.36,62.73) 146.38,62.73 146.58,62.93 146.58,63.54 146.27,63.85 R2033.1
  L3 w0.508: v2(160.37,72.8) 159.79,72.8 158.69,73.9 156.25,73.9 155.31,73.9 154.05,72.64 151.26,72.64 150.22,73.68 v2(149.44,73.68) ; v2(141.37,23.93) 141.62,24.19 v2(144.9,24.19) ; v2(174.48,106.79) 169.82,106.79 169.39,106.35 166.72,106.35 166.09,106.99 164.38,106.99 163.44,106.05 157.94,106.05 v2(157.64,105.74) ; v2(170.07,81.59) 170.06,81.6 167.89,81.6 167.02,82.47 163.55,82.47 162.69,83.34 159.77,83.34 158.54,82.11 151.38,82.11 151.01,81.73 148.19,81.73 147.98,81.52 146.27,81.52 146.02,81.77 144.51,81.77 143.7,80.96 v2(142.43,80.96) 141.93,81.45 141.22,81.45 v2(141,81.23) ; v2(166.9,32.87) 167.05,33.02 168.07,33.02 170.35,35.31 171.17,35.31 v2(171.83,35.97) ; v2(196.47,76.81) 196.47,75.6 193.78,72.91 192.78,72.91 192.31,73.37 v2(190.82,73.37)
  L3 w1.016: v3(190.32,40.9) v3(181.32,40.9)
  L3 w1.27: 89.05,148.41 89.05,148.41 88.79,148.16 88.79,135.41 89.68,134.52 89.68,128.02 92.55,125.15 92.55,123.21
  L4 w0.508: 145.61,73.23 147.48,73.23 147.93,73.68 v2(149.44,73.68) ; 145.61,73.23 145.14,73.7 144.5,73.7 142.93,75.27 v2(142.93,75.89) ; 145.61,73.23 145.61,71.87 146.11,71.38 146.11,70.25 145.69,69.83 145.69,68.71 145.36,68.38 145.36,64.69 146.45,63.6 146.45,62.82 v2(146.36,62.73) ; 160.68,13.64 158.85,15.47 158.85,18.88 160.83,20.86 160.83,23.79 160.37,24.25 v2(160.05,24.25) ; v2(155.13,128.49) 156.01,129.37 156.01,130.92 155.59,131.34 155.59,133.77 155.82,134 155.82,140.38 154.69,141.52 154.69,146.49 v2(154.69,146.49) ; v2(80.55,172.17) 77.6,169.23 77.6,169.07 ; v2(145.77,14.88) 144.9,15.76 v2(144.9,24.19)
  L4 w1.27: 190.47,89.53 188.56,91.43 188.56,115.96 v2(188.46,116.06) 188.46,116.27 v2(186.72,118.01) 177.97,126.77 177.97,127.48 175.08,130.37 175.08,131.53 v3(173.12,133.5)
  BOTTOM w0.33: v2(125.5,36.69) 125.05,37.14 DM1.199 ; DM2.199 139.55,23.92 139.78,23.69 141.13,23.69 v2(141.37,23.93)
  BOTTOM w0.381: Q6408.2 179.3,113.46 v2(179,113.76)
  BOTTOM w0.508: R4020.1 155.13,126.07 v2(155.13,128.49) ; v2(160.37,72.8) 160.53,72.8 160.61,72.72 161.59,72.72 162.28,72.04 164.21,72.04 168.78,76.61 168.78,79.48 169.36,80.07 169.36,81.14 169.81,81.59 v2(170.07,81.59) 170.68,82.2 170.68,84.77 170.58,84.87 170.58,87.41 170.35,87.63 170.35,88.4 169.88,88.87 169.88,89.2 ; v2(140.27,63.16) 140.26,63.16 R2017.1 140.24,63.82 R2015.1 ; R2009.2 134.51,68.87 v2(134.51,68.69) ; v2(157.64,105.74) 157.64,105.74 153.36,101.47 152.99,101.47 151.91,100.4 v2(151.91,100.07) ; R5521.1 v2(75.5,169.53) ; R2048.2 140.57,80.8 v2(141,81.23) 140.6,81.63 R2049.2 ; R9119.2 159.59,26.37 R9108.2 158.75,25.52 R9120.2 v2(160.05,24.25) ; v2(175.18,96.51) 175.67,96.01 R6701.1 176.41,95.49 R6703.1 ; v2(144.9,24.19) 144.9,27.3 140.7,31.5 134.24,31.5 128.91,36.83 v2(127.94,36.83) ; v2(24.26,6.86) 25.94,6.86 27.48,8.4 32.64,8.4 34.61,10.37 37.79,10.37 39.75,12.32 42.94,12.32 45.1,14.48 45.1,16.31 43.69,17.73 42.68,17.73 41.09,19.32 41.09,23.66 42.12,24.69 42.12,26.46 43.81,28.15 v3(44.67,28.15) ; R2021.1 134.18,63.48 v2(133.83,63.13) ; R9114.2 167.13,32.65 v2(166.9,32.87) ; v2(138.79,9.74) 138.79,11.22 139.9,12.33 143.22,12.33 v2(145.77,14.88) ; R2025.1 v2(142.77,62.1) ; v2(52.82,13.11) 52.82,12.01 52.5,11.69 R2729.1 ; v2(142.93,75.89) 143.14,76.1 R2050.1 143.21,77.34 R2043.1
  BOTTOM w1.524: 52.8,79.68 56.03,79.68 58.78,82.42 62.17,82.42 64.59,84.83 ; 91.6,119.66 86.77,114.82 86.77,110.29 84.74,108.27 84.74,106.37 83.48,105.11 83.48,103.15 79.45,99.12 79.45,95.2 69.07,84.83
  vias: v1(34.46,74.86) v1(46.8,75.76) v1(139.29,148.04) v1(141.87,92.38) v1(149.62,92) v2(14.26,70.31) v2(45.78,75.22) v2(45.79,74.54) v2(138.82,99.2) v2(139.3,99.72) v2(140.99,94.37) v2(141.63,94.29) v2(170.87,89.21) v2(171.73,89.24) v3(34.01,28.35) v3(34.87,28.35) v3(36.29,28.9) v3(45.08,28.99) v3(45.54,28.15) v3(76.57,157.08) v3(76.57,156.24) v3(86.27,150.8) v3(87.12,150.06) v3(87.88,149.43) v3(93.02,121.43) v3(93.02,120.55) v3(132.83,151.66) v3(133.67,151.66) v3(157.97,147.34) v3(158.66,147.81) v3(168.34,136.58) v3(168.94,137.18)
3D3V_S5: length 369.7
  TOP w0.305: U1702.5 154,40.84 C1703.1 154.95,40.34 v2(155.96,39.33)
  TOP w0.406: PWR1.1 215.2,154.94 AFTP6103.1 215.07,154.63 C6401.1
  TOP w0.508: Q2412.G 192.24,66.2 R2484.2 191.14,66.98 R2438.2 190.66,66.99 v2(190.17,66.5) ; PR4450.2 125.54,168.18 v2(125.55,168.17) ; v2(170.04,40.45) 169.2,39.6 R6118.1 ; v2(159.15,56.26) 159.55,55.87 R6105.1 ; v2(164.18,71.37) 164.36,71.19 Q2414.G 164.63,68.95 165.55,68.03 R2489.2 ; C6401.1 215.07,150.79 v2(214.57,150.3) ; 158.43,73.07 157.23,74.26 156.06,74.26 155.55,74.78 155.55,75.52 156.23,76.21 156.23,80.71 v2(158.26,82.74) 158.58,82.74 161.27,85.42 v2(161.27,86.18) ; R2434.1 192.5,71.06 v2(192.68,70.88) ; v2(33.73,55.78) 33.96,55.55 PR4534.1 ; C2421.1 181.43,63.08 C2416.1 182.14,62.59 R2446.1 183.03,62.59 183.76,63.32 v2(183.76,63.47) ; R2712.2 v2(22.06,27.76) ; R4031.1 126.87,148.43 v1(129.3,146) 132.18,143.12 142.95,143.12 145.05,141.02 146.82,141.02 v3(146.86,140.98) ; R2442.1 v2(182.38,53.07) ; R2498.2 184.8,55.58 184.31,55.09 Q2416.G 183.57,55.09 183.32,55.34 v2(183.32,56.02) ; PR4304.1 122.93,176.05 v2(123.44,176.56) 124.36,175.64 PD4302.2 ; PR4311.2 v2(117.47,178.21) ; R2433.2 185.16,85.08 184.62,85.62 184.62,86.25 v2(184.42,86.45) ; v2(52.96,168.8) 52.94,168.83 R3113.2 ; v2(180.96,99.72) 177.77,102.91 177.77,104.93 175.33,107.38 v3(175.33,108.63) 179.34,112.65 v2(183.29,112.65) ; R2443.1 v2(171.89,56.97) 171.89,57.45 173.26,58.81 179.09,58.81 C2415.1
  L3 w0.508: 180.52,85.71 180.52,86.08 179.78,86.82 v2(179.47,86.82) ; v2(183.32,56.02) 182.47,56.02 182.04,56.45 176.13,56.45 175.81,56.77 172.44,56.77 172.24,56.97 v2(171.89,56.97) 170.33,56.97 170.08,56.72 168.88,56.72 167.06,54.9 164.24,54.9 163.31,55.84 159.57,55.84 v2(159.15,56.26) 158.81,56.26 157.98,57.08 157,57.08 155.68,55.77 v2(155.68,55.3) ; 163.68,171.73 163.68,174.18 169.32,179.82 186.61,179.82 v2(187.16,179.27) ; v2(155.96,39.33) 157.09,38.2 163.6,38.2 164.85,39.46 169.05,39.46 v2(170.04,40.45) ; v2(192.68,70.88) 192.27,70.88 191.88,70.5 191.88,68.74 192.69,67.93 193.95,67.93 194.31,67.58 194.31,66.77 194.04,66.5 v2(190.17,66.5) 188,64.33 184.62,64.33 v2(183.76,63.47)
  L3 w1.016: v3(170.92,18.12) 168.93,18.12 167.92,17.1 162.55,17.1 160.92,15.47 v3(153.8,15.47)
  L4 w0.508: v2(180.96,99.72) 180.96,95.37 179.4,93.82 179.4,89.43 179.36,89.39 179.36,87.04 179.47,86.93 v2(179.47,86.82)
  BOTTOM w0.305: v2(157.92,64.64) 158.3,65.02 158.3,65.35 158.73,65.77 R1709.1 ; v2(179.47,86.82) 179.42,86.82 177.46,84.87 R2409.2
  BOTTOM w0.381: v2(164.18,71.37) 164.12,71.37 163.52,70.77 161.62,70.77 161.13,71.25 v2(160.22,71.25) ; R6402.1 183.27,113.46 Q6408.5
  BOTTOM w0.508: v2(187.16,179.27) 187.84,178.59 217.99,178.59 219.91,176.66 219.91,156.22 214.57,150.89 v2(214.57,150.3) ; R9110.2 165.42,31.36 164.38,32.39 160.09,32.39 159.68,31.98 R9109.2 159.52,31.2 v3(157.7,31.2) ; 31.05,29.61 30.73,29.28 28.07,29.28 27.71,28.92 23.21,28.92 v2(22.06,27.76) ; v2(182.38,53.07) 182.38,53.99 183.32,54.93 v2(183.32,56.02) 183.32,58.14 184.24,59.06 184.24,59.95 183.56,60.63 183.56,62.16 183.88,62.48 183.88,63.35 v2(183.76,63.47) ; v2(161.27,86.18) 161.91,86.83 R1711.1 ; v2(123.44,176.56) 123.44,175.04 125.55,172.93 v2(125.55,168.17) ; v2(157.08,133.76) 157.08,132.62 156.66,132.2 R4026.1 ; R6402.1 v2(183.29,112.65)
  vias: v1(27.95,70.25) v1(36.67,26.3) v1(39.51,71.84) v1(42.22,15.23) v1(42.62,70.32) v1(93.43,113.8) v1(158.24,68.77) v2(154.93,129.44) v2(172.26,111.47) v3(27.42,71.48) v3(28.26,71.48) v3(28.64,56.55) v3(28.64,55.72) v3(28.64,54.88) v3(29.09,71.48) v3(29.93,71.48) v3(33.55,33.8) v3(34.19,32.91) v3(34.19,32.03) v3(34.44,33.8) v3(35.08,32.91) v3(35.08,32.03) v3(35.33,33.8) v3(35.97,32.91) v3(35.97,32.03) v3(36.22,33.8) v3(39.33,70.34) v3(40.17,70.34) v3(41.01,70.34) v3(42.18,16.3) v3(42.81,15.74) v3(42.99,16.62) v3(43.53,15.04) v3(58.08,174) v3(58.92,174) v3(60.34,12.29) v3(61.18,12.29) v3(62.01,12.29) v3(82.81,10.75) v3(83.64,10.75) v3(84.48,10.75) v3(91.29,102.97) v3(91.81,102.25) v3(91.81,101.41) v3(93.67,112.33) v3(93.67,111.5) v3(93.67,110.66) v3(98.34,135.78) v3(98.34,134.88) v3(98.34,133.99) v3(103.52,145.87) v3(104.57,146.54) v3(105.48,146.56) v3(135.63,10.76) v3(136.47,10.76) v3(137.31,10.76) v3(141.35,160.05) v3(142.36,160.05) v3(143.5,160.05) v3(146.86,140.14) v3(147.7,140.14) v3(149.24,139.97) v3(153.02,139.82) v3(153.47,139.05) v3(154.26,138.41) v3(155.01,57.02) v3(155.63,57.59) v3(156.25,58.22) v3(158.2,129.84) v3(158.78,129.19) v3(158.78,128.35) v3(162.99,169.59) v3(163.83,169.59) v3(163.83,168.76) v3(167.74,124.55) v3(167.74,123.71) v3(167.74,122.88) v3(168.94,111.36) v3(168.94,110.53) v3(169.78,111.36)
3D3V_S5_KBC: length 546.3
  TOP w0.203: KBC24.65 172.79,80.61 172.6,80.8 172.6,81.18 ; KBC24.5 188.33,69.81 188.18,69.96 188.18,70.12 187.91,70.39 187.39,70.39 186.08,71.7 185.53,71.7 ; KBC24.43 183.68,83.28 v2(183.63,83.33) ; KBC24.22 187.28,76.61 v2(187.05,76.39) ; KBC24.103 177.68,68.2 177.73,68.26 ; KBC24.115 182.48,65.81 182.65,65.64 183.46,65.64 183.91,65.18 v2(183.91,64.97) ; v2(190.85,74.96) 190.41,75.41 KBC24.19
  TOP w0.254: v2(190.85,74.96) 191.2,74.62 191.5,74.62 C2413.1
  TOP w0.381: U2401.5 178.49,54.17 179.55,53.11 v2(179.55,52.27)
  TOP w0.508: v2(158.9,42.36) 158.8,42.45 156.99,42.45 156.54,42 156.54,41.16 PR8314.1 ; R2496.2 167.58,79.1 168.67,78.01 v2(169.75,78.01) 169.77,78.04 170.81,78.04 R2450.2 ; v2(146.1,140.32) 146.03,140.38 144.78,140.38 142.68,142.48 131.69,142.48 v1(126.99,147.19) 125.98,148.2 R4032.1 ; v2(157.86,169.07) 157.82,169.04 D4305.2 ; v2(179.47,86.12) 179.69,86.12 180.13,86.56 180.13,87.33 R2462.2 ; v2(156.66,100.17) 157.16,100.67 157.16,101.82 157.99,102.64 160.13,102.64 163.54,106.05 163.54,106.77 164.44,107.68 164.44,108.37 165.58,109.51 v2(165.58,110.4) ; R2446.2 183.65,61.27 R2420.2 184.14,61.3 v2(184.48,61.64) ; R2424.2 192.77,76.42 193.24,76.42 193.4,76.26 193.4,76.26 v2(193.42,76.25) ; 185.53,71.7 184.8,71.7 184.13,72.37 182.4,72.37 182.21,72.55 v2(180.57,72.55) 177.73,69.71 177.73,68.26 ; v2(153.79,169.07) 153.76,169.04 D4304.2 153.76,156.41 161.57,148.6 v2(163.7,148.6) ; v2(171.96,86.76) 173.03,85.69 173.03,84.93 173.44,84.51 C2417.1 174.1,83.56 v2(174.7,82.96) 174.7,82.94 174.04,82.28 173.1,82.28 172.6,81.77 172.6,81.18 ; v2(178.47,59.48) 178.45,59.5 C2414.1 ; v2(170.21,76.43) 170.75,76.43 R2478.2 ; v2(158.6,176.7) 158.6,173.87 159.04,173.43 159.04,171.4 159.55,170.88 161.39,170.88 161.79,170.49 v2(161.79,169.18) 161.89,169.08 D4306.2 ; v2(183.91,64.97) 183.91,64.56 C2422.1
  L3 w0.508: v2(147.27,178.19) 154.6,178.19 156.09,176.7 v2(158.6,176.7) ; v2(180.72,106.77) 176.75,110.74 173.98,110.74 172.95,109.71 168.55,109.71 167.16,111.09 166.28,111.09 v2(165.58,110.4) ; v2(160.14,16.54) 153.59,16.54 v2(153.53,16.61) ; v2(193.42,76.25) 193.42,76.43 192.83,77.02 188.55,77.02 187.92,76.39 v2(187.05,76.39) ; v2(193.42,76.25) 192.14,74.96 v2(190.85,74.96) 189.96,74.07 189.96,72.91 188.75,71.71 187.43,71.71 186.34,72.79 185.51,72.79 185.03,73.27 184,73.27 183.06,72.34 182.38,72.34 182,72.72 180.74,72.72 v2(180.57,72.55) 179.92,72.55 178.28,74.19 178.28,74.69 v2(177.4,75.58) 175.47,75.58 174.63,74.74 v2(172.23,74.74) ; v2(193.42,76.25) v2(194.7,74.97) ; v2(193.2,63.08) 191.95,61.83 189.59,61.83 189.24,61.47 184.65,61.47 184.49,61.64 v2(184.48,61.64) ; v2(164.92,42.3) 164.46,42.77 159.3,42.77 v2(158.9,42.36) ; v2(171.96,86.76) 173.59,86.76 174.42,85.92 177.98,85.92 178.18,86.12 v2(179.47,86.12) ; v2(186.3,52.96) 185.5,52.96 184.76,53.7 181.88,53.7 180.46,52.27 v2(179.55,52.27) 179.55,52.43 179.33,52.65 175.82,52.65 174.8,51.63 169.19,51.63 168.07,52.75 v2(165.97,52.75) ; v2(174.7,82.96) 174.59,83.07 174.59,83.67 175.1,84.17 179.64,84.17 180.22,84.75 182.21,84.75 v2(183.63,83.33) ; v2(193.51,67.26) 192.18,67.26 190.34,69.09 185.9,69.09 185.54,69.45 184.49,69.45 v2(184.46,69.42) 183.52,69.42 182.78,68.68 182.78,68.45 181.71,67.39 175.22,67.39 174.36,68.25 173.78,68.25 173.76,68.23 173.58,68.23 v2(173.08,67.73)
  L4 w0.508: v2(179.47,86.12) 179.23,86.12 178.71,86.65 178.71,89.63 178.76,89.69 178.76,94.26 180.33,95.83 180.33,101.52 180.86,102.06 181.23,102.43 181.23,103.93 180.72,104.43 180.72,106.77 v2(180.72,106.77) ; v2(164.92,42.3) 164.44,42.79 164.44,44.64 165.27,45.47 165.27,50.07 165.97,50.77 v2(165.97,52.75) ; v2(165.58,110.4) 165.58,114.46 167.14,116.02 167.14,118.15 167.9,118.91 167.9,121.23 166.6,122.53 166.6,127.48 166.22,127.86 v2(166.22,128.58) ; v2(161.79,169.18) 161.68,169.07 v2(157.86,169.07) v2(153.79,169.07) ; v2(183.91,64.97) 184.4,64.48 184.4,61.73 184.48,61.65 v2(184.48,61.64) ; v2(162.16,140.53) 162.19,140.55 162.19,146.2 163.7,147.72 v2(163.7,148.6) ; v2(171.96,86.76) 171.94,86.74 171.94,86.4 171.27,85.73 171.27,84.66 171.27,84.66 171.27,84.41 171.24,84.39 171.24,84.01 171.24,84.01 171.24,83.04 170.71,82.5 170.71,81.93 170.71,80.43 170.63,80.35 170.63,78.74 169.9,78.01 v2(169.75,78.01) 170.21,77.55 v2(170.21,76.43) 171.09,76.43 172.18,75.34 172.18,74.78 v2(172.23,74.74) 171.75,74.26 171.75,69.06 v2(173.08,67.73) ; v2(160.14,16.54) 160.14,18.7 162.43,20.99 162.43,25.68 160.83,27.29 160.83,36.69 158.69,38.83 158.69,39.35 158.9,39.56 v2(158.9,42.36)
  BOTTOM w0.356: 187.99,76.16 188.05,76.22 188.51,76.22 188.64,76.08 RN2603.2 ; 187.99,76.16 RN2603.1 ; 187.99,76.16 187.74,76.41 187.08,76.41 v2(187.05,76.39)
  BOTTOM w0.508: v2(147.27,178.19) 146.7,177.62 144.12,177.62 143.57,178.17 118.71,178.17 117.92,177.38 107.3,177.38 100.18,170.26 100.18,167.34 PR4412.1 PR4411.1 ; v2(178.47,59.48) 178.68,59.7 178.68,61.93 178.15,62.46 178.15,66.17 178.87,66.9 178.87,71.47 178.16,72.18 178.16,72.66 178.16,72.67 178.16,73.51 177.52,74.15 177.52,74.22 177.4,74.34 v2(177.4,75.58) ; v2(184.48,61.64) 185.8,60.32 185.8,54.78 186.42,54.16 186.42,53.08 v2(186.3,52.96) ; R2415.2 173.08,67.94 v2(173.08,67.73) ; C2429.1 187.03,76.36 v2(187.05,76.39) ; R2607.1 160.29,100.75 158.89,100.75 158.6,101.04 157.53,101.04 v2(156.66,100.17) 156.59,100.1 156.59,99.26 156.29,98.96 R2608.1 ; v2(153.53,16.61) 153.53,17.31 R2476.2 ; R2414.2 160.14,17.35 v2(160.14,16.54) ; v2(166.22,128.58) 165.82,128.99 161.61,128.99 159.31,131.28 159.31,134.84 162.16,137.69 v2(162.16,140.53) 159.13,143.55 146.6,143.55 146.1,143.05 v2(146.1,140.32)
3D3V_S5_PCH: length 126.6
  TOP w0.381: v2(139.25,68.67) 140.66,67.26 140.9,67.26 141.69,66.48 v2(141.69,65.45)
  TOP w0.508: v2(140.52,76.52) 139.94,77.1 139.94,79.31 v2(140.7,80.07) 141.58,79.19 R1731.1 145.22,79.19 v1(146.35,80.32) 147.1,81.07 147.21,81.07 147.23,81.09 v2(148.49,81.09) ; v2(151.9,69.69) 151.12,69.69 149.76,71.04 R2039.1 149.76,72.17 R2007.1 152.43,72.18 v2(153.79,73.54) 155.93,73.54 157.76,71.71 v2(158.69,71.71) ; v2(148.89,56.67) 148.94,56.62 150.38,56.62 152.43,54.57 152.43,50.78 152.04,50.39 v2(151.11,50.39)
  L3 w0.508: v2(149.91,103.12) 147.63,103.12 147.23,103.51 138.77,103.51 137.17,101.91 135.67,101.91 135.55,101.79 134.85,101.79 134.55,101.49 133.89,101.49 133.51,101.11 133.51,100.41 v2(133.61,100.31) ; v2(140.52,76.52) 140.65,76.64 141.74,76.64 141.83,76.74 143.12,76.74 143.69,76.17 144.9,76.17 144.95,76.22 146.12,76.22 147.05,75.28 148.33,75.28 149.24,74.37 150.43,74.37 151.53,73.27 153.52,73.27 v2(153.79,73.54)
  L4 w0.508: v3(138.94,56.33) 138.94,59.7 136.63,62.01 135.41,62.01 135.01,62.4 135.01,63.07 v2(135.01,63.08) ; v2(151.63,92.76) 151.8,92.94 151.8,94.98 150.48,96.29 150.48,98.39
  BOTTOM w0.356: 154.96,52.74 154.66,53.05 RN2502.4 153.97,53.69 153.82,53.84 153.52,53.84 153.32,53.64 RN2502.3
  BOTTOM w0.381: R1834.1 139.3,68.62 v2(139.25,68.67)
  BOTTOM w0.508: 142.79,64.77 143.46,64.11 143.46,61.79 142.98,61.31 140.15,61.31 ; v2(148.89,56.67) 148.23,56.01 R2501.2 147.94,57.01 147.32,57.63 147.32,62.21 147.44,62.32 147.44,62.76 149.34,64.67 149.34,66.43 150.98,68.07 ; v2(135.01,63.08) 135.01,63.78 R1814.1 ; 151.54,86.53 151.54,92.07 151.63,92.16 v2(151.63,92.76) ; 154.96,52.74 155.17,52.53 R2515.2 v2(155.17,50.49) ; R2041.1 140.61,79.98 v2(140.7,80.07) ; R1835.1 140.14,76.14 v2(140.52,76.52)
  vias: v2(149.61,99.16) v2(150.25,99.18) v2(150.32,50.42)
