# Allegro board 14291-1.0917WZS2026.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
TP2015  TPAD14-OP-GP  [TPAD14-OP]  139.55 82.66 180 bottom
TP2016  TPAD14-OP-GP  [TPAD14-OP]  141.14 82.55 180 bottom
TP2017  TPAD14-OP-GP  [TPAD14-OP]  137.17 84.03 0 top
TP2101  TPAD14-OP-GP  [TPAD14-OP]  130.31 78.83 0 top
TP2102  TPAD14-OP-GP  [TPAD14-OP]  129.4 76.87 0 top
TP2301  TPAD14-OP-GP  [TPAD14-OP]  94.86 95.33 0 top
TP2302  TPAD14-OP-GP  [TPAD14-OP]  93.47 94.14 0 top
TP2303  TPAD14-OP-GP  [TPAD14-OP]  94.91 72.52 0 top
TP2304  TPAD14-OP-GP  [TPAD14-OP]  94.97 70.71 0 top
TP2305  TPAD14-OP-GP  [TPAD14-OP]  136.65 72.22 0 top
TP2306  TPAD14-OP-GP  [TPAD14-OP]  135.35 72.83 0 top
TP2307  TPAD14-OP-GP  [TPAD14-OP]  135.33 96.38 0 top
TP2308  TPAD14-OP-GP  [TPAD14-OP]  135.66 94.3 0 top
TP2702  TPAD14-OP-GP  [TPAD28]  31.32 11.01 0 top
TP3101  TPAD14-OP-GP  [TPAD14-OP]  49.34 174.28 0 top
TP3103  TPAD14-OP-GP  [TPAD14-OP]  47.96 172.73 0 top
TP4404  TPAD14-OP-GP  [TPAD14-OP]  104.64 161.32 0 top
TP4405  TPAD14-OP-GP  [TPAD14-OP]  105.47 166.65 180 bottom
TP4501  TPAD14-OP-GP  [TPAD14-OP]  43.25 56.19 0 top
TP6102  TPAD14-OP-GP  [TPAD14-OP]  165.49 51.62 0 top
TP6103  TPAD14-OP-GP  [TPAD14-OP]  167.47 52 0 top
TP7501  TPAD14-OP-GP  [TPAD14-OP]  201.14 153.45 0 top
TP7502  TPAD14-OP-GP  [TPAD14-OP]  198.47 155.91 0 top
TP7503  TPAD14-OP-GP  [TPAD14-OP]  201.01 149.31 0 top
TP7504  TPAD14-OP-GP  [TPAD14-OP]  197.89 153.04 0 top
TP7505  TPAD14-OP-GP  [TPAD14-OP]  194.91 149.18 0 top
TP7601  TPAD14-OP-GP  [TPAD14-OP]  176.05 134.49 180 bottom
TP7602  TPAD14-OP-GP  [TPAD14-OP]  178.51 134.5 180 bottom
TP7603  TPAD14-OP-GP  [TPAD14-OP]  201.42 141.56 0 top
TP7604  TPAD14-OP-GP  [TPAD14-OP]  199.31 141.99 0 top
TP7605  TPAD14-OP-GP  [TPAD14-OP]  177.28 134.5 180 bottom
TP7606  TPAD14-OP-GP  [TPAD14-OP]  189.59 127.94 180 bottom
TP8301  TPAD14-OP-GP  [TPAD14-OP]  150.24 36.97 0 top
TP9903  TPAD14-OP-GP  [TPAD14-OP]  141.44 58.38 0 top
TP9904  TPAD14-OP-GP  [TPAD14-OP]  130.02 62.87 270 bottom
TP9905  TPAD14-OP-GP  [TPAD14-OP]  144.02 62.99 180 bottom
TP9906  TPAD14-OP-GP  [TPAD14-OP]  126.11 28.48 0 top
TP9907  TPAD14-OP-GP  [TPAD14-OP]  126.11 29.75 0 top
TP9908  TPAD14-OP-GP  [TPAD14-OP]  110.28 92.48 0 top
TP9909  TPAD14-OP-GP  [TPAD14-OP]  110.69 90.74 45 top
TP9910  TPAD14-OP-GP  [TPAD14-OP]  102.36 97.53 0 top
TP9911  TPAD14-OP-GP  [TPAD14-OP]  102.24 101.53 180 bottom
TP9914  TPAD14-OP-GP  [TPAD14-OP]  103.47 101.5 180 bottom
TP9915  TPAD14-OP-GP  [TPAD14-OP]  104 100.33 180 bottom
TP9916  TPAD14-OP-GP  [TPAD14-OP]  105.81 100.17 180 bottom
TP9917  TPAD14-OP-GP  [TPAD14-OP]  106.9 100.77 270 bottom
TP9918  TPAD14-OP-GP  [TPAD14-OP]  101.53 92.61 0 top
TP9919  TPAD14-OP-GP  [TPAD14-OP]  105.44 97.22 0 top
TP9921  TPAD14-OP-GP  [TPAD14-OP]  137.95 66.94 90 bottom
TP9922  TPAD14-OP-GP  [TPAD14-OP]  131.7 91.51 90 top
TP9923  TPAD14-OP-GP  [TPAD14-OP]  132.92 94.96 90 top
TP9924  TPAD14-OP-GP  [TPAD14-OP]  86.99 93.5 90 bottom
TP9925  TPAD14-OP-GP  [TPAD14-OP]  90.09 96.6 90 bottom
TP9926  TPAD14-OP-GP  [TPAD14-OP]  89.03 95.99 90 bottom
TP9927  TPAD14-OP-GP  [TPAD14-OP]  99.25 93.42 90 top
TP9928  TPAD14-OP-GP  [TPAD14-OP]  91.74 93.68 90 bottom
TP9929  TPAD14-OP-GP  [TPAD14-OP]  88.95 97.21 90 bottom
TP9930  TPAD14-OP-GP  [TPAD14-OP]  86.93 94.77 90 bottom
TP9931  TPAD14-OP-GP  [TPAD14-OP]  100.46 93.21 90 top
TP9932  TPAD14-OP-GP  [TPAD14-OP]  88.26 93.5 90 bottom
TP9933  TPAD14-OP-GP  [TPAD14-OP]  91.36 96.78 90 bottom
TP9934  TPAD14-OP-GP  [TPAD14-OP]  89.22 90.34 90 bottom
TP9935  TPAD14-OP-GP  [TPAD14-OP]  91.55 92.13 90 bottom
TP9936  TPAD14-OP-GP  [TPAD14-OP]  90.49 90.34 90 bottom
TP9937  TPAD14-OP-GP  [TPAD14-OP]  87.78 92.11 90 bottom
TP9938  TPAD14-OP-GP  [TPAD14-OP]  91.76 90.34 180 bottom
TP9939  TPAD14-OP-GP  [TPAD14-OP]  89.07 92.08 180 bottom
TP9940  TPAD14-OP-GP  [TPAD14-OP]  89.18 88.74 90 bottom
TP9941  TPAD14-OP-GP  [TPAD14-OP]  91.71 88.97 90 bottom
TP9942  TPAD14-OP-GP  [TPAD14-OP]  90.4 88.76 90 bottom
TP9943  TPAD14-OP-GP  [TPAD14-OP]  90.32 92.16 90 bottom
TP9944  TPAD14-OP-GP  [TPAD14-OP]  105.42 94.14 90 top
TP9945  TPAD14-OP-GP  [TPAD14-OP]  105.18 98.96 90 top
TP9946  TPAD14-OP-GP  [TPAD14-OP]  106.37 95.97 90 top
TP9947  TPAD14-OP-GP  [TPAD14-OP]  106.5 98.05 90 top
TPAD1  ACES-CON8-40-GP  [50505-0084N-002]  63.9 77.27 90 top
TR3301  FILTER-4P-137-GP  [L125100-4P-1H28]  173.82 29.94 180 bottom
TR3406  FILTER-4P-137-GP  [L125100-4P-1H28]  173.86 27.08 180 bottom
TR3601  FILTER-4P-137-GP  [L125100-4P-1H28]  20.34 37.42 0 bottom
TR3602  FILTER-4P-137-GP  [L125100-4P-1H28]  26.38 29.26 0 top
TR5501  FILTER-4P-137-GP  [L125100-4P-1H28]  82.14 159.81 0 top
U1701  74LVC1G07GW-GP  [SC70-5H44]  94.96 103.23 180 bottom
U1702  74LVC1G07GW-GP  [SC70-5H44]  154.3 42.6 270 top
U2401  AZAW1210C-R7G-GP  [SC70-6H44]  176.9 54.17 270 top
U3201  AZ1045-04F-R7G-GP  [DFN10G2510H26]  32.67 174.1 90 top
U3202  AZ1045-04F-R7G-GP  [DFN10G2510H26]  33.4 176.18 270 bottom
U3501  SY6288DAAC-GP  [SOT-23-5H56]  23.49 40.03 270 top
U3502  SY6288DAAC-GP  [SOT-23-5H56]  22.7 33.11 270 top
U3503  SY6288DAAC-GP  [SOT-23-5H56]  186.34 39.82 90 bottom
U3601  AZ1045-04F-R7G-GP  [DFN10G2510H26]  16.76 43.21 270 bottom
U3602  AZ1045-04F-R7G-GP  [DFN10G2510H26]  16.63 32.92 270 bottom
U4001  G5016KD1U-GP  [DFN14J3020-G255D85H32]  37.84 30.89 0 top
U4002  M5938ARD1U-GP-U  [DFN8F3-G2416-1H32]  161.81 121.91 90 bottom
U4003  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  153.66 128.43 180 bottom
U4005  74LVC1G07GW-GP  [SC70-5H44]  156.84 128.55 0 bottom
U4006  M5938ARD1U-GP-U  [DFN8F3-G2416-1H32]  161.98 115.2 270 bottom
U4101  SY6288C10CAC-GP  [MSOP8-1H44]  153.04 82.24 270 bottom
U5501  RT9724GB-GP  [SOT-23-5H51]  81.62 156.85 90 bottom
U6001  AZ1045-04F-R7G-GP  [DFN10G2510H26]  181.22 24.16 270 bottom
U6002  AO6402A-GP  [SOT-6-1H50]  179.85 33.54 270 top
U6101  AO6402A-GP  [SOT-6-1H50]  162.07 61.29 0 top
U6701  LNG2DMTR-GP  [LGA12G2H40]  171.44 93.76 270 bottom
U7301  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  177.79 124.56 270 bottom
U8301  G5016KD1U-GP  [DFN14J3020-G255D85H32]  171.31 132.72 180 bottom
U9101  NPCT650JAAYX-GP  [QFN32G5-G3D6H32]  166.11 25.43 180 bottom
USB1  SKT-USB13-18-GP-U  [SKT-USB13-160166-2]  2.87 44.87 90 bottom
USB2  SKT-USB13-18-GP-U  [SKT-USB13-160166-2]  2.87 24.87 90 bottom
VGABD1  HRS-CON16-2-GP  [TF31-16S-0D5SH-800]  198.5 79.27 90 top
VRAM1  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  201.75 168.52 90 bottom
VRAM2  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  178.75 168.52 270 bottom
VRAM3  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  201.75 168.52 270 top
VRAM4  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  178.75 168.52 90 top
WLAN1  SKT-MINI67P-12-GP-U  [NFSA0-S6705-TP40]  165.9 53.77 90 bottom
X1801  XTAL-24MHZ-81-GP  [OSC-3225-4P-4H36]  120.63 105.09 0 bottom
X1802  XTAL-32D768KHZ-68-GP  [SMD49-6914-0603H56]  151.54 77.34 0 bottom
X2401  XTAL-32D768KHZ-83-GP  [SMD49-3215-0713H36]  175.64 62.33 0 top
X3101  XTAL-25MHZ-181-GP  [OSC-3225-4P-4H36]  45.43 176.61 180 top
X7601  XTAL-27MHZ-85-GP-U  [OSC-3225-4P-4H30]  211.6 137.28 0 bottom
XF3103  XFORM-24P-101-GP  [XFORM24C1510H168]  22.26 172.27 270 bottom

## Library data of the parts
AFTP2501 AFTP2502 AFTP2801-AFTP2803 AFTP2901-AFTP2904 AFTP3101-AFTP3108 AFTP3401-AFTP3406 AFTP3801-AFTP3803 AFTP3805-AFTP3807 AFTP3902-AFTP3910 AFTP5601 AFTP5801-AFTP5807 AFTP6101-AFTP6104 AFTP6201-AFTP6203 AFTP6206-AFTP6208 AFTP6213-AFTP6248 AFTP6301-AFTP6308 AFTP6311 AFTP6314 AFTP8902-AFTP8904 = AFTE14P-75: tolerance: ZZ.AFT14.101
BATT1 = 200277MR008G121ZR-U: tolerance: 20.81153.008
C715 C1207-C1209 C1317 C1318 C1323 C2601 C2706 C2708 C2712 C2713 C6112 C6703 C7323 C7604 C7813 C7815 PC1055-PC1061 PC5116 PC5117 PC5403 PC8303 PC8304 PC8306 PC8307 PC8309 PC8310 = C603H38: tolerance: 78.10610.5BL
C716 C717 C719 C722 C1101-C1103 C1116 C1117 C1136 C1138 C1147-C1154 C1172-C1175 C1180 C1212-C1216 C1303 C1304 C1307 C1321 C1322 C1901 C1902 C2101-C2109 C2116 C2117 C2120 C2418 C2426 C2703 C2704 C3110 C3113 C3508 C3510 C3511 C3516 C3518 C4018 C4021 C4031 C4032 C4101 C4102 C5536 C7312 C7319 C7711-C7714 C7728 C7736 C8305 C8307 C9202 EC1001 EC1003 EC1004 EC9718-EC9720 EC9722 EC9725 EC9732-EC9734 EC9736-EC9738 PC4631 PC4708 PC4808 PC5309 PC5408 PC5409 PC8301 = C402H22: tolerance: 78.10523.5FL
C718 C720 C721 C1201-C1204 C1206 C1210 C1211 C1217 C1218 C1220-C1222 C1301 C1302 C1306 C1308-C1316 C1702 C1703 C2110-C2112 C2118 C2119 C2406-C2408 C2410-C2414 C2416 C2420-C2423 C2428 C2429 C2502 C2504 C2602 C2605 C2608-C2610 C2612 C2707 C2709 C2710 C2714 C2717 C2719-C2721 C3102 C3105 C3106 C3108 C3112 C3114-C3118 C3406 C3504 C3507 C3509 C3517 C3603 C3618 C4003 C4006 C4008 C4014 C4019 C4020 C4029 C4030 C5401 C5538 C6001 C6007 C6107 C6109 C6401 C6501-C6504 C6701 C6702 C7318 C7501 C7502 C7505 C7506 C7601 C7602 C7605 C7729 C7734 C7735 C7804 C7820 C7821 C7827 C7829-C7836 C7909 C7910 C7912 C7913 C7921-C7923 C7925 C7927-C7930 C8303 C9102-C9105 C9201 EC1707-EC1709 EC1711 EC1712 EC1805-EC1808 EC1902 EC2401 EC2601 EC4001 EC6405-EC6407 EC6507 PC4517 PC4518 PC5103 PC5106 PC5115 PC5121 PC5407 PC8201 = C402H22: tolerance: 78.10421.2FL
C1176 C1183 C1704 C2501 C2505 C4004 C4005 C4007 C4012 C4013 C4016 C6002 C6008 C7517 C8301 C8304 = C805H54: tolerance: 78.10623.51L
C1181 C1184 C2113-C2115 C4017 C7326 C7518 C7520 C7710 C7717 PC1001-PC1037 PC1041-PC1044 PC1046-PC1054 PC1062 PC1063 PC1065-PC1098 PC5302 PC5402 PC5404 = C603H40: tolerance: 78.22610.5BL
C1182 C3512-C3515 C3519 PC1038 PC1039 PC1064 PC5123-PC5128 PC5303 PC5307 PC5308 = C805H58: tolerance: 78.22610.51L
C1205 C1305 C2415 C2417 C2705 PC4401 PC5001 PC5304 = C603H36: tolerance: 78.22523.5BL
C1601-C1604 C3109 C3111 C3601 C3602 C3604 C3605 C5402-C5409 C5508 C5531-C5534 C5537 = C402H22: tolerance: 78.10421.2FL; signal model: C402H22_SCD1U16V2KX-3GP
C1605-C1612 C6003-C6006 C7301-C7308 = C402H22: tolerance: 78.22423.5FL; signal model: C402H22_SCD22U10V2KX-1GP
C1701 C2402 PC4609 PC5306 = C402H22: tolerance: 78.22124.2FL
C1801 C1802 C3101 C3107 PC4604 PC4619 = C402H22: tolerance: 78.15034.1FL
C1803 C1804 = C402H22: tolerance: 78.5R074.1FL
C2403 PC8205 PC8217 PC8219 PC8222 = C402H22: tolerance: 78.47034.1FL
C2405 C2613 EC2905-EC2908 PC4621 PC8305 = C402H22: tolerance: 78.10134.1FL
C2409 C3119 PC4303-PC4305 PC4309 PC4413 PC4531 PC4602 PC4607 PC4626 PC4629 PC5102 PC8204 PC8308 = C402H22: tolerance: 78.10324.2FL
C2424 C2425 C5540 C5541 EC1801 EC1802 EC1901 EC2503 EC2505 EC2602 EC2701 EC3101-EC3108 EC4306 EC4309 EC4310 EC5504 PC4617 = C402H22: tolerance: 78.10034.1FL
C2427 C2435 C2441 C2603 C2607 PC4410 PC4612 PC4618 PC4709 PC4810 PC5031 = C402H22: tolerance: 78.22224.2FL
C2503 C4028 PC5118 PC5311 = C402H22: tolerance: 78.22423.5FL
C2604 C2611 C2701 C2702 C2711 C2715 C2716 C2718 C2907 C2908 C3103 C3104 C4009 C5505 C5539 C6108 C7310 C7315 C7317 C7324 C7513 C7514 C7603 C7701-C7704 C7708 C7709 C7719-C7726 C7730-C7732 C9101 C9106 PC4526 PC5120 = C603H36: tolerance: 78.47520.5BL
C2606 C4001 C4002 C6110 C6111 C8302 C8306 PC4613-PC4615 = C402H22: tolerance: 78.47124.2FL
C2723 EC1710 EC1713 EC2708 EC2709 EC9201 EC9202 PC5227 = C402H22: tolerance: 78.22034.1FL
C3201 = C1808H56: tolerance: 78.1013N.1AL
C4201-C4203 PC4634 = C402H22: tolerance: 78.22321.2FL
C5515 C5516 EC1702-EC1704 EC1706 EC1903 EC2002 EC2704 EC2706 EC2707 EC2901-EC2904 EC5102 EC5103 EC6001 EC6401 EC9745 PC4605 PC4608 PC4611 PC4620 PC4622 PC4625 PC4627 PC4632 PC4633 PC8203 = C402H22: tolerance: 78.10224.2FL
C5535 C5542 EC5101 PC4302 PC4409 PC4419 PC4516 PC4525 PC4530 PC4535 PC5113 PC5119 PC5305 PC8207 PC8211 PC8216 = C603H36: tolerance: 78.10424.2BL
C6009 C6113 PC5406 = C402H22: tolerance: 78.47224.2FL
C7316 EC1002 EC1005 EC2703 EC2705 EC4302-EC4304 EC4307 EC4311-EC4314 EC5301 EC5505 EC6402 EC6403 EC9701-EC9717 EC9721 EC9723 EC9724 EC9735 EC9739 EC9743 EC9744 PC4402-PC4404 PC4411 PC4420-PC4422 PC4610 PC4628 PC4630 PC4710 PC4811 PC5002 PC8202 PC8220 PC8221 PC8225 PC8226 = C402H22: tolerance: 78.10422.5FL
C7507 C7525 C7805 C7810-C7812 C7814 C7816 C7817 C7822 C7906 C7911 C7915-C7917 C7919 C7924 C7926 PC4524 PC5101 PC5104 PC5401 = C603H36: tolerance: 78.10523.2BL
C7606 PC4707 PC4807 = C402H22: tolerance: 78.22523.5FL
C7607 C7608 PC4522 PC4523 = C402H22: tolerance: 78.18034.1FL
C7609 C7610 PC8223 = C402H22: tolerance: 78.27224.2FL
C7803 C7902 = C402H22: tolerance: 78.82124.2FL
CPU1 = BGA1356M4224-U2H52: tolerance: 071.SKYLA.000U
D502 D1217 D1319 ED6401 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
D1701 D4004 D4005 PD4404 = SOD323AKH42: tolerance: 83.04148.D1H
D1702 D5401 = SOT-23-10H44: tolerance: 75.00056.07D
D1703 D2402 D2403 D2405 D4001 = SOD323AKH38: tolerance: 83.R2004.G8F
D2501 = SOT-23-9H44: tolerance: 75.00040.07D
D2601 = SOD323AKH38: tolerance: 83.R5003.H8H
D2701 D5502 D5503 D8301 = SOT23-2D4-312H48: tolerance: 75.00054.E7D
D4002 = SOT23-2D4-312H44: tolerance: 83.00016.K11
D4304-D4306 PD4302 = SOT23-2D4-312H44: tolerance: 75.00099.O7D
D7301 = SOT23-2D4-312H44: tolerance: 75.00054.X7D
D7601 D7602 = SOD723AKH27: tolerance: 83.00400.C1F
DB1 = HS81100: tolerance: 20.D0075.110
DB2 = 88459-047N: tolerance: 20.F1897.004
DB3 = 50696-00601-001: tolerance: 20.K0691.006
DCIN1 = 50458-00601-W01: tolerance: 20.F2132.006
DM1 = DAN06-K4406-0103-U: tolerance: 62.10017.I31
DM2 = AS0A621-J4SB-7H: tolerance: 62.10024.S11
EC1803 EC2501 EC2502 EC2504 EC2506 = C402H22: tolerance: 78.4R7B4.1FL
EC4301 PC4306 PC4405-PC4408 PC4415-PC4418 PC4519 PC4527 PC4528 PC4701-PC4705 PC4802-PC4806 PC5027 PC5029 PC5112 PC5301 PC5310 PC8210 PC8214 PC8215 PC8224 = C805H56: tolerance: 78.10622.51L
EC4308 EC9726-EC9728 PC4308 PC4412 PC4426 = C603H36: tolerance: 78.10522.5BL
EC5501 EC5502 = C402H22: tolerance: 78.6R074.1FL
EC5503 EC6102 EC6103 EC6501-EC6506 = C402H22: tolerance: 78.33034.1FL
ED301-ED306 = SOD-523-4H28: tolerance: 75.05125.070
EU3404 EU3601 EU3602 = SOT-6H58: tolerance: 075.09904.0A7C
EU5701-EU5703 = SLP2510P8-3H26: tolerance: 75.00524.A73
F5502 F5503 = POLYSW-4633-UH43: tolerance: 69.50007.A31
F5701 = POLYSW-2114H30: tolerance: 69.48001.081
FAN1 = 88631-00401-W01: tolerance: 20.F1621.004
FAN261 = SOIC8H69: tolerance: 74.02113.0E1
FPR1 LEDBD1 = 196415-06031-3: tolerance: 020.K0002.0006
G1901 G6401 G6402 = CON2O-U: tolerance: ZZ.CON2O.XXX
GPU1 = BGA595M23H83: tolerance: 71.0N14M.B0U
H1 H6 = HOLE256R126: tolerance: ZZ.00PAD.Z61
H2 H4 H5 = HOLE335R115: tolerance: ZZ.00PAD.D01
H3 = HT85BE95R29-U-5: tolerance: ZZ.00PAD.D31
H7 = HOLE296R182: tolerance: ZZ.00PAD.Y51
HCPU1-HCPU3 = HOLE197R166: tolerance: ZZ.00PAD.V71
HDA27 = QFN48J6-G465H40: tolerance: 071.03246.0003
HDD1 = 50406-02071-001: tolerance: 20.F2036.020
HDMI1 = SKT-HDMI23-188137: tolerance: 22.10296.981
HGPU1-HGPU3 = STF237R117H81: tolerance: 34.44L12.001
HPMIC1 = PAD-2SJ3095-060111F-U-1: tolerance: ZZ.00PAD.IB1
IOBD1 = 88513-180N-W01: tolerance: 20.K0707.018
IRCCD1 = 50208-0060N-001: tolerance: 20.F1550.006
KB1 = FL4S030HT6R300-DT: tolerance: 20.K0592.030
KBC24 = TQFP128-2H48: tolerance: 071.01404.000E
KBLIT1 = 51575-00401-W01: tolerance: 20.K0800.004
L2901-L2904 = L1608-UH38: tolerance: 68.00206.021
L7301 = L603H38: tolerance: 68.00335.151
L7501 L7601 = L603H38: tolerance: 68.00335.051
L7602 = L603H38: tolerance: 68.00909.261
LCD1 = 51540-04001-W01: tolerance: 20.K0678.040
LOM31 = QFN32J4-G2D85H36: tolerance: 71.08111.U03
MESW1 = JSD1210-0111FC: tolerance: 62.40018.691
PC4301 = C805H58: tolerance: 78.10594.41L
PC4310 = C402H22: tolerance: 78.47420.5FL
PC4414 PC4623 = C402H22: tolerance: 78.47322.2FL
PC4423 PC4424 = C603H36: tolerance: 78.10134.1BL
PC4509 PC4529 PC5109 PC5111 PC5114 PC8208 PC8209 PC8212 PC8213 = C805H54: tolerance: 78.47522.51L
PC4520 = C603: tolerance: 78.33124.2BL
PC4536 = C603: tolerance: 78.56124.2BL
PC4601 = C402H22: tolerance: 78.15224.2FL
PC4603 = C402H22: tolerance: 78.10224.2FL; signal model: C402H22_SC1KP50V2KX-1GP
PC4606 = C402H22: tolerance: 78.15322.2FL
PC4616 = C402H22: tolerance: 78.56321.2FL
PC4706 PC4809 PC5008 = C603H40: tolerance: 78.22422.2BL
PC5122 PC8206 PC8218 = C402H22: tolerance: 78.33124.2FL
PC5405 = C402H22: tolerance: 78.68034.1FL
PC8302 = C402H22: tolerance: 78.22044.1FL
PD4301 = D5436AKH97: tolerance: 83.P6SBM.AAG
PD4303 = SOT-23-10H44: tolerance: 83.0024V.0A1
PD4304 = SOD123FLAKH40: tolerance: 83.SMF18.0AH
PD4402 PD4403 PD4405 = SOD323AKH40: tolerance: 83.1R504.B8F
PG4401-PG4403 PG4409-PG4417 PG4532 PG4535 PG4601 PG4707 PG4708 PG4808 PG4809 PG5021 PG5022 PG5107 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG4404-PG4407 PG4518 PG4520 PG4521 PG4524 PG4525 PG4531 PG4534 PG4536 PG4542 PG4543 PG5023-PG5031 PG5101-PG5106 PG5124 PG5211-PG5214 PG5301-PG5310 PG5404-PG5407 PG8301-PG8307 = GAP-CLOSE-PWR: tolerance: ZZ.CON2d.XXX
PL4401 = L7066-1830-UH119: tolerance: 68.4R71A.20H
PL4501 = L736630-MH119: tolerance: 68.2R210.20B
PL4502 = L736630H119: tolerance: 68.3R310.20A
PL4701 PL4801 = L7366-1930H158: tolerance: 68.R1510.20A
PL5001 PL5101 = L736630H119: tolerance: 68.R4710.10M
PL5301 = L686647-127318H119: tolerance: 68.R681A.10A
PL8201 PL8202 = L736630H119: tolerance: 68.R3310.201
PL8301 = L4240-D815-UH79: tolerance: 68.2R210.20T
PQ4301 = SOT23DGS2D4H48: tolerance: 84.05067.031
PQ4302 Q2603 Q3102 Q3103 Q5401 = SOT23CBE2D4H44: tolerance: 84.T3904.H11
PQ4303 PQ4306 PQ4402 PQ4405 PQ8301 PQ8303 PQ8305-PQ8307 Q1701 Q1702 Q1801 Q2601 Q2604 Q4001 Q6001 Q6101 Q6406 Q6408 Q6503 Q6701 Q7601 Q7602 = SOT-363H44: tolerance: 84.2N702.A3F
PQ4304 = SOT323CBE2D2H44: tolerance: 84.00124.H1K
PQ4305 = SOT323CBE2D2H44: tolerance: 84.00124.K1K
PQ4308 PQ4403 PQ8302 Q1901 Q2408 Q2412-Q2414 Q2416 Q2505 Q2602 Q3101 Q4004 Q4009 Q5403 Q6402 Q6407 Q6505 Q7301 Q7606 Q9102 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ4408 = SOT23CBE2D4H44: tolerance: 84.T3906.E11
PQ8304 = PPAK-5PH45: tolerance: 084.SRA06.0037
PR4302 R7642 = R402H16: tolerance: 64.15025.6DL
PR4303 PR4311 PR8258 PR8259 R405 R802 R1302 R1503 R1606-R1609 R1707 R1709 R1714 R1717 R1723 R1726 R1733 R1814 R1817 R1829-R1833 R1902 R2002 R2005 R2008 R2009 R2015-R2018 R2021 R2023-R2026 R2032-R2034 R2039-R2041 R2043 R2044 R2047 R2050 R2051 R2415 R2420 R2429 R2430 R2438 R2607 R2919 R2920 R3102 R3103 R3109 R3113 R4008 R4013 R4026 R4039 R4046 R5412 R5521 R6105 R6402 R6514 R7303 R7312 R7518 R7601 R7602 R7609 R7612 R7613 R7615 R7617 R7621 R7622 R7625-R7628 R7631-R7635 R7637 R7643-R7645 R7648 R7649 R9102-R9104 R9117-R9120 = R402H16: tolerance: 63.10334.1DL
PR4304 R803 R804 R1821 R4003 = R402H16: tolerance: 63.22234.1DL
PR4305 PR4306 = R402H16: tolerance: 63.33034.1DL
PR4307 = R603H22: tolerance: 63.24434.15L
PR4308 = R603H22: tolerance: 63.47333.15L
PR4309 PR4312 PR4313 PR4316 PR4318 PR4403 PR4420 PR4431 PR4435 PR4534 PR8203 PR8307 PR8310 PR8311 PR8314 PR8315 PR8317 PR8319 R603 R806 R1715 R1727 R1737 R1904 R2409 R2417 R2433 R2434 R2436 R2449-R2452 R2454 R2478 R2484 R2488 R2489 R2496 R2498 R2711 R2722 R3111 R4004 R4019 R4020 R4031 R4032 R5413 R5506 R5528 R5529 R6003 R6005 R6101 R6102 R6505 R6507 R6509 R6702-R6705 R7605 R7610 = R402H16: tolerance: 63.10434.1DL
PR4310 PR4319 PR4416 PR4418 PR4455 PR4458 PR4462 PR4504 PR4506 PR4507 PR4532 PR4617 PR4618 PR4630 PR4645 PR4648 PR4650 PR4655 PR4670 PR4671 PR4704 PR4808 PR5106 PR5107 PR5109 PR5303 PR5308 PR5310 PR5408 R307 R805 R1201 R1202 R1301 R1704 R1728 R2411 R2412 R2479 R2497 R2499 R2602 R2606 R2611 R2708 R2712 R2713 R2723 R2726 R2728 R3104 R3108 R3114 R4002 R4010-R4012 R4021 R4022 R4024 R4029 R4030 R4036 R4205 R5419 R5530 R5531 R5539 R5540 R6007 R6104 R6112-R6114 R6116 R6121 R6404 R6405 R6508 R6512 R6521 R9202 R9927 R9928 R9930 R9935 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11
PR4314 = R1206H28: tolerance: 63.33232.11L
PR4315 PR8256 PR8308 R401 R417 R419 R604 R605 R1702 R1703 R1722 R1822-R1827 R1834-R1836 R1909 R2006 R2007 R2019 R2432 R2467 R2502 R2717 R2921 R2922 R3106 R4005 R6506 R6516 = R402H16: tolerance: 63.10234.1DL
PR4317 R705 R1108-R1110 R1112-R1117 R1121-R1128 R1130-R1135 R1138 R1139 R1708 R1711 R1720 R2106 R2446 R2482 R2483 R2703 R2706 R2727 R2730 R2906 R2907 R2909 R2911 R2923 R3101 R3105 R4037 R4048 R5409 R5527 R6701 R9101 R9109 R9111-R9114 = 0R0603-PAD-U: tolerance: ZZ.R0603.001
PR4402 PR4415 = R3720H40: tolerance: 64.R0105.7FL
PR4404 PR4463 PR4501 PR4525 PR4530 PR4535 PR5110 PR5216 PR5218 PR5309 PR5311 PR5405-PR5407 PR8207 PR8220 PR8221 PR8257 PR8305 PR8320 R420 R807 R1710 R1718 R1721 R1729 R1736 R2003 R2004 R2401 R2418 R2427 R2440 R2457 R2463-R2466 R2472 R2476 R2492-R2495 R2601 R2605 R2612 R2705 R2710 R2715 R2724 R2725 R2729 R2732 R4023 R4028 R4033 R4045 R4102 R4204 R4210 R4212 R5418 R5524 R5526 R6004 R6115 R6118 R6511 R6515 R6520 R6706 R6801 R6802 R7304 R7305 R7308 R7313 R7519 R7623 R7629 R7630 R7636 R7653 R7656 R7657 R8302 R8303 R8306 R9201 R9918 R9920 R9926 = R402H16: tolerance: 63.R0034.1DL
PR4405 = R805H24: tolerance: 63.30231.16L
PR4406 PR4424 PR4450 PR4523 PR4614 PR4663 PR5103 PR8302 R1732 R2443 R2448 R2510 R7302 R7508-R7512 R7606 R7614 R7618 R7620 = R402H16: tolerance: 64.10025.6DL
PR4407 = R402H14: tolerance: 63.10034.1DL
PR4408 = R402H16: tolerance: 64.30935.6DL
PR4409 R1719 = R402H16: tolerance: 64.47025.6DL
PR4410 = R402H16: tolerance: 64.40215.6DL
PR4411 PR4412 = R402H16: tolerance: 63.33234.1DL
PR4413 PR5304 PR5305 PR5402 PR8304 R1716 R1725 R2441 R2444 R7306 = R402H16: tolerance: 64.10035.6DL
PR4414 PR4417 PR4646 R1811 R2503 R2908 R2910 = R402H14: tolerance: 64.10R05.6DL
PR4419 = R402H16: tolerance: 64.7R505.6DL
PR4421 PR4423 = R402H16: tolerance: 64.59025.6DL
PR4422 = R603H22: tolerance: 63.20333.15L
PR4425 = R402H16: tolerance: 64.30025.6DL
PR4430 = R402H16: tolerance: 64.47035.6DL
PR4432 = R402H16: tolerance: 63.12434.1DL
PR4433 PR5307 R1802 R6707 R7603 R8304 = R402H16: tolerance: 63.10534.1DL
PR4451 = R402H16: tolerance: 64.68035.6DL
PR4512 = R402H16: tolerance: 64.68015.6DL
PR4517 = R402H16: tolerance: 64.17435.6DL
PR4524 PR4528 = R603H22: tolerance: 63.1R534.15L
PR4526 = R402H16: tolerance: 64.97615.6DL
PR4527 = R402H16: tolerance: 64.15425.6DL
PR4529 PR4533 PR4703 PR4804 PR5014 PR5112 PR8215 PR8216 = R805H24: tolerance: 64.2R205.16L
PR4531 = R402H16: tolerance: 64.13735.6DL
PR4601 PR4603 PR4624 PR4626 = R402H16: tolerance: 64.10015.6DL
PR4602 = R402H16: tolerance: 64.75005.6DL
PR4604 PR4607 R709 R732 R2719 R3605-R3612 R5401-R5408 R5535 R5536 R6110 R6111 R9203 R9204 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: R402H16_0R2J-2-GP
PR4605 = R402H16: tolerance: 64.82505.6DL
PR4606 PR4633 PR4653 PR4656 = NTC-402H24-U: tolerance: 69.60013.201
PR4608 = R402H16: tolerance: 64.27415.6DL; signal model: R402H16_2K55R2F-GP
PR4609 = R402H16: tolerance: 64.14325.6DL
PR4611 = R402H16: tolerance: 64.48725.6DL
PR4612 PR4627 = R603H22: tolerance: 64.80615.55L
PR4613 = R402H16: tolerance: 64.10235.6DL
PR4616 PR4636 PR4649 R3112 R7301 = R402H16: tolerance: 64.24915.6DL
PR4619 = R402H16: tolerance: 64.10015.6DL; signal model: R402H16_1KR2F-3-GP
PR4621 = R402H16: tolerance: 64.45R35.6DL
PR4622 PR4669 = R402H16: tolerance: 64.75R05.6DL
PR4623 PR4668 PR8212 PR8213 R503 R719-R722 R726 R730 R733-R735 R1501 R1604 R9115 = R402H14: tolerance: 64.10005.6DL
PR4625 = R402H16: tolerance: 64.37R45.6DL
PR4628 = R402H16: tolerance: 64.10735.6DL
PR4629 = R402H16: tolerance: 64.14025.6DL
PR4631 = R402H16: tolerance: 64.47515.6DL
PR4632 R2609 R7639 = R402H16: tolerance: 64.24925.6DL
PR4634 = NTC-402H24-U: tolerance: 69.60028.031
PR4635 = R402H16: tolerance: 64.61925.6DL
PR4637 = R603H22: tolerance: 64.57625.55L
PR4638 R2709 R5410 = R402H16: tolerance: 64.20035.6DL
PR4639 = R402H16: tolerance: 64.75025.6DL
PR4640 = R402H16: tolerance: 64.12425.6DL
PR4644 = R402H16: tolerance: 64.42205.6DL
PR4647 = R402H16: tolerance: 64.34015.6DL
PR4651 = R402H16: tolerance: 64.48715.6DL
PR4652 PR4661 = R402H16: tolerance: 64.12725.6DL
PR4657 PR4702 PR4803 PR8202 PR8301 = R402H16: tolerance: 64.2R205.6DL
PR4658 = R402H16: tolerance: 64.90925.6DL
PR4659 PR4664 = R402H16: tolerance: 64.24025.6DL
PR4660 R2603 = R402H16: tolerance: 64.18725.6DL
PR4662 = R402H16: tolerance: 64.49925.6DL
PR4665 = R402H16: tolerance: 64.49R95.6DL; signal model: R402H16_49D9R2F-GP
PR4666 R1828 R1910 R1913 R2428 R2721 R6108 R6109 R6119 R6518 R6519 = R402H16: tolerance: 63.R0034.1DL; signal model: R402H16_0R2J-2-GP
PR4667 R1806-R1809 R2485-R2487 R2505-R2509 R2511-R2514 = R402H14: tolerance: 64.10R05.6DL; signal model: R402H14_10R2F-L-GP
PR4701 PR4802 = R603H22: tolerance: 63.3R934.15L
PR5013 PR5105 = R603H22: tolerance: 64.2R205.55L
PR5101 R7638 = R402H16: tolerance: 64.30125.6DL
PR5102 = R402H16: tolerance: 64.18235.6DL
PR5104 PR8206 PR8222 R2424 R2707 R7616 = R402H16: tolerance: 64.20025.6DL
PR5108 = R402H16: tolerance: 64.12025.6DL
PR5111 PR5302 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21
PR5301 = R402H16: tolerance: 64.68025.6DL
PR5401 = R402H16: tolerance: 63.47334.1DL
PR5403 = R402H16: tolerance: 64.16525.6DL
PR5404 = R402H16: tolerance: 64.13325.6DL
PR8201 = R402H16: tolerance: 64.49935.6DL
PR8208 R2604 = R402H16: tolerance: 64.20015.6DL
PR8209 = R402H16: tolerance: 64.18025.6DL
PR8210 PR8211 R1101 R1102 R1104 R1111 R1118-R1120 R1129 R1136 R1712 R5501 R5520 R5522 R6504 R6517 R9108 R9110 R9116 = R603H22: tolerance: 63.00000.00L
PR8223 = R603H22: tolerance: 63.2R233.15L
PR8224 = R402H16: tolerance: 64.57615.6DL
PR8260 = R402H16: tolerance: 64.13025.6DL
PR8303 = R402H16: tolerance: 64.75015.6DL
PR8306 PR8309 PR8313 PR8316 PR8318 R5518 R5519 R5525 R5537 R5538 R6403 R6408 = R402H14: tolerance: 63.10134.1DL
PR8312 R1730 R6002 R6103 = R402H16: tolerance: 63.33434.1DL
PT4501 PT4502 = SE361414H178: tolerance: 79.22710.3KL
PT4701 PT4801 PT8206 PT8207 = CT7343H83: tolerance: 79.33719.L01
PT4702 PT4703 = SE361413H182: tolerance: 79.33612.6CL
PT8208 = SE361414H178: tolerance: 79.3371V.6CL
PU4301 PU4402 PU4403 = PPAK-8P-2H45: tolerance: 84.07121.037
PU4401 = QFN28-G2D7H32: tolerance: 074.24780.0B73
PU4404 PU4405 PU4501 PU4504 PU4505 PU5002 PU5003 PU5102 = PPAK-8P-2H45: tolerance: 84.00412.037
PU4502 PU5103 = PPAK-8P-2H45: tolerance: 84.00780.037
PU4503 = QFN20-G1D75H32: tolerance: 074.06576.0043
PU4601 = LFQFN48J6-G4D6H40: tolerance: 074.81208.0B73
PU4701 PU4801 = QFN36J4060-G2554H40: tolerance: 074.81382.0AE3
PU5001 = LFDFN8G2-G1309H40: tolerance: 074.81253.0AE3
PU5101 = QFN20-G1D75H32: tolerance: 74.51716.073
PU5203 = DFN8F3-G2517H32: tolerance: 074.22961.0093
PU5301 = QFN10M3-G4P-UH34: tolerance: 74.08208.K73
PU5401 = SOIC8-G3530H63: tolerance: 74.05930.03D
PU5402 = SOT-23-5H52: tolerance: 74.01339.B3F
PU8201 = QFN20-G1D75H32: tolerance: 74.08812.073
PU8202 PU8204 PU8206 PU8208 = PPAK-8P-G5324H44-COLAY: tolerance: ZZ.00215.037
PU8301 = DFN10G3-G265175H32: tolerance: 74.08068.A43
PWR1 = 50503-0040N-W01: tolerance: 20.K0422.004
PWSW2 = TJE-533-S-V-T-R-744: tolerance: 62.40009.731
Q3104 Q4003 Q4008 Q6504 Q9101 = SOT23DGS2D4H48: tolerance: 84.02130.031
Q4002 = SOT23CBE2D4H44: tolerance: 84.02222.V11
Q5402 = SOT-363H44: tolerance: 84.2N702.A3F; signal model: SOT-363H44_2N7002KDW-GP
Q6401 Q6403-Q6405 Q6502 = SOT23CBE2D4H44: tolerance: 84.00143.K11
Q6501 = SOT23DGS2D4H48: tolerance: 84.03404.C31
R402 R406-R409 R416 R421-R423 = R402H16: tolerance: 63.51034.1DL
R403 = R402H16: tolerance: 64.49905.6DL
R404 R504 R602 R1705 R1706 R1713 R1801 R1810 R1819 R2045 R2402 R2410 R2416 R2419 R2431 R2435 R2445 R2458 R2462 R2469 R2470 R2473 R2481 R2491 = 0R0402-PAD: tolerance: ZZ.R0402.001
R412 R413 R601 = R402H16: tolerance: 64.49R95.6DL
R501 = R402H16: tolerance: 64.12105.6DL
R502 = R402H16: tolerance: 64.80R65.6DL
R505 = R402H16: tolerance: 64.47005.6DL
R723 = R402H16: tolerance: 64.54R95.6DL
R727 = R402H16: tolerance: 63.56034.1DL
R728 = R402H16: tolerance: 63.22134.1DL; signal model: R402H16_220R2J-L2-GP
R801 R4207 R4211 R4215 = R402H16: tolerance: 64.24R95.6DL
R1103 R1106 R1724 R1735 R2702 R2704 R2731 R4101 R6006 = 0R0805-PAD-U: tolerance: ZZ.R0805.001
R1105 R1107 R5523 R5532 = R805H24: tolerance: 63.R0031.16L
R1502 R1901 R7307 = R402H16: tolerance: 64.20005.6DL
R1603 = R402H16: tolerance: 64.11305.6DL
R1701 = R402H16: tolerance: 63.30234.1DL
R1731 R3110 R4006 R4040 = R402H16: tolerance: 63.20334.1DL
R1734 R7501 R7503 = R402H16: tolerance: 64.60R45.6DL
R1803 = R402H16: tolerance: 64.27015.6DL
R1804 R1805 = R402H16: tolerance: 63.22034.1DL; signal model: R402H16_22R2J-2-GP
R1812 R1813 R1816 R1908 R1911 R2490 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: R402H16_0R2J-2-GP
R1815 R2504 = R402H16: tolerance: 63.10634.1DL
R1818 = R402H16: tolerance: 64.82015.6DL
R1820 R5411 = R402H16: tolerance: 64.15035.6DL
R1907 R1912 R9105-R9107 = R402H16: tolerance: 63.33034.1DL; signal model: R402H16_33R2J-2-GP
R2046 R2048 R2049 R6503 = R402H16: tolerance: 63.51334.1DL
R2414 R2501 R2515 R2912 R2913 R4007 R4009 R4047 R6513 = R402H16: tolerance: 63.47234.1DL
R2421-R2423 R6401 R6406 R6409 = R402H16: tolerance: 63.33134.1DL
R2437 = R402H16: tolerance: 63.43034.1DL
R2442 = R402H16: tolerance: 64.64925.6DL
R2608 = R402H16: tolerance: 64.25525.6DL
R2610 = NTC-603H38: tolerance: 69.60035.041
R2714 R2716 = R402H16: tolerance: 63.22034.1DL
R2718 R2720 = R402H16: tolerance: 63.22034.1DL; signal model: R402H16_0R2J-2-GP
R3107 = R402H16: tolerance: 63.15334.1DL
R4025 = 0R1206-PAD-1: tolerance: ZZ.R1206.ZZ1
R4201 R4203 R4206 R4209 R4214 R4216 = R402H16: tolerance: 64.18015.6DL
R4202 R4208 R4213 = R402H16: tolerance: 64.2R005.6DL
R5414-R5417 = R402H16: tolerance: 63.15134.1DL
R6407 = R402H16: tolerance: 63.47134.1DL
R6522 = R603H22: tolerance: 63.10133.15L
R7505 = R402H16: tolerance: 64.40R25.6DL
R7506 = R402H16: tolerance: 64.51R15.6DL
R7507 = R402H16: tolerance: 64.42R25.6DL
R7604 = R402H16: tolerance: 63.13234.1DL
R7607 = R402H16: tolerance: 64.40225.6DL
R7608 R7611 R7619 R7640 R7647 R7650 = R402H16: tolerance: 64.49915.6DL
R7646 R7654 R7655 = R402H16: tolerance: 64.45325.6DL
R7806 R7807 R7903 R7904 = R402H16: tolerance: 64.13315.6DL
R7808 R7809 R7912 R7913 = R402H16: tolerance: 64.24305.6DL
R7810 R7914 = R402H16: tolerance: 64.16205.6DL
R8301 = R1206H28: tolerance: 63.R0032.11L
R8305 = R402H16: tolerance: 63.75434.1DL
R9804 = R402H16: tolerance: 64.47015.6DL
RJ45 = PAD-23-00980-2A03-A-1: tolerance: ZZ.00PAD.IA1
RN801 RN1811 RN2008 RN2602 RN2901 RN5401 RN6502 RN7603-RN7605 = ARES2H16: tolerance: 66.22236.04L
RN1602 RN2411 RN2412 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN1702 RN2701 = SMD-ARES4H20: tolerance: 66.R0036.04L
RN1806 RN6801 = ARES8-CN24H22: tolerance: 66.R0036.A8L
RN1807 = ARES8-CN24-UH20: tolerance: 66.22236.A8L
RN1810 RN2007 RN2009 RN2603 RN3101 RN6504 RN7401-RN7404 RN7602 = ARES2H18: tolerance: 66.10336.04L
RN1901 = SMD-ARES4H20: tolerance: 66.20336.04L
RN2402 RN2501 RN2502 RN7601 = SMD-ARES4H18: tolerance: 66.47236.04L
RN2403 RN2404 RN2409 RN2410 RN5502 = ARES8-CN24H20: tolerance: 66.10436.A8L
RN3201 = ARES8-CN24H22: tolerance: 66.75036.08L
RN4302 RN5503 = ARES8-CN24H20: tolerance: 66.10136.A8L
RN5402 RN5403 = ARES8-CN24H20: tolerance: 66.47136.08L
RN5504 RN6503 = SMD-ARES4H18: tolerance: 66.33036.04L
RN5505 = SMD-ARES4H18: tolerance: 66.33036.04L; signal model: SMD-ARES4H18_SRN33J-5-GP-U
RTC1 = 87213-0020N-W02: tolerance: 20.F0772.002
SKT25 SKT26 = G6179HT0321-001: tolerance: 62.10089.011
SPI25 = SOIC8-1H86: tolerance: 72.25128.0A1
SPI252 = SOIC8-1H86: tolerance: 72.25Q64.K01
SPK1 = 50224-0040N-001: tolerance: 20.F1639.004
SPR1 = SPR7345H154: tolerance: 34.49U24.001
SPR2 = SPR5230H134: tolerance: 34.45T31.001
SPR3 = SPR7837H229: tolerance: 34.43E24.001
TC1201 = CT7343H83: tolerance: 79.33719.20L
TC3501 TC3502 = C1206H71: tolerance: 78.10710.52L
THM26 = MSOP8-1H44: tolerance: 74.07718.0B9
TP401-TP404 TP501 TP502 TP601-TP617 TP704 TP708 TP801 TP802 TP1601-TP1603 TP1703 TP1704 TP1706-TP1708 TP1801 TP1804-TP1806 TP1902 TP2006 TP2009 TP2012-TP2017 TP2101 TP2102 TP2301-TP2308 TP3101 TP3103 TP4404 TP4405 TP4501 TP6102 TP6103 TP7501-TP7505 TP7601-TP7606 TP8301 TP9903-TP9911 TP9914-TP9919 TP9921-TP9947 = TPAD14-OP: tolerance: ZZ.PAD14.001
TP2702 = TPAD28: tolerance: ZZ.PAD14.001
TPAD1 = 50505-0084N-002: tolerance: 20.K0667.008
TR3301 TR3406 TR3601 TR3602 TR5501 = L125100-4P-1H28: tolerance: 68.01012.20B
U1701 U1702 U4005 = SC70-5H44: tolerance: 73.01G07.0HG
U2401 = SC70-6H44: tolerance: 73.01210.00J
U3201 U3202 U3601 U3602 U6001 = DFN10G2510H26: tolerance: 75.01045.073
U3501-U3503 = SOT-23-5H56: tolerance: 074.06288.009B
U4001 U8301 = DFN14J3020-G255D85H32: tolerance: 074.05016.0093
U4002 U4006 = DFN8F3-G2416-1H32: tolerance: 074.05938.0093
U4003 U7301 = SC70-5-1H44: tolerance: 73.01G08.EHG
U4101 = MSOP8-1H44: tolerance: 074.06288.0079
U5501 = SOT-23-5H51: tolerance: 74.09724.09F
U6002 U6101 = SOT-6-1H50: tolerance: 84.06402.B3D
U6701 = LGA12G2H40: tolerance: 074.LNG2D.00BZ
U9101 = QFN32G5-G3D6H32: tolerance: 071.00650.0A03
USB1 USB2 = SKT-USB13-160166-2: tolerance: 22.10339.331
VGABD1 = TF31-16S-0D5SH-800: tolerance: 020.K0032.0016
VRAM1-VRAM4 = BGA96D0914H48: tolerance: 72.41K26.00U
WLAN1 = NFSA0-S6705-TP40: tolerance: 062.10007.0081
X1801 = OSC-3225-4P-4H36: tolerance: 82.30004.841
X1802 = SMD49-6914-0603H56: tolerance: 82.30001.G01
X2401 = SMD49-3215-0713H36: tolerance: 082.30003.0131
X3101 = OSC-3225-4P-4H36: tolerance: 82.30020.G71
X7601 = OSC-3225-4P-4H30: tolerance: 82.30034.641
XF3103 = XFORM24C1510H168: tolerance: 068.IH219.3001; signal model: XFORM24C1510H168_XFORM-24P-101-GP

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0402-PAD-1
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0603-PAD-1-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0603-PAD-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0805-PAD-U
  rect 1.549x1.333 smd: 1(0,0.838) 2(0,-0.838)
0R1206-PAD-1
  rect 1.854x2.057 smd: 1(0,1.397) 2(0,-1.397)
50208-0060N-001
  rect 0.356x0.991 smd: 1(-2,1.95) 2(-1.2,1.95) 3(-0.4,1.95) 4(0.4,1.95) 5(1.2,1.95) 6(2,1.95)
  rect 1.194x1.702 smd: 7(-3.297,0) 8(3.297,0)
50224-0040N-001
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.797,0) 6(2.797,0)
50406-02071-001
  rect 0.305x1.295 smd: 1(-4.75,-1.95) 2(-4.25,-1.95) 3(-3.75,-1.95) 4(-3.25,-1.95) 5(-2.75,-1.95) 6(-2.25,-1.95) 7(-1.75,-1.95) 8(-1.25,-1.95) 9(-0.75,-1.95) 10(-0.25,-1.95) 11(0.25,-1.95) 12(0.75,-1.95) 13(1.25,-1.95) 14(1.75,-1.95) 15(2.25,-1.95) 16(2.75,-1.95) 17(3.25,-1.95) 18(3.75,-1.95) 19(4.25,-1.95) 20(4.75,-1.95)
  rect 1.194x2.692 smd: 21(-7.15,0) 24(7.15,0)
  rect 2.311x1.295 smd: 22(-3.9,1.95) 23(3.9,1.95)
50458-00601-W01
  rect 0.559x1.295 smd: 1(5,5.025) 2(3,5.025) 3(1,5.025) 4(-1,5.025) 5(-3,5.025) 6(-5,5.025)
  rect 1.295x2.057 smd: 7(8.1,0) 8(-8.1,0)
50503-0040N-W01
  rect 0.406x1.295 smd: 1(-1.5,2.8) 2(-0.5,2.8) 3(0.5,2.8) 4(1.5,2.8)
  rect 1.803x1.397 smd: 5(-3.65,0) 6(3.65,0)
50505-0084N-002
  rect 0.406x1.295 smd: 1(3.5,3.25) 2(2.5,3.25) 3(1.5,3.25) 4(0.5,3.25) 5(-0.5,3.25) 6(-1.5,3.25) 7(-2.5,3.25) 8(-3.5,3.25)
  rect 0.991x2.007 smd: 9(6.1,0) 10(-6.1,0)
50696-00601-001
  rect 0.305x0.813 smd: 1(1.25,2.5) 2(0.75,2.5) 3(0.25,2.5) 4(-0.25,2.5) 5(-0.75,2.5) 6(-1.25,2.5)
  rect 0.406x0.813 smd: 7(2.25,0) 8(-2.25,0)
51540-04001-W01
  rect 0.305x0.838 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.813x2.007 smd: 41(-11.45,0) 42(11.45,0)
51575-00401-W01
  rect 0.406x0.838 smd: 1(-1.5,3.175) 2(-0.5,3.175) 3(0.5,3.175) 4(1.5,3.175)
  rect 0.813x2.007 smd: 5(-3.7,0) 6(3.7,0)
87213-0020N-W02
  rect 0.61x1.549 smd: 1(-0.5,3.876) 2(0.5,3.876)
  rect 1.194x1.803 smd: 3(-1.797,0) 4(1.797,0)
88459-047N
  rect 0.508x0.991 smd: 1(1.2,1.455) 2(0.4,1.455) 3(-0.4,1.455) 4(-1.2,1.455)
  rect 1.194x1.702 smd: 5(2.5,0) 6(-2.5,0)
88513-180N-W01
  rect 0.508x1.295 smd: 1(-8.5,2.8) 2(-7.5,2.8) 3(-6.5,2.8) 4(-5.5,2.8) 5(-4.5,2.8) 6(-3.5,2.8) 7(-2.5,2.8) 8(-1.5,2.8) 9(-0.5,2.8) 10(0.5,2.8) 11(1.5,2.8) 12(2.5,2.8) 13(3.5,2.8) 14(4.5,2.8) 15(5.5,2.8) 16(6.5,2.8) 17(7.5,2.8) 18(8.5,2.8)
  rect 1.803x1.397 smd: 19(-10.65,0) 20(10.65,0)
88631-00401-W01
  rect 0.813x1.905 smd: 1(-1.875,4.925) 2(-0.625,4.925) 3(0.625,4.925) 4(1.875,4.925)
  rect 1.295x3.353 smd: 5(-4.725,0) 6(4.725,0)
196415-06031-3
  rect 0.305x0.838 smd: 1(-1.25,3.175) 2(-0.75,3.175) 3(-0.25,3.175) 4(0.25,3.175) 5(0.75,3.175) 6(1.25,3.175)
  rect 0.813x2.007 smd: 7(-2.95,0) 8(2.95,0)
200277MR008G121ZR-U
  round 1.626 hole 1.219: 1(7,0) 2(5,0) 3(3,0) 4(1,0) 5(-1,0) 6(-3,0) 7(-5,0) 8(-7,0)
  oval 1.727x3.505 hole 1.016x2.794: 9(10.125,0) 10(-10.125,0)
AFTE14P-75
  round 0.356 smd: 1(0,0)
ARES2H16
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
ARES2H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
ARES8-CN24-MUH20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24-UH20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24H20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24H22
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
AS0A621-J4SB-7H
  round 0.254 hole 1.6 unplated: (-33.4,0)
  round 0.254 hole 1.118 unplated: (33.4,0)
  custom 0.114x0.114 smd: 1(-31.65,-4.1) 2(-31.35,4.1) 3(-31.05,-4.1) 4(-30.75,4.1) 5(-30.45,-4.1) 6(-30.15,4.1) 7(-29.85,-4.1) 8(-29.55,4.1) 9(-29.25,-4.1) 10(-28.95,4.1) 11(-28.65,-4.1) 12(-28.35,4.1) 13(-28.05,-4.1) 14(-27.75,4.1) 15(-27.45,-4.1) 16(-27.15,4.1) 17(-26.85,-4.1) 18(-26.55,4.1) 19(-26.25,-4.1) 20(-25.95,4.1) 21(-25.65,-4.1) 22(-25.35,4.1) 23(-25.05,-4.1) 24(-24.75,4.1) 25(-24.45,-4.1) 26(-24.15,4.1) 27(-23.85,-4.1) 28(-23.55,4.1) 29(-23.25,-4.1) 30(-22.95,4.1) 31(-22.65,-4.1) 32(-22.35,4.1) 33(-22.05,-4.1) 34(-21.75,4.1) 35(-21.45,-4.1) 36(-21.15,4.1) 37(-20.85,-4.1) 38(-20.55,4.1) 39(-20.25,-4.1) 40(-19.95,4.1) 41(-19.65,-4.1) 42(-19.35,4.1) 43(-19.05,-4.1) 44(-18.75,4.1) 45(-18.45,-4.1) 46(-18.15,4.1) 47(-17.85,-4.1) 48(-17.55,4.1) 49(-17.25,-4.1) 50(-16.95,4.1) 51(-16.65,-4.1) 52(-16.35,4.1) 53(-16.05,-4.1) 54(-15.75,4.1) 55(-15.45,-4.1) 56(-15.15,4.1) 57(-14.85,-4.1) 58(-14.55,4.1) 59(-14.25,-4.1) 60(-13.95,4.1) 61(-13.65,-4.1) 62(-13.35,4.1) 63(-13.05,-4.1) 64(-12.75,4.1) 65(-12.45,-4.1) 66(-12.15,4.1) 67(-11.85,-4.1) 68(-11.55,4.1) 69(-11.25,-4.1) 70(-10.95,4.1) 71(-10.65,-4.1) 72(-10.35,4.1) 73(-7.65,-4.1) 74(-7.35,4.1) 75(-7.05,-4.1) 76(-6.75,4.1) 77(-6.45,-4.1) 78(-6.15,4.1) 79(-5.85,-4.1) 80(-5.55,4.1) 81(-5.25,-4.1) 82(-4.95,4.1) 83(-4.65,-4.1) 84(-4.35,4.1) 85(-4.05,-4.1) 86(-3.75,4.1) 87(-3.45,-4.1) 88(-3.15,4.1) 89(-2.85,-4.1) 90(-2.55,4.1) 91(-2.25,-4.1) 92(-1.95,4.1) 93(-1.65,-4.1) 94(-1.35,4.1) 95(-1.05,-4.1) 96(-0.75,4.1) 97(-0.45,-4.1) 98(-0.15,4.1) 99(0.15,-4.1) 100(0.45,4.1) 101(0.75,-4.1) 102(1.05,4.1) 103(1.35,-4.1) 104(1.65,4.1) 105(1.95,-4.1) 106(2.25,4.1) 107(2.55,-4.1) 108(2.85,4.1) 109(3.15,-4.1) 110(3.45,4.1) 111(3.75,-4.1) 112(4.05,4.1) 113(4.35,-4.1) 114(4.65,4.1) 115(4.95,-4.1) 116(5.25,4.1) 117(5.55,-4.1) 118(5.85,4.1) 119(6.15,-4.1) 120(6.45,4.1) 121(6.75,-4.1) 122(7.05,4.1) 123(7.35,-4.1) 124(7.65,4.1) 125(7.95,-4.1) 126(8.25,4.1) 127(8.55,-4.1) 128(8.85,4.1) 129(9.15,-4.1) 130(9.45,4.1) 131(9.75,-4.1) 132(10.05,4.1) 133(10.35,-4.1) 134(10.65,4.1) 135(10.95,-4.1) 136(11.25,4.1) 137(11.55,-4.1) 138(11.85,4.1) 139(12.15,-4.1) 140(12.45,4.1) 141(12.75,-4.1) 142(13.05,4.1) 143(13.35,-4.1) 144(13.65,4.1) 145(13.95,-4.1) 146(14.25,4.1) 147(14.55,-4.1) 148(14.85,4.1) 149(15.15,-4.1) 150(15.45,4.1) 151(15.75,-4.1) 152(16.05,4.1) 153(16.35,-4.1) 154(16.65,4.1) 155(16.95,-4.1) 156(17.25,4.1) 157(17.55,-4.1) 158(17.85,4.1) 159(18.15,-4.1) 160(18.45,4.1) 161(18.75,-4.1) 162(19.05,4.1) 163(19.35,-4.1) 164(19.65,4.1) 165(19.95,-4.1) 166(20.25,4.1) 167(20.55,-4.1) 168(20.85,4.1) 169(21.15,-4.1) 170(21.45,4.1) 171(21.75,-4.1) 172(22.05,4.1) 173(22.35,-4.1) 174(22.65,4.1) 175(22.95,-4.1) 176(23.25,4.1) 177(23.55,-4.1) 178(23.85,4.1) 179(24.15,-4.1) 180(24.45,4.1) 181(24.75,-4.1) 182(25.05,4.1) 183(25.35,-4.1) 184(25.65,4.1) 185(25.95,-4.1) 186(26.25,4.1) 187(26.55,-4.1) 188(26.85,4.1) 189(27.15,-4.1) 190(27.45,4.1) 191(27.75,-4.1) 192(28.05,4.1) 193(28.35,-4.1) 194(28.65,4.1) 195(28.95,-4.1) 196(29.25,4.1) 197(29.55,-4.1) 198(29.85,4.1) 199(30.15,-4.1) 200(30.45,4.1) 201(30.75,-4.1) 202(31.05,4.1) 203(31.35,-4.1) 204(31.65,4.1)
  rect 3.505x4.597 smd: 205(-32.8,12) 206(32.8,12)
BGA96D0914H48
  round 0.356 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BGA595M23H83
  round 0.432 smd: A2(-9.9,10.7) A3(-9.1,10.7) A25(9.1,10.7) A26(9.9,10.7) AE1(-10.7,-9.1) AE2(-9.9,-9.1) AE3(-9.1,-9.1) AE25(9.1,-9.1) AE26(9.9,-9.1) AE27(10.7,-9.1) AF1(-10.7,-9.9) AF2(-9.9,-9.9) AF3(-9.1,-9.9) AF25(9.1,-9.9) AF26(9.9,-9.9) AF27(10.7,-9.9) AG2(-9.9,-10.7) AG3(-9.1,-10.7) AG25(9.1,-10.7) AG26(9.9,-10.7) B1(-10.7,9.9) B2(-9.9,9.9) B3(-9.1,9.9) B25(9.1,9.9) B26(9.9,9.9) B27(10.7,9.9) C1(-10.7,9.1) C2(-9.9,9.1) C3(-9.1,9.1) C25(9.1,9.1) C26(9.9,9.1) C27(10.7,9.1)
  round 0.381 smd: A4(-8.3,10.7) A6(-6.6,10.7) A7(-5.8,10.7) A9(-4.12,10.7) A10(-3.32,10.7) A12(-1.64,10.7) A13(-0.84,10.7) A15(0.84,10.7) A16(1.64,10.7) A18(3.32,10.7) A19(4.12,10.7) A21(5.8,10.7) A22(6.6,10.7) A24(8.3,10.7) AA1(-10.7,-5.8) AA2(-9.9,-5.8) AA3(-9.1,-5.8) AA4(-8.3,-5.8) AA5(-7.5,-5.8) AA6(-6.66,-5.8) AA7(-5.8,-5.8) AA8(-4.96,-5.8) AA9(-4.12,-5.86) AA10(-3.32,-5.86) AA12(-1.64,-5.86) AA13(-0.84,-5.86) AA14(0,-5.86) AA15(0.84,-5.86) AA16(1.64,-5.86) AA18(3.32,-5.86) AA19(4.12,-5.86) AA20(4.96,-5.8) AA21(5.8,-5.8) AA22(6.66,-5.8) AA23(7.5,-5.8) AA24(8.3,-5.8) AA25(9.1,-5.8) AA26(9.9,-5.8) AA27(10.7,-5.8) AB1(-10.7,-6.6) AB2(-9.9,-6.6) AB3(-9.1,-6.6) AB4(-8.3,-6.6) AB5(-7.5,-6.6) AB6(-6.6,-6.6) AB7(-5.8,-6.66) AB8(-4.96,-6.66) AB9(-4.12,-6.66) AB10(-3.32,-6.66) AB11(-2.48,-6.66) AB12(-1.64,-6.66) AB13(-0.84,-6.66) AB14(0,-6.66) AB15(0.84,-6.66) AB16(1.64,-6.66) AB17(2.48,-6.66) AB18(3.32,-6.66) AB19(4.12,-6.66) AB20(4.96,-6.66) AB21(5.8,-6.66) AB22(6.6,-6.6) AB23(7.5,-6.6) AB24(8.3,-6.6) AB25(9.1,-6.6) AB26(9.9,-6.6) AB27(10.7,-6.6) AC2(-9.9,-7.45) AC3(-9.1,-7.45) AC4(-8.3,-7.45) AC5(-7.45,-7.45) AC6(-6.6,-7.5) AC7(-5.8,-7.5) AC8(-4.96,-7.5) AC9(-4.12,-7.5) AC10(-3.32,-7.5) AC11(-2.48,-7.5) AC12(-1.64,-7.5) AC13(-0.84,-7.5) AC14(0,-7.5) AC15(0.84,-7.5) AC16(1.64,-7.5) AC17(2.48,-7.5) AC18(3.32,-7.5) AC19(4.12,-7.5) AC20(4.96,-7.5) AC21(5.8,-7.5) AC22(6.6,-7.5) AC23(7.45,-7.45) AC24(8.3,-7.45) AC25(9.1,-7.45) AC26(9.9,-7.45) AD1(-10.7,-8.3) AD2(-9.9,-8.3) AD3(-9.1,-8.3) AD4(-8.3,-8.3) AD5(-7.45,-8.3) AD6(-6.6,-8.3) AD7(-5.8,-8.3) AD8(-4.96,-8.3) AD9(-4.12,-8.3) AD10(-3.32,-8.3) AD11(-2.48,-8.3) AD12(-1.64,-8.3) AD13(-0.84,-8.3) AD14(0,-8.3) AD15(0.84,-8.3) AD16(1.64,-8.3) AD17(2.48,-8.3) AD18(3.32,-8.3) AD19(4.12,-8.3) AD20(4.96,-8.3) AD21(5.8,-8.3) AD22(6.6,-8.3) AD23(7.45,-8.3) AD24(8.3,-8.3) AD25(9.1,-8.3) AD26(9.9,-8.3) AD27(10.7,-8.3) AE4(-8.3,-9.1) AE5(-7.45,-9.1) AE6(-6.6,-9.1) AE7(-5.8,-9.1) AE8(-4.96,-9.1) AE9(-4.12,-9.1) AE10(-3.32,-9.1) AE11(-2.48,-9.1) AE12(-1.64,-9.1) AE13(-0.84,-9.1) AE14(0,-9.1) AE15(0.84,-9.1) AE16(1.64,-9.1) AE17(2.48,-9.1) AE18(3.32,-9.1) AE19(4.12,-9.1) AE20(4.96,-9.1) AE21(5.8,-9.1) AE22(6.6,-9.1) AE23(7.45,-9.1) AE24(8.3,-9.1) AF4(-8.3,-9.9) AF5(-7.45,-9.9) AF6(-6.6,-9.9) AF7(-5.8,-9.9) AF8(-4.96,-9.9) AF9(-4.12,-9.9) AF10(-3.32,-9.9) AF11(-2.48,-9.9) AF12(-1.64,-9.9) AF13(-0.84,-9.9) AF14(0,-9.9) AF15(0.84,-9.9) AF16(1.64,-9.9) AF17(2.48,-9.9) AF18(3.32,-9.9) AF19(4.12,-9.9) AF20(4.96,-9.9) AF21(5.8,-9.9) AF22(6.6,-9.9) AF23(7.45,-9.9) AF24(8.3,-9.9) AG4(-8.3,-10.7) AG6(-6.6,-10.7) AG7(-5.8,-10.7) AG9(-4.12,-10.7) AG10(-3.32,-10.7) AG12(-1.64,-10.7) AG13(-0.84,-10.7) AG15(0.84,-10.7) AG16(1.64,-10.7) AG18(3.32,-10.7) AG19(4.12,-10.7) AG21(5.8,-10.7) AG22(6.6,-10.7) AG24(8.3,-10.7) B4(-8.3,9.9) B5(-7.45,9.9) B6(-6.6,9.9) B7(-5.8,9.9) B8(-4.96,9.9) B9(-4.12,9.9) B10(-3.32,9.9) B11(-2.48,9.9) B12(-1.64,9.9) B13(-0.84,9.9) B14(0,9.9) B15(0.84,9.9) B16(1.64,9.9) B17(2.48,9.9) B18(3.32,9.9) B19(4.12,9.9) B20(4.96,9.9) B21(5.8,9.9) B22(6.6,9.9) B23(7.45,9.9) B24(8.3,9.9) C4(-8.3,9.1) C5(-7.45,9.1) C6(-6.6,9.1) C7(-5.8,9.1) C8(-4.96,9.1) C9(-4.12,9.1) C10(-3.32,9.1) C11(-2.48,9.1) C12(-1.64,9.1) C13(-0.84,9.1) C14(0,9.1) C15(0.84,9.1) C16(1.64,9.1) C17(2.48,9.1) C18(3.32,9.1) C19(4.12,9.1) C20(4.96,9.1) C21(5.8,9.1) C22(6.6,9.1) C23(7.45,9.1) C24(8.3,9.1) D1(-10.7,8.3) D2(-9.9,8.3) D3(-9.1,8.3) D4(-8.3,8.3) D5(-7.45,8.3) D6(-6.6,8.3) D7(-5.8,8.3) D8(-4.96,8.3) D9(-4.12,8.3) D10(-3.32,8.3) D11(-2.48,8.3) D12(-1.64,8.3) D13(-0.84,8.3) D14(0,8.3) D15(0.84,8.3) D16(1.64,8.3) D17(2.48,8.3) D18(3.32,8.3) D19(4.12,8.3) D20(4.96,8.3) D21(5.8,8.3) D22(6.6,8.3) D23(7.45,8.3) D24(8.3,8.3) D25(9.1,8.3) D26(9.9,8.3) D27(10.7,8.3) E2(-9.9,7.45) E3(-9.1,7.45) E4(-8.3,7.45) E5(-7.45,7.45) E6(-6.6,7.5) E7(-5.8,7.5) E8(-4.96,7.5) E9(-4.12,7.5) E10(-3.32,7.5) E11(-2.48,7.5) E12(-1.64,7.5) E13(-0.84,7.5) E14(0,7.5) E15(0.84,7.5) E16(1.64,7.5) E17(2.48,7.5) E18(3.32,7.5) E19(4.12,7.5) E20(4.96,7.5) E21(5.8,7.5) E22(6.6,7.5) E23(7.45,7.45) E24(8.3,7.45) E25(9.1,7.45) E26(9.9,7.45) F1(-10.7,6.6) F2(-9.9,6.6) F3(-9.1,6.6) F4(-8.3,6.6) F5(-7.5,6.6) F6(-6.6,6.6) F7(-5.8,6.66) F8(-4.96,6.66) F9(-4.12,6.66) F10(-3.32,6.66) F11(-2.48,6.66) F12(-1.64,6.66) F13(-0.84,6.66) F14(0,6.66) F15(0.84,6.66) F16(1.64,6.66) F17(2.48,6.66) F18(3.32,6.66) F19(4.12,6.66) F20(4.96,6.66) F21(5.8,6.66) F22(6.6,6.6) F23(7.5,6.6) F24(8.3,6.6) F25(9.1,6.6) F26(9.9,6.6) F27(10.7,6.6) G1(-10.7,5.8) G2(-9.9,5.8) G3(-9.1,5.8) G4(-8.3,5.8) G5(-7.5,5.8) G6(-6.66,5.8) G7(-5.8,5.8) G8(-4.96,5.8) G9(-4.12,5.86) G10(-3.32,5.86) G12(-1.64,5.86) G13(-0.84,5.86) G14(0,5.86) G15(0.84,5.86) G16(1.64,5.86) G18(3.32,5.86) G19(4.12,5.86) G20(4.96,5.8) G21(5.8,5.8) G22(6.66,5.8) G23(7.5,5.8) G24(8.3,5.8) G25(9.1,5.8) G26(9.9,5.8) G27(10.7,5.8) H2(-9.9,4.96) H3(-9.1,4.96) H4(-8.3,4.96) H5(-7.5,4.96) H6(-6.66,4.96) H22(6.66,4.96) H23(7.5,4.96) H24(8.3,4.96) H25(9.1,4.96) H26(9.9,4.96) J1(-10.7,4.12) J2(-9.9,4.12) J3(-9.1,4.12) J4(-8.3,4.12) J5(-7.5,4.12) J6(-6.66,4.12) J7(-5.86,4.12) J21(5.86,4.12) J22(6.66,4.12) J23(7.5,4.12) J24(8.3,4.12) J25(9.1,4.12) J26(9.9,4.12) J27(10.7,4.12) K1(-10.7,3.32) K2(-9.9,3.32) K3(-9.1,3.32) K4(-8.3,3.32) K5(-7.5,3.32) K6(-6.66,3.32) K7(-5.86,3.32) K21(5.86,3.32) K22(6.66,3.32) K23(7.5,3.32) K24(8.3,3.32) K25(9.1,3.32) K26(9.9,3.32) K27(10.7,3.32) L2(-9.9,2.48) L3(-9.1,2.48) L4(-8.3,2.48) L5(-7.5,2.48) L6(-6.66,2.48) L22(6.66,2.48) L23(7.5,2.48) L24(8.3,2.48) L25(9.1,2.48) L26(9.9,2.48) M1(-10.7,1.64) M2(-9.9,1.64) M3(-9.1,1.64) M4(-8.3,1.64) M5(-7.5,1.64) M6(-6.66,1.64) M7(-5.86,1.64) M21(5.86,1.64) M22(6.66,1.64) M23(7.5,1.64) M24(8.3,1.64) M25(9.1,1.64) M26(9.9,1.64) M27(10.7,1.64) N1(-10.7,0.84) N2(-9.9,0.84) N3(-9.1,0.84) N4(-8.3,0.84) N5(-7.5,0.84) N6(-6.66,0.84) N7(-5.86,0.84) N21(5.86,0.84) N22(6.66,0.84) N23(7.5,0.84) N24(8.3,0.84) N25(9.1,0.84) N26(9.9,0.84) N27(10.7,0.84) P2(-9.9,0) P3(-9.1,0) P4(-8.3,0) P5(-7.5,0) P6(-6.66,0) P22(6.66,0) P23(7.5,0) P24(8.3,0) P25(9.1,0) P26(9.9,0) R1(-10.7,-0.84) R2(-9.9,-0.84) R3(-9.1,-0.84) R4(-8.3,-0.84) R5(-7.5,-0.84) R6(-6.66,-0.84) R7(-5.86,-0.84) R21(5.86,-0.84) R22(6.66,-0.84) R23(7.5,-0.84) R24(8.3,-0.84) R25(9.1,-0.84) R26(9.9,-0.84) R27(10.7,-0.84) T1(-10.7,-1.64) T2(-9.9,-1.64) T3(-9.1,-1.64) T4(-8.3,-1.64) T5(-7.5,-1.64) T6(-6.66,-1.64) T7(-5.86,-1.64) T21(5.86,-1.64) T22(6.66,-1.64) T23(7.5,-1.64) T24(8.3,-1.64) T25(9.1,-1.64) T26(9.9,-1.64) T27(10.7,-1.64) U2(-9.9,-2.48) U3(-9.1,-2.48) U4(-8.3,-2.48) U5(-7.5,-2.48) U6(-6.66,-2.48) U22(6.66,-2.48) U23(7.5,-2.48) U24(8.3,-2.48) U25(9.1,-2.48) U26(9.9,-2.48) V1(-10.7,-3.32) V2(-9.9,-3.32) V3(-9.1,-3.32) V4(-8.3,-3.32) V5(-7.5,-3.32) V6(-6.66,-3.32) V7(-5.86,-3.32) V21(5.86,-3.32) V22(6.66,-3.32) V23(7.5,-3.32) V24(8.3,-3.32) V25(9.1,-3.32) V26(9.9,-3.32) V27(10.7,-3.32) W1(-10.7,-4.12) W2(-9.9,-4.12) W3(-9.1,-4.12) W4(-8.3,-4.12) W5(-7.5,-4.12) W6(-6.66,-4.12) W7(-5.86,-4.12) W21(5.86,-4.12) W22(6.66,-4.12) W23(7.5,-4.12) W24(8.3,-4.12) W25(9.1,-4.12) W26(9.9,-4.12) W27(10.7,-4.12) Y2(-9.9,-4.96) Y3(-9.1,-4.96) Y4(-8.3,-4.96) Y5(-7.5,-4.96) Y6(-6.66,-4.96) Y22(6.66,-4.96) Y23(7.5,-4.96) Y24(8.3,-4.96) Y25(9.1,-4.96) Y26(9.9,-4.96)
  round 0.457 smd: K10(-4,4) K11(-3,4) K12(-2,4) K13(-1,4) K14(0,4) K15(1,4) K16(2,4) K17(3,4) K18(4,4) L10(-4,3) L11(-3,3) L12(-2,3) L13(-1,3) L14(0,3) L15(1,3) L16(2,3) L17(3,3) L18(4,3) M10(-4,2) M11(-3,2) M12(-2,2) M13(-1,2) M14(0,2) M15(1,2) M16(2,2) M17(3,2) M18(4,2) N10(-4,1) N11(-3,1) N12(-2,1) N13(-1,1) N14(0,1) N15(1,1) N16(2,1) N17(3,1) N18(4,1) P10(-4,0) P11(-3,0) P12(-2,0) P13(-1,0) P14(0,0) P15(1,0) P16(2,0) P17(3,0) P18(4,0) R10(-4,-1) R11(-3,-1) R12(-2,-1) R13(-1,-1) R14(0,-1) R15(1,-1) R16(2,-1) R17(3,-1) R18(4,-1) T10(-4,-2) T11(-3,-2) T12(-2,-2) T13(-1,-2) T14(0,-2) T15(1,-2) T16(2,-2) T17(3,-2) T18(4,-2) U10(-4,-3) U11(-3,-3) U12(-2,-3) U13(-1,-3) U14(0,-3) U15(1,-3) U16(2,-3) U17(3,-3) U18(4,-3) V10(-4,-4) V11(-3,-4) V12(-2,-4) V13(-1,-4) V14(0,-4) V15(1,-4) V16(2,-4) V17(3,-4) V18(4,-4)
