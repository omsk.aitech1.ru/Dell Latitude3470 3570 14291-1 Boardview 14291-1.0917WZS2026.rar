# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CLK1_CPU#: length 120.2
  L4 w0.114: v2(164.85,67.82) 164.85,67.94 164.33,68.46 164.33,70.58 164.85,71.1 164.85,72.19 164.59,72.45 164.59,74.19 161.37,77.41 161.37,79.56 159.71,81.21 159.71,81.9 159.55,82.06 159.55,82.69 158.47,83.77 158.12,83.77 157.53,84.37 157.53,85.01 155.95,86.58 155.95,90.16 154.2,91.91 154.2,92.86 153.54,93.52 153.54,95.73 153.36,95.91 153.36,101.01 152.34,102.03 152.34,102.91 152.34,103.1 149.94,105.5 149.94,106.47 146.87,109.54 138.61,109.54 138.46,109.39 129.61,109.39 128.06,107.85 116.56,107.85 112.46,103.75 111.99,103.75 v2(111.78,103.96)
  BOTTOM w0.089: CPU1.B42 111.36,94.43 111.64,94.72 111.64,95.44 111.69,95.49 111.69,97.28 111.28,97.69 111.28,98.67 111.31,98.7 111.31,98.71
  BOTTOM w0.127: v2(111.78,103.96) 111.99,103.75 112.21,103.75 112.56,103.4 112.56,102.36 111.31,101.12 111.31,98.71 ; v2(164.85,67.82) 164.57,67.54 164.57,67.17 ; 164.57,67.17 164.57,66.17 164.85,65.88 EC6102.1 164.56,65.37 164.56,64.75 164.13,64.32 164.13,62.79 165.46,61.46 165.46,60.32 163.31,58.16 163.31,56.95 163.61,56.65 163.61,55.05 163.79,54.87 163.79,51.75 163.24,51.2 161.59,51.2 161.41,51.02 WLAN1.49 ; 164.57,67.17 v1(164.76,67.17)
PEG_CLK2_CPU: length 154.1
  TOP w0.127: v2(48.28,165.47) 48.29,165.46 48.49,165.46 48.68,165.65 48.68,165.89 48.5,166.07 47.93,166.07 47.53,166.47 LOM31.15
  L4 w0.114: v2(48.28,165.47) 48.32,165.51 48.53,165.51 48.66,165.38 48.66,164.8 49.06,164.4 52.3,164.4 52.67,164.03 54.2,164.03 63.6,173.43 79.3,173.43 79.8,173.93 81.37,173.93 82.16,174.72 83.51,174.72 85,173.23 85,168.75 83.07,166.81 83.07,161.11 81.34,159.37 81.34,152.28 82.34,151.28 82.34,149.28 89,142.62 89,135.6 94.25,130.34 94.25,128.08 93.75,127.57 93.75,122.72 94.31,122.16 94.31,118.73 88.9,113.32 88.9,105.06 89.58,104.37 90.69,104.37 92.85,102.21 101.52,102.21 103.06,100.67 106.02,100.67 106.66,100.03 110.65,100.03 111.49,99.19 111.95,98.73 111.95,98.61 v2(111.84,98.5)
  BOTTOM w0.127: 112.57,97.27 112.57,97.67 112.23,98.01 112.23,98.19 111.92,98.5 v2(111.84,98.5) ; 112.57,97.27 v1(112.42,97.27) ; 112.57,97.27 112.57,96.82 112.23,96.47 112.23,95.75 111.84,95.36 111.84,94.15 CPU1.C41
PEG_CLK2_CPU#: length 154.1
  TOP w0.127: LOM31.16 47.93,166.44 48.06,166.32 48.6,166.32 48.92,165.99 48.92,165.64 v2(49.09,165.47)
  L4 w0.114: v2(112.49,98.51) 110.74,100.26 106.75,100.26 106.12,100.9 103.15,100.9 101.61,102.44 92.95,102.44 90.78,104.6 89.68,104.6 89.13,105.15 89.13,113.23 94.54,118.64 94.54,122.26 93.98,122.82 93.98,127.48 94.48,127.98 94.48,130.43 89.23,135.69 89.23,142.71 82.56,149.37 82.56,151.38 81.57,152.38 81.57,159.28 83.3,161.01 83.3,166.72 85.23,168.65 85.23,173.32 83.6,174.95 82.07,174.95 81.27,174.16 79.7,174.16 79.21,173.66 63.51,173.66 54.11,164.26 52.76,164.26 52.4,164.63 49.15,164.63 48.89,164.89 48.89,165.27 v2(49.09,165.47)
  BOTTOM w0.127: CPU1.D41 111.8,93.66 112.11,93.97 112.11,94.24 112.08,94.27 112.08,95.26 112.47,95.65 112.47,96.37 112.81,96.72 112.81,97.77 112.47,98.11 112.47,98.49 v2(112.49,98.51)
PEG_TX_CPU_N0: length 10.3
  BOTTOM w0.089: 127.71,97.7 127.7,97.68 127.65,97.68 126.91,96.94 126.91,95.87 126.45,95.41 126.45,94.78 CPU1.B17
  BOTTOM w0.127: 128.23,98.22 v1(128.37,98.08) ; 128.23,98.22 127.71,97.7 ; 128.23,98.22 129.16,99.14 129.16,99.69 131.11,101.64 131.11,101.88 C1606.2
PEG_TX_CPU_N1: length 13.1
  BOTTOM w0.089: CPU1.D16 126.67,93.7 126.97,94.01 126.97,95.36 127.41,95.8 127.41,96.64 127.95,97.18 127.99,97.18 128.01,97.19
  BOTTOM w0.127: 132.53,101.56 131.78,100.81 131.03,100.81 129.94,99.72 129.94,98.75 128.38,97.19 128.01,97.19 ; 132.53,101.56 v1(132.66,101.42) ; 132.53,101.56 133.02,102.05 133.02,102.8 C1608.2
PEG_TX_CPU_N2: length 13.3
  BOTTOM w0.089: CPU1.D17 126.01,93.13 125.88,93.26 125.73,93.8 125.73,94.13 125.66,94.34 125.66,94.54 125.72,94.69 125.72,94.79 125.66,94.97 125.66,95.5 126.22,96.05 126.22,97.43 126.37,97.58 126.37,97.64 126.38,97.65
  BOTTOM w0.127: 129.73,102.98 129.73,102.28 129.28,101.83 129.28,101 126.65,98.37 126.65,97.92 126.38,97.65 ; 129.73,102.98 129.73,103.96 C1610.2 ; 129.73,102.98 v1(129.56,102.98)
PEG_TX_CPU_N3: length 10.3
  BOTTOM w0.089: CPU1.B19 124.76,94.62 124.49,94.89 124.49,96.58 124.66,96.76 124.66,97.46 124.63,97.49 124.63,97.51
  BOTTOM w0.127: 125.63,101.47 v1(125.47,101.63) ; 125.63,101.47 125.87,101.72 125.87,103.33 C1612.2 ; 125.63,101.47 124.63,100.48 124.63,97.51
PEG_TX_CPU_P0: length 9.5
  BOTTOM w0.089: CPU1.A17 126.27,95.25 126.27,95.48 126.74,95.95 126.74,97.02 127.53,97.81 127.53,97.85 127.54,97.87
  BOTTOM w0.127: 130.14,101.02 130.87,101.74 130.87,102.01 C1605.2 ; 130.14,101.02 128.91,99.79 128.91,99.24 127.54,97.87 ; 130.14,101.02 v1(129.99,101.18)
PEG_TX_CPU_P1: length 12.5
  BOTTOM w0.089: CPU1.C16 126.8,94.23 126.8,95.43 127.23,95.87 127.23,96.72 127.82,97.3 127.82,97.35 127.83,97.37
  BOTTOM w0.127: 131.3,101.05 131.68,101.05 132.78,102.15 132.78,102.66 132.47,102.97 C1607.2 ; 131.3,101.05 v1(131.3,101.22) ; 131.3,101.05 130.93,101.05 129.7,99.82 129.7,98.85 128.28,97.44 127.91,97.44 127.83,97.37
PEG_TX_CPU_P2: length 12.6
  BOTTOM w0.089: CPU1.C17 125.9,94.08 125.9,94.16 125.84,94.37 125.84,94.51 125.89,94.66 125.89,94.82 125.84,94.99 125.84,95.43 126.4,95.98 126.4,97.35 126.5,97.46 126.53,97.46 126.55,97.48
  BOTTOM w0.127: 128.03,99.41 126.89,98.27 126.89,97.82 126.55,97.48 ; 128.03,99.41 129.52,100.9 129.52,101.73 129.97,102.18 129.97,103.95 C1609.2 ; 128.03,99.41 v1(128.14,99.29)
PEG_TX_CPU_P3: length 9.5
  BOTTOM w0.089: 124.87,97.51 124.87,97.49 124.84,97.46 124.84,96.68 124.67,96.51 124.67,95.17 CPU1.A19
  BOTTOM w0.127: 124.87,97.51 124.87,100.38 126.11,101.62 126.11,102.6 ; 126.11,102.6 v1(126.31,102.6) ; 126.11,102.6 126.11,103.33 C1611.2
PEX_TERMP: length 6.3
  BOTTOM w0.102: GPU1.AF25 182.44,152.18 182.44,152.4 182.44,152.41 182.44,152.73 182.17,153 180.47,153 179.85,153.62 R7301.1 178.8,154.23 v1(178.44,154.59)
PEXTSTCLK_OUT: length 6
  BOTTOM w0.14: v1(177.77,147.02) R7307.1 179.98,147.02 181.86,148.9 182.28,148.9 182.65,149.27 GPU1.AF22
PEXTSTCLK_OUT#: length 7.4
  BOTTOM w0.14: GPU1.AE22 183.27,148.89 182.66,148.89 182.44,148.67 182.44,148.33 180.25,146.13 R7307.2 178.78,145.41 v1(178.53,145.16)
PIRQA#: length 11
  BOTTOM w0.102: CPU1.BB11 129.64,72.41 129.64,71.76 129.95,71.44 129.95,70.6 131.14,69.41 131.14,68.38 132.06,67.46 132.8,67.46 133.76,66.5 133.97,66.5 v1(134.64,65.83) 135.8,64.67 R1607.1
PLT_RST#: length 491.1
  TOP w0.102: R4007.1 31.86,56.21 30.03,56.21 29.83,56.41 29.83,59.59 30.58,60.33 31,60.33 v2(31.18,60.15) ; v2(165.95,56.83) 165.18,56.06 164.7,56.06 164.22,55.59 R6116.1 ; v2(84.16,140.52) 81.91,142.77 81.91,149.87 80.46,151.32 R5538.2 80.01,152.19 79.35,152.85 79.35,153.63 77.83,155.15 71.8,155.15 63.21,163.73 v1(61.54,163.73) 60.55,163.73 57.87,166.42 v2(57.46,166.42) Q3103.E 56.27,167.13 56.46,167.32 R3108.1 ; v2(172.01,87.39) 172.47,87.86 R2410.2
  L3 w0.102: v2(84.16,140.52) 85.36,139.32 85.36,136.05 87.73,133.68 87.73,127.06 90.47,124.31 90.47,116.72 86.44,112.69 86.44,106.09 83.75,103.4 83.75,100.32 65.3,81.87 64.82,81.87 62.94,79.99 62.94,76.51 v2(62.81,76.38) ; v2(57.46,166.42) 60.01,166.42 60.29,166.7 60.29,166.93 64.46,171.09 66.61,173.25 77.19,173.25 77.25,173.19 81.47,173.19 82.42,174.14 82.42,174.34 82.67,174.59 84.23,174.59 85.3,173.53 88.57,173.53 90.7,175.66 102.34,175.66 102.73,175.27 105.25,175.27 105.46,175.48 109.31,175.48 110.48,174.32 115.16,174.32 115.58,173.9 123.8,173.9 124.54,173.16 126.75,173.16 126.9,173 131.5,173 131.7,172.8 135.3,172.8 136.16,173.66 148.68,173.66 152.58,169.75 154.95,169.75 159.65,165.05 163.97,165.05 v2(164.35,164.67) ; v2(156.25,75.04) 156.48,74.82 159.7,74.82 159.83,74.68 167.76,74.68 167.91,74.83 169.38,74.83 v2(169.58,75.03)
  L4 w0.102: v2(31.74,70.59) 32.53,71.38 50.85,71.38 51.23,71 51.96,71 52.26,71.3 55.86,71.3 56.9,72.34 58.95,72.34 62.81,76.19 v2(62.81,76.38) ; v2(172.01,87.39) 172.17,87.55 172.17,89.42 172.28,89.53 172.28,94.44 172.31,94.47 172.31,96.15 174.59,98.43 174.59,98.82 176.24,100.46 176.24,103.22 176.65,103.63 176.65,106.49 175.85,107.28 175.85,108 176.09,108.24 176.09,112 174.09,114 174.09,114.87 173.26,115.69 173.26,116.88 173.93,117.55 v2(173.93,123.32) 173.93,125.66 168.73,130.86 168.73,134.84 167.3,136.27 167.3,137.37 165.22,139.45 165.22,144.08 165.64,144.5 165.64,147.68 167.28,149.32 167.28,157.22 164.88,159.63 164.88,163.2 164.35,163.73 v2(164.35,164.67) ; v2(168.26,21.56) 168.26,21.99 168.32,22.05 168.32,28.3 166.97,29.65 166.97,30.56 162.48,35.06 162.48,35.92 159.79,38.61 159.79,40.86 v2(159.55,41.1)
  BOTTOM w0.102: v2(156.25,75.04) 156.67,75.04 156.95,74.76 C1701.1 EC1703.1 155.47,74.05 R1715.1 155.29,74.81 R1713.1 ; v2(172.01,87.39) 171.8,87.19 171.78,87.19 171.47,86.88 171.47,85.24 171.57,85.14 171.57,81.83 171.05,81.31 171.05,77.99 169.69,76.63 169.69,75.14 v2(169.58,75.03) 169.16,74.61 169.16,73.21 169.84,72.53 170.23,72.53 170.48,72.28 170.48,72.27 170.68,72.07 170.68,71.49 170.9,71.27 170.9,65.31 170.31,64.73 170.31,63.54 170.53,63.31 170.53,62.08 168.85,60.41 167.43,60.41 166.49,59.47 166.49,57.37 v2(165.95,56.83) 166.4,56.38 166.4,52.57 165.93,52.11 165.93,49.99 165.06,49.11 165.06,44.85 164.49,44.28 164.49,40.91 164.69,40.71 R6802.1 161.12,39.53 v2(159.55,41.1) ; v2(168.26,21.56) 167.86,21.97 U9101.17 ; v2(173.93,123.32) 175.1,123.32 176.35,124.56 U7301.2 ; v2(31.74,70.59) 31.69,70.54 31.69,60.67 v2(31.18,60.15)
PLT_RST#_DEBUG: length 5.8
  BOTTOM w0.127: DB1.7 163.09,37.38 164.08,38.37 164.42,38.37 R6802.2 165.58,40.85 v1(165.22,41.22)
PLT_RST#_LAN: length 16.4
  TOP w0.127: LOM31.19 49.3,168.37 49.35,168.32 49.91,168.32 50.64,167.58 50.64,166.66 50.93,166.37 53.21,166.37 53.8,166.96 53.8,167.63 54.02,167.85 v1(54.4,167.85) R3108.2 55.57,167.54 54.37,166.33 Q3103.C 54.37,164.89 55.66,163.6 55.66,162.51 55.91,162.26 RN3101.3
PLT_RST_NGFF#: length 8.6
  TOP w0.102: R6116.2 165.58,54.57 AFTP5805.1 165.89,53.56 165.13,52.8 165.13,51.54 165.14,51.53 165.14,51.47 165.35,51.26 165.41,51.26 v2(166.61,50.06)
  BOTTOM w0.102: v2(166.61,50.06) 166.82,50.27 WLAN1.52
PM_LAN_ENABLE: length 216.9
  TOP w0.127: v2(175.23,116.79) 174.71,117.32 v1(172.18,117.32) v2(171.45,117.32) ; v2(59.86,166.88) 59.86,166.92 59.85,166.92 R3111.1 58.62,167.54 58.37,167.79 Q3101.G
  L3 w0.127: v2(162.77,165.56) 162.68,165.65 160.48,165.65 159.52,166.61 158.44,166.61 155.05,170 152.68,170 148.78,173.9 135.21,173.9 135.02,174.08 126.81,174.08 126.12,173.4 124.64,173.4 123.9,174.15 118.04,174.15 117.56,174.62 114.87,174.62 113.77,175.72 105.36,175.72 105.16,175.52 102.81,175.52 102.44,175.9 90.6,175.9 88.63,173.93 85.25,173.93 84.35,174.83 82.57,174.83 82.18,174.44 82.18,174.24 81.37,173.44 77.35,173.44 77.29,173.49 66.51,173.49 64.22,171.19 59.9,166.88 v2(59.86,166.88)
  L4 w0.127: v2(162.77,165.56) 163.13,165.2 163.13,163.35 163.75,162.74 163.75,159.19 166.18,156.76 166.18,151.24 164.49,149.56 164.49,147.21 162.96,145.68 162.96,144.11 163.86,143.22 163.86,138.16 164.66,137.37 164.66,136.77 166.53,134.9 166.53,134.9 167.07,134.35 167.37,134.06 167.37,130.3 167.77,129.9 171.99,125.68 171.99,117.86 v2(171.45,117.32)
  BOTTOM w0.127: v2(175.23,116.79) 175.71,116.31 175.71,114.88 177.97,112.62 177.97,100.67 181.64,97 181.64,91.91 181.36,91.64 181.36,90.9 181.02,90.56 181.02,87.89 180.27,87.14 180.27,85.87 178.88,84.48 178.88,82.47 179.41,81.94 179.41,81.15 179.06,80.8 179.06,79.17 R2491.2
PM_LAN_ENABLE_C: length 5.1
  TOP w0.127: R3110.2 59.02,172.18 C3110.2 58.3,172.17 57.16,171.03 Q3104.G 56.6,170.38 v1(56.07,169.85)
PM_PCH_PWROK: length 44.8
  TOP w0.127: R1732.2 138.89,57.84 R1706.2 ; R1706.2 139.36,56.71 139.84,56.71 140.97,55.59 v2(140.97,54.67) ; R1706.2 138.52,57.18 138.44,57.1 EC1713.2
  L4 w0.127: v2(140.56,48.95) 140.45,49.06 140.45,54.15 v2(140.97,54.67)
  BOTTOM w0.089: CPU1.BA20 124.75,72.91 125.53,72.13 125.53,70.42 125.63,70.32
  BOTTOM w0.127: v2(140.56,48.95) 140.45,49.06 140.45,49.37 139.58,50.23 134.96,50.23 127.79,57.4 127.79,63.62 127.14,64.27 127.14,64.79 126.3,65.63 v1(126.3,66.13) 126.3,67.03 126.03,67.3 126.03,69.93 125.63,70.32
PM_RSMRST#: length 111.7
  TOP w0.127: v2(142.07,58.26) 142.07,57.43 141.98,57.34 R1704.1 141.46,58.36 TP9903.1 141.35,58.48 140.03,58.48 139.63,58.08 R1733.2
  L3 w0.127: v2(142.07,58.26) 142.07,58.25 142.37,58.54 142.44,58.54 142.72,58.83 147.13,58.83 147.93,58.04 147.93,57.32 148.13,57.11 149.07,57.11 149.33,56.85 149.33,56.85 150.05,56.13 155.42,56.13 156.98,57.69 v2(158.26,57.69)
  L4 w0.127: v2(158.26,57.69) 158.26,58.38 157.96,58.69 157.96,59.08 156.48,60.56 156.48,65.12 156.26,65.34 156.26,66.43 153.81,68.88 153.81,70.04 152.39,71.46 151.01,71.46 150.47,72 150.47,73.3 151.13,73.96 v2(152.32,73.96) ; v2(142.07,58.26) 142.07,57.92 143.01,56.98 143.01,54.37 142.61,53.97 142.61,51.63 142.96,51.28 142.96,50.67 143.42,50.21 143.42,48.07 143.15,47.8 143.15,47.37 v2(143.12,47.35)
  BOTTOM w0.089: CPU1.AY17 125.97,73.65 125.71,73.39 125.71,70.79 125.85,70.65
  BOTTOM w0.127: R1720.2 163.38,68.77 163.38,67.05 162.54,66.21 162.54,65.35 163.23,64.66 163.23,62.02 161.44,60.23 158.74,60.23 158.26,59.75 v2(158.26,57.69) ; v2(152.32,73.96) 151.81,73.96 R1702.1 152.35,72.94 Q1701.3 ; 125.85,70.65 126.26,70.24 126.26,67.44 v1(127.53,66.17) 127.76,65.94 127.76,63.96 128.04,63.67 128.04,57.51 135.06,50.48 139.76,50.48 141.3,48.94 141.3,48.94 141.45,48.8 141.6,48.8 142.37,48.03 142.69,48.03 143.12,47.59 v2(143.12,47.35)
PM_RSMRST#_M: length 4.5
  BOTTOM w0.127: Q1702.6 159.8,69.22 159.07,69.96 v1(158.57,69.96) 158.57,69.37 R1737.2 159.37,68.57 Q1702.5
PM_RSMRST#_R: length 4
  BOTTOM w0.127: R1720.1 164.78,69.11 164.28,69.6 162.93,69.6 162.79,69.46 162.79,68.76 162.6,68.57 Q1702.2
PM_SLP_S0_STG#: length 6.2
  BOTTOM w0.127: R4028.2 156.99,124.61 154.81,124.61 v1(154.62,124.81) 154.06,125.36 R4020.2 154.32,126.15 U4003.1
PM_SLP_S3_STG#: length 7.2
  BOTTOM w0.127: v1(153.02,124.45) 153.27,124.7 R4021.2 153.27,126.49 153.66,126.89 U4003.2 153.66,128.2 153.47,128.4 R4022.1 151.17,128.4 v1(150.77,128.81)
PME#: length 1.9
  TOP w0.102: v2(129.85,75.9) 130.11,75.64 TP1707.1
  BOTTOM w0.102: CPU1.AU11 129.53,75.57 v2(129.85,75.9)
POWER_SW_IN#: length 5.4
  TOP w0.102: R2432.2 190.62,64.22 v1(189.96,64.88) 189.83,64.88 189.75,64.8 R2451.1 188.93,64.8 C2426.1 188.09,65.11 187.59,65.62 187.46,65.62 187.28,65.8 KBC24.127
PQ3802_1:
  vias: v1(110.47,174.24)
PQ3808D: length 3.1
  TOP w0.254: PQ4308.D 111.53,171.86 PC4308.2 111.5,172.19 v1(110.77,172.92)
PQ3808G: length 3.7
  TOP w0.254: PR4315.1 PC4309.1 116.49,170.88 PQ4308.G 114.84,170.6 v1(114.84,169.72)
PQ3809_D: length 4.5
  BOTTOM w0.254: v1(85.75,156.24) PR4314.2 88.29,157.47 88.3,157.47 89.08,158.25 PQ4306.3
PQ4303_5: length 10.6
  TOP w0.254: PC4310.1 119.25,171.99 v2(118.74,172.5) ; PQ4303.5 117.72,175.8 118.36,176.43 PR4318.1 119.69,176.62 120.01,176.94 v2(120.01,177.45)
  BOTTOM w0.254: v2(120.01,177.45) 120.01,177.38 119.88,177.26 119.88,177.24 119.59,176.94 119.2,176.94 118.74,176.48 v1(118.74,175.85) v2(118.74,172.5)
PQ4405_2: length 24.1
  TOP w0.102: PQ4405.2 123.44,171.99 123.81,172.36 124.47,172.36 126.12,170.72 v1(126.12,170.05) 126.12,167.92 126.76,167.27 126.76,166.23 v2(126.65,166.11) ; v2(114.29,166.78) 113.98,166.46 PR4462.1 113.53,166.21 PR4463.1
  L4 w0.102: v2(126.65,166.11) 125.47,166.11 124.86,166.73 119.17,166.73 118.56,167.34 114.85,167.34 v2(114.29,166.78)
PQ4405_3: length 2.6
  TOP w0.14: v1(120.88,171.87) 121.41,171.35 PR4455.1 122.11,171.04 122.47,171.4 PQ4405.3
PQ4405_5: length 4.4
  TOP w0.102: PQ4405.5 123.44,168.5 PR4413.2 123.91,167.39 PC4426.1 122.97,166.16 v1(122.82,166.16)
PQ4405_6: length 4.2
  TOP w0.102: PQ4405.6 124.09,168.26 PR4450.1 125.09,167.1 PC4426.2 v1(126.39,167.1)
PQ4408_C: length 4.5
  TOP w0.102: PQ4408.C 114.68,167.35 PR4462.2 112.66,167.35 112.44,167.57 v1(112.44,167.85) 112.44,168.1 112.58,168.24 PR4451.1
PQ4408_E: length 3.8
  TOP w0.102: PR4431.2 PR4433.1 118.07,168.81 117.91,168.65 PQ4408.E 116.9,169.68 v1(117.09,169.87)
PR4601_1: length 2.4
  TOP w0.254: PR5101.2 49.72,16.3 v1(50.28,16.3) 50.98,16.3 PR5106.1
PR4605_2: length 2.9
  TOP w0.508: v1(52.51,25.33) 53.2,24.65 PR5105.2 PC5119.1
PROC_SELECT#: length 5.9
  BOTTOM w0.089: 99.03,96.73 99.3,96.46 99.3,94.22 CPU1.C64
  BOTTOM w0.102: R603.1 97.38,98.12 v1(97.45,98.05) 97.71,98.05 99.03,96.73
PROJECT_ID1: length 14.8
  TOP w0.102: v2(137.53,65.5) 137.53,65.8 v1(137.8,66.07)
  L4 w0.102: v2(137.53,65.5) 136.45,65.5 136.1,65.85 135.97,65.85 134.67,67.16 134.67,67.53 132.36,69.84 132.36,71.01 131.84,71.53 131.77,71.53 v2(131.74,71.56)
  BOTTOM w0.089: v2(131.74,71.56) 131.57,71.73 131.57,73.14 131.72,73.29 131.72,73.57 131.39,73.91 CPU1.AY8
  BOTTOM w0.102: R2015.2 139.3,64.71 R2016.1 138.31,64.71 137.53,65.49 v2(137.53,65.5)
PROJECT_ID2: length 17.4
  TOP w0.102: v2(138.18,65.46) v1(138.18,64.9)
  L4 w0.102: v2(131.89,70.82) 131.89,70.04 134.48,67.45 134.48,67.08 134.72,66.84 134.72,65.71 135.53,64.9 137.61,64.9 v2(138.18,65.46)
  BOTTOM w0.089: v2(131.89,70.82) 131.35,71.37 131.35,73.39 CPU1.BA8
  BOTTOM w0.102: R2018.1 141.09,64.1 140.46,64.73 R2017.2 139.53,65.46 v2(138.18,65.46)
PS_ID: length 163.4
  TOP w0.102: v2(187.9,84.34) 187.9,83.68 187.44,83.22 186.78,83.22 186.48,82.91 KBC24.36 ; PR4304.2 PR4305.2 123.63,173.7 123.88,173.45 PD4302.3 125.34,175.97 v2(125.15,176.17)
  L3 w0.102: v2(187.9,84.34) 185.94,84.34 184.84,85.44 184.84,86.1 184.88,86.13 184.88,86.65 184.6,86.92 180.52,86.92 180.09,87.36 177.75,87.36 177.24,87.87 176.72,87.87 176.57,87.71 175.97,87.71 175.77,87.91 172.53,87.91 172.08,88.35 170.73,88.35 170.36,87.98 168.03,87.98 v2(167.93,88.08) ; v2(162.97,166.62) 162.12,167.47 161.6,167.47 160.3,168.77 159.44,168.77 154.52,173.7 150.8,173.7 149.45,175.05 136,175.05 134.82,176.23 127.32,176.23 127.03,175.94 125.38,175.94 v2(125.15,176.17)
  L4 w0.102: v2(167.93,88.08) 167.93,89.24 168.18,89.49 168.18,90.57 168.02,90.72 168.02,92.69 168.16,92.83 168.16,93.37 168.02,93.51 168.02,94.85 168.25,95.08 168.25,96 170.43,98.17 170.43,102.45 171.31,103.34 171.31,109.52 172.95,111.15 172.95,111.63 171.01,113.57 171.01,114.85 171.88,115.72 171.88,116.45 172.24,116.8 172.24,125.78 168.01,130 167.61,130.4 167.61,134.16 167.17,134.6 166.77,135 166.77,135 164.9,136.87 164.9,137.47 164.1,138.26 164.1,139.58 164.1,143.31 163.2,144.21 163.2,145.58 164.74,147.11 164.74,149.46 166.42,151.14 166.42,156.86 163.99,159.29 163.99,162.84 163.38,163.45 163.38,165.69 162.97,166.1 v2(162.97,166.62)
  BOTTOM w0.102: v2(162.97,166.62) 162.97,166.25 v1(163.16,166.05)
PS_ID_R: length 17.2
  TOP w0.102: PR4317.1 102.21,170 AFTP3802.1 101.78,169.58 96.22,169.58 92.4,165.76 DCIN1.4
PS_ID_R1: length 19.9
  TOP w0.635: PR4305.1 121.98,172.81 v2(121.91,172.88)
  L4 w0.635: v2(121.91,172.88) 120.71,174.08 118.46,174.08 117.63,174.91 113.63,174.91 112.5,176.04 105.03,176.04 v2(104.58,176.5)
  vias: v1(105.48,177.12)
PS_ID_R2:
  vias: v1(103.36,172.78)
PS_S3CNTRL: length 4.7
  BOTTOM w0.127: v1(54.83,32.09) 54.83,31.4 54.46,31.02 R4004.2 54.1,30.75 Q4001.6 52.47,30.75 52.34,30.88 52.34,31.25 52.49,31.4 Q4001.5
PSID_DISABLE#_R_C:
  vias: v1(110.43,176.86)
PSYS: length 3.3
  TOP w0.102: v2(111.78,147.71) 111.93,147.71 112.51,147.12 PU4601.46
  BOTTOM w0.102: PR4671.2 v1(111.79,146.96) 111.79,147.69 v2(111.78,147.71)
PTP_DIS#: length 19.3
  TOP w0.102: v2(172.43,70.71) 172.53,70.61 KBC24.90 ; v2(172.92,60.5) v1(172.03,60.5) 170.41,60.5 169.82,61.1 166.71,61.1 166.51,60.9 D2405.K
  BOTTOM w0.102: v2(172.92,60.5) 172.44,60.98 172.44,65.5 172,65.93 172,70.28 v2(172.43,70.71)
PTP_INT#_EC: length 3.7
  TOP w0.102: v1(189.68,84.21) 189.36,83.89 R2431.2 188.6,82.48 188.27,82.16 KBC24.33
PU4301_G: length 39.2
  TOP w0.254: PC4308.1 111.5,169.73 111.75,169.48 v1(112,169.48) 112.26,169.48 112.31,169.52 112.31,169.52 112.52,169.73 v2(112.52,170.46) ; v2(95.96,153.67) 95.96,154.23 96.26,154.53 PU4301.4
  L3 w0.254: v2(95.96,153.67) 95.96,154.23 97.18,155.45 97.18,162.67 96.41,163.43 96.41,167.77 98.53,169.89 104.65,169.89 105.58,170.82 108.34,170.82 109.99,169.17 111.22,169.17 v2(112.52,170.46)
  BOTTOM w0.254: PR4319.2 112.39,170.59 v2(112.52,170.46)
PURE_HW_SHUTDOWN#: length 340.7
  TOP w0.102: Q4002.C 29.18,54.32 29.18,60.06 v2(30.17,61.04) 30.58,61.45 31.29,61.45 31.61,61.13 31.61,59.91 31.01,59.31 D4001.K ; v2(193.13,125.62) 193.13,125.7 192.4,126.43 190.48,126.43 189.93,125.88 188.04,125.88 187.16,125 185.29,125 183.23,122.94 183.23,122.07 181.47,120.31 181.47,117.26 179.18,114.96 178.54,114.96 177.28,113.7 177.28,112.88 175.38,110.98 174.15,110.98 171.6,108.43 167.99,108.43 167.37,107.81 v1(167.37,105.8) 167.37,101.25 v2(163.76,97.63)
  L3 w0.102: v2(30.17,61.04) 32.77,63.64 49.03,63.64 56.12,56.55 56.12,38.54 57.63,37.03 57.63,35.45 60.74,32.35 61.95,32.35 63.78,30.51 65.06,30.51 65.31,30.27 66.23,30.27 72.88,23.61 72.88,23.41 73.55,22.75 73.55,19.21 77.99,14.76 91.09,14.76 95.82,10.03 130.31,10.03 136.21,15.94 140.23,15.94 149.2,24.91 155.84,24.91 156.11,25.18 163.24,25.18 166.32,22.1 167.29,22.1 167.6,22.4 169.01,22.4 169.32,22.1 172.13,22.1 172.77,21.46 173.86,21.46 v2(174.69,22.28)
  L4 w0.102: v2(163.76,97.63) 163.76,97.05 164.66,96.15 164.66,94.53 164.23,94.11 164.23,92.88 166.16,90.95 166.16,90.09 166.5,89.75 166.5,86.38 167.16,85.72 167.16,85.53 167.3,85.39 167.3,84.3 168.03,83.56 168.03,83.17 167.61,82.75 167.61,82.39 168.16,81.84 168.16,79.05 167.93,78.82 167.93,77.75 167.93,77.75 167.93,77.39 168.31,77.01 168.31,77 168.42,76.9 168.42,76.54 167.91,76.03 167.91,74.51 168.37,74.05 168.37,73.63 168.63,73.37 168.63,72.4 167.98,71.76 167.98,69.01 167.84,68.88 167.84,68.24 167.86,68.22 167.86,66.06 166.84,65.04 166.84,63.13 166.73,63.02 166.73,52.74 167.35,52.12 167.35,44.23 167.39,44.2 167.39,42.47 166.9,41.98 166.9,38.51 172.74,32.67 172.74,32.18 173.43,31.49 173.43,28.7 174.07,28.06 174.07,25.18 174.74,24.52 174.74,24.07 174.79,24.02 174.79,22.39 v2(174.69,22.28)
  BOTTOM w0.102: v2(163.76,97.63) 163.14,97.01 Q2602.D 162.41,96.23 162.2,96.43 162.2,97.85 162.38,98.02 C2610.1 R2612.1 ; C7610.1 191.88,124.86 R7653.2 193.13,125.26 v2(193.13,125.62)
PWR_1D0V_BOOT:
  vias: v1(148.62,137.47) v2(147.99,137.34)
PWR_1D0V_BOOT_R:
  vias: v1(148.33,135.18)
PWR_1D0V_BYP: length 3.1
  BOTTOM w0.254: PU5301.7 147.37,138.01 PR5303.1 148.03,138.18 148.59,138.74 v1(148.59,138.89)
PWR_1D0V_EN: length 7.8
  BOTTOM w0.127: v1(152.96,131.76) 152.96,131.91 153.23,132.18 PR5309.2 PR5311.2 152.86,133.66 152.8,133.59 PR5307.1 PC5311.1 151.21,133.59 150.89,133.27 149.83,133.27 148.66,134.44 PU5301.1
PWR_1D0V_FB: length 3.9
  BOTTOM w0.254: PU5301.4 149.04,135.79 v1(149.13,135.88) 149.16,135.9 PR5305.1 150.41,135.9 150.48,135.84 PC5306.2 PR5301.2
PWR_1D0V_ILMT: length 3.3
  BOTTOM w0.254: PU5301.3 148.97,135.34 149.36,134.95 PR5308.2 150.05,134.37 v1(150.48,133.95)
PWR_1D0V_LDO: length 3.3
  BOTTOM w0.254: PC5304.1 149.15,137.87 v1(149.04,137.76) 148.72,137.44 148.72,136.46 148.49,136.24 PU5301.5
PWR_1D0V_LX:
  vias: v1(144.59,135.16) v2(146.3,133.63)
PWR_1D0V_PG: length 8.3
  BOTTOM w0.127: v1(153.48,136.45) PR5304.2 PR5310.2 152.7,134.57 152.39,134.27 151.39,134.27 150.69,133.56 150.04,133.56 148.72,134.89 PU5301.2
PWR_1D05V_EN: length 3.9
  BOTTOM w0.305: 147.86,152.46 147.59,152.73 PU8301.5
  BOTTOM w0.508: 147.86,152.46 148.18,152.14 PC8302.1 147.72,151.43 147.63,151.52 v1(147.23,151.52) PR8305.2
PWR_1D5V_EN: length 5.4
  TOP w0.127: PU5402.3 39.4,18.6 39.26,18.74 39.26,19.58 39.58,19.91 v1(39.95,19.91) 40.98,19.91 PC5407.1 41.42,19.88 41.91,19.4 PR5405.2
PWR_1D05V_FB: length 4.2
  BOTTOM w0.305: 144.52,152.53 144.5,152.55 PU8301.6
  BOTTOM w0.508: 144.52,152.53 v1(144.52,151.88) PR8302.1 PR8303.2 143.09,151.53 PC8305.2
PWR_1D05V_PGOOD: length 5.2
  BOTTOM w0.127: PU8301.4 148.36,153.71 149.03,153.05 PR8304.2 PR8320.1 v1(150.95,151.44)
PWR_1D05V_PHASE:
  vias: v1(147.74,156.77)
PWR_1D05V_PVDD:
  vias: v1(142.01,157)
PWR_1D05V_SVIN: length 3.2
  BOTTOM w0.203: PC8301.1 143.02,153.7 v1(143.33,154) 143.53,154.21 PU8301.8
  BOTTOM w0.508: PC8301.1 PR8301.2
PWR_1D8V_EN: length 7
  BOTTOM w0.127: PR5406.2 174.47,113.92 PR5407.2 174.48,113.49 PR5401.1 PC5406.1 174.05,111.71 174.11,111.65 PU5401.8 v1(176.12,110.03)
PWR_1D8V_POK: length 5
  BOTTOM w0.127: PU5401.7 172.84,111.45 173.16,111.77 PR5402.2 PR5408.2 172.27,113.57 172.59,113.89 v1(172.59,114.41)
PWR_1D35V_DRVH: length 16.4
  TOP w0.203: v3(50.54,23.27) 50.54,23.02 50.18,22.66 PU5101.14
  L3 w1.016: v3(62.56,25.43) 61.35,25.43 59.98,26.8 52.61,26.8 50.54,24.73 v3(50.54,23.27)
  vias: v1(63.26,25.42)
PWR_1D35V_DRVL: length 10.1
  TOP w0.203: 49.42,21.1 PU5101.11
  TOP w0.254: v3(49.78,20.73) 49.42,21.09 49.42,21.1
  L3 w1.016: v3(58.03,18.44) 52.73,18.44 51.19,19.99 50.52,19.99 v3(49.78,20.73)
  vias: v1(58.09,17.69)
PWR_1D35V_EN: length 4.9
  TOP w0.127: v1(51.8,26.35) 51.8,26.15 51.02,25.38 PR5107.2 PC5106.1 49.94,24.81 49.76,24.63 48.96,24.63 48.67,24.34 PU5101.16
PWR_1D35V_MODE: length 3.2
  TOP w0.203: 47.26,24.7 47.47,24.49 PU5101.19
  TOP w0.254: 47.26,24.7 47.02,24.94 46.6,24.94 v1(46.37,25.16) 46.08,25.45 PR5108.1
PWR_1D35V_REFIN: length 5.2
  TOP w0.203: 47.87,19.37 PU5101.8
  TOP w0.254: 47.87,19.37 48.07,19.18 PR5103.2 48.49,18.01 PC5102.1 49.3,17.61 PR5101.1 49.37,17.55 v1(50.36,17.55)
PWR_1D35V_SW: length 18
  TOP w0.203: v3(51.05,22) 50.53,22 50.27,22.25 PU5101.13
  TOP w0.508: PC5119.2 51.87,22.32 51.56,22 v3(51.05,22)
  L3 w1.016: v3(51.05,22) 51.07,22 51.81,22.74 51.81,24.21 53.14,25.53 59.27,25.53 v3(62.36,22.45)
  vias: v1(63.44,24.21) v3(61.14,18.01) v3(62.18,18.01) v3(62.45,19.19) v3(62.51,24.16) v3(62.51,21.12) v3(63.11,20.14) v3(63.23,18.32) v3(63.26,23.34)
PWR_1D35V_TRIP: length 2.5
  TOP w0.203: 47.87,24.62 PU5101.18
  TOP w0.254: 47.87,24.62 47.87,25.1 v1(47.79,25.19) PR5102.1
PWR_1D35V_VBST: length 3.3
  TOP w0.203: PU5101.15 49.42,23.56
  TOP w0.508: PR5105.1 v1(50.68,24.13) 49.75,24.13 49.42,23.81 49.42,23.56
PWR_1D35V_VDDQS: length 34.1
  TOP w0.203: 48.28,19.64 48.27,19.65 PU5101.9
  TOP w0.254: v1(49,18.52) 48.76,18.75 v2(48.76,19.21) 48.76,19.21 48.61,19.36 48.56,19.36 48.28,19.64
  BOTTOM w0.254: v2(48.76,19.21) 48.84,19.28 49.76,19.28 51.82,17.23 52.81,17.23 53.19,16.84 53.19,16.84 54.58,15.46 63.07,15.46 64.81,13.72 73.16,13.72 73.66,14.22 73.66,16.8 73.23,17.23 PG5107.1
PWR_1D35V_VREF: length 4.6
  TOP w0.203: PU5101.6 47.07,19.88
  TOP w0.254: v1(46.54,17.43) 46.72,17.61 PC5103.1 47.6,18.01 PR5103.1 46.83,18.78 46.83,19.36 47.07,19.61 47.07,19.88
PWR_1D35V_VTTREF:
  vias: v1(45.03,20.35)
PWR_3D3V_CS2: length 3.9
  TOP w0.203: PU4503.5 37.87,56.69
  TOP w0.254: PR4517.1 35.76,57.36 v1(35.94,57.54) 36.06,57.67 36.61,57.67 37.58,56.69 37.87,56.69
PWR_3D3V_DRVH2: length 16.7
  TOP w0.203: v3(36.72,53.74) 36.72,53.87 37.19,54.34 PU4503.10
  L3 w1.016: v3(31.26,41.55) 31.26,41.89 31.74,42.37 31.74,49.42 35.82,53.49 36.47,53.49 v3(36.72,53.74)
  BOTTOM w0.508: v1(36.08,53.59) 36.24,53.74 v3(36.72,53.74)
PWR_3D3V_DRVL2: length 9.4
  TOP w0.203: PU4503.11 38.34,52.78 v3(38.12,52.56)
  L3 w1.016: v3(38.12,52.56) 33.55,47.99 v3(33.55,46.89)
  BOTTOM w0.508: v1(38.08,51.9) 38.12,51.94 v3(38.12,52.56)
PWR_3D3V_EN2: length 2.5
  TOP w0.127: PU4503.6 37,55.94 36.58,56.36 v1(36.29,56.36) 35.34,56.36 PR4506.2
PWR_3D3V_FB2: length 5.5
  TOP w0.203: PU4503.4 38.74,57.16 38.46,57.43 37.97,57.43
  TOP w0.254: 37.97,57.43 37.46,57.94 PR4523.1 37.4,58.58 36.56,58.58 v1(36.55,58.59) 36.55,59.45 PR4512.2 PC4523.2
PWR_3D3V_FB2_R: length 2.1
  TOP w0.254: PC4523.1 35.71,61.15 PR4535.2 34.57,61.21 v1(34.47,61.11)
PWR_3D3V_LL2: length 19.5
  TOP w0.203: v3(35.96,54.76) 35.96,54.89 36.22,55.14 PU4503.8
  TOP w0.508: v3(35.96,54.76) 35.58,54.38 PC4535.2
  L3 w1.016: v3(29.99,41.52) 29.99,42.55 30.47,43.04 30.47,49.94 35.29,54.76 v3(35.96,54.76)
  vias: v1(33.37,40.23) v3(29.1,40.41) v3(30.25,40.41) v3(32.66,41.17) v3(33.68,41.17) v3(34.69,41.17) v3(35.71,41.17) v3(36.44,40.54)
PWR_3D3V_SNUB: length 2.9
  TOP w0.508: PR4533.2 37.98,43.52 v1(37.74,43.76) PC4520.1
PWR_3D3V_VBST2: length 3.7
  TOP w0.203: PU4503.9 36.85,54.74 35.65,53.54
  TOP w0.508: 35.65,53.54 v1(35.65,53.54) 35.22,53.11 PR4528.2
PWR_3D3V_VBST2_1: length 2.6
  TOP w0.508: PC4535.1 PR4528.1 33.24,52.96 v1(32.42,52.13)
PWR_5V_CS1: length 3.9
  TOP w0.203: PU4503.1 39.94,57.07 40.17,57.31
  TOP w0.254: PR4531.1 42.29,57.97 v1(42.11,57.79) 41.86,57.79 41.38,57.31 40.17,57.31
PWR_5V_DRVH1: length 17.5
  TOP w0.203: PU4503.16 41.08,54.34 v3(41.55,53.87)
  L3 w1.016: v3(41.55,53.87) 42.25,53.87 48.76,47.35 48.76,41.65 v3(48.66,41.55)
  BOTTOM w0.508: v3(41.55,53.87) 41.25,53.87 v1(40.96,54.17)
PWR_5V_DRVL1: length 9.2
  TOP w0.203: PU4503.15 39.94,53.2 40.28,52.85 v3(40.79,52.85)
  L3 w1.016: v3(40.79,52.85) 41.17,52.47 v3(41.17,45.87)
  BOTTOM w0.508: v1(40.76,52.19) 40.79,52.22 v3(40.79,52.85)
PWR_5V_EN1: length 4.9
  TOP w0.127: PU4503.20 40.69,56.3 41.16,56.77 42.68,56.77 43.32,57.41 v1(43.32,57.41) 43.32,58.61 PR4504.2
PWR_5V_EN1_R: length 16.4
  TOP w0.127: PR4507.2 34.16,58.38 PR4530.1 PR4501.2 33.45,59.98 33.45,60.81 v1(33.26,61) 33.04,61.22 v2(32.74,61.22) ; PR4504.1 43.17,60.83 v2(42.92,61.09)
  L3 w0.127: v2(42.92,61.09) 42.92,61.25 42.04,62.13 33.9,62.13 33.07,61.3 32.82,61.3 v2(32.74,61.22)
PWR_5V_FB1: length 5
  TOP w0.203: 39.68,57.33 39.54,57.18 PU4503.2
  TOP w0.254: v1(39.75,61.58) 39.75,61.26 39.68,61.19 39.68,60.73 39.68,60.73 PR4526.1 PR4527.2 PC4522.2 39.68,57.33
PWR_5V_FB1_R: length 2.5
  TOP w0.254: PC4522.1 40.57,57.9 v1(40.63,57.84) 41.12,57.84 41.4,58.12 PR4525.2
PWR_5V_LL1: length 24
  TOP w0.203: v3(41.8,55.14) PU4503.18
  TOP w0.508: PC4516.2 43.15,55.14 v3(41.8,55.14)
  L3 w1.016: v3(47.39,40.54) 47.39,40.46 47.57,40.28 49.19,40.28 50.03,41.13 50.03,47.89 42.78,55.14 v3(41.8,55.14)
  vias: v1(44.14,40.38) v3(41.68,41.42) v3(42.57,41.42) v3(43.45,41.42) v3(44.34,41.42) v3(45.23,41.42) v3(46.12,41.42) v3(46.99,41.45)
PWR_5V_SNUB: length 2.9
  TOP w0.508: PC4536.1 39.77,43.85 v1(39.78,43.85) 39.78,42.4 PR4529.2
PWR_5V_VBST1: length 3.2
  TOP w0.203: v1(42.39,54.25) 42.06,54.58 41.35,54.58 41.19,54.74 PU4503.17
  TOP w0.508: v1(42.39,54.25) 42.39,54.25 43.02,53.62 PR4524.1
PWR_5V_VBST1_1: length 2.4
  TOP w0.508: v1(44.73,52.47) 44.72,52.47 PR4524.2 PC4516.1
PWR_5V_VCLK: length 2.8
  TOP w0.102: TP4501.1 43.13,56.07 41.85,56.07 41.31,55.54 PU4503.19
PWR_5V_VO1: length 92.2
  TOP w0.203: v2(39.64,52.73) 39.54,52.84 PU4503.14
  TOP w0.508: v2(41.4,60.41) PR4525.1 41.33,59.59 PR4527.1
  L3 w0.508: v2(43.62,31.01) 44.46,31.84 50.2,31.84 51.92,33.57 51.92,53.39 48.09,57.22 41.39,57.22 40.41,56.24 40.41,54.83 39.64,54.06 v2(39.64,52.73)
  BOTTOM w0.254: v2(43.62,31.01) 43.48,31.15 PG4532.2 43.48,32.65 44.71,33.88 48.86,33.88 52.56,37.58 52.56,52.66 45.47,59.75 41.92,59.75 41.4,60.28 v2(41.4,60.41)
  BOTTOM w0.508: v2(39.64,52.73) 39.64,52.38 v1(39.32,52.06)
PWR_CHG_1: length 19.4
  TOP w0.254: v2(113.43,156.85) 112.92,157.36 112.29,157.36 111.93,157 v1(109.72,157) 108.2,158.52 108.2,161.79 109.31,162.91 114.23,162.91 PD4402.K 116.67,162.59 PD4405.K
  BOTTOM w0.254: v2(113.43,156.85) 113.39,156.89 PR4407.1
PWR_CHG_ACDET: length 4.6
  BOTTOM w0.203: PU4401.6 105.77,157.37
  BOTTOM w0.254: 105.77,157.37 v1(105.77,157.03) 105.77,156.97 106.59,156.15 PR4409.1 PC4413.1 PR4408.2
PWR_CHG_ACN: length 12.9
  TOP w0.203: v1(106.9,155.71) 106.9,155.81 ; 106.9,155.81 107.48,155.81 108.6,154.69 109.72,154.69 v2(110.23,155.2) ; 106.9,155.81 106.03,155.81 105.46,155.23 105.46,154.69 PG4403.2
  BOTTOM w0.203: PC4404.2 110.23,154.65 v2(110.23,155.2) 110.29,155.26 PC4402.1 PR4404.1 109.46,157.51 107.88,157.51 107.77,157.62 PU4401.1
PWR_CHG_ACOK: length 233.9
  TOP w0.102: D1703.K 162.5,66.84 v2(162.83,67.18) ; PR4432.1 PR4463.2 112.07,164.94 v2(111.88,164.75) PR4435.2 ; R2469.1 190.47,61.93 v1(189.61,61.93) 189.61,62.38 v2(189.81,62.59)
  L3 w0.102: v2(111.88,164.75) 111.88,165.91 113.67,167.71 123.75,167.71 124.88,166.58 126.18,166.58 126.35,166.75 130.06,166.75 130.38,166.43 135.79,166.43 138.31,168.95 146.52,168.95 156.68,158.79 158.22,158.79 159.14,157.86 159.14,151.01 161.34,148.82 162.85,148.82 165.35,146.32 v2(167.06,146.32) ; v2(162.83,67.18) 162.87,67.14 166.52,67.14 166.92,66.74 168.56,66.74 169.57,65.72 173.1,65.72 173.68,66.3 177.76,66.3 177.88,66.18 180.34,66.18 181.95,64.58 181.95,63.56 183.28,62.23 186.05,62.23 186.37,61.91 188.36,61.91 188.49,62.04 189.19,62.04 189.4,62.25 189.47,62.25 v2(189.81,62.59) 191.69,64.47 195.18,64.47 196.06,65.35 196.06,68.93 196.82,69.68 196.82,72.85 197.95,73.99 197.95,90.5 192.7,95.75 191.4,95.75 189.85,97.31 189.85,98.89 185.31,103.42 185.11,103.42 184.5,103.42 v2(182.05,105.87)
  L4 w0.102: v2(167.06,146.32) 167.06,145 167.52,144.53 167.52,143.87 166.86,143.21 166.86,141.05 170.14,137.76 170.14,133.05 172.11,131.09 172.11,129.1 177.22,123.99 177.22,122.41 180.79,118.84 180.79,118.31 181.44,117.67 181.44,112.21 182.05,111.6 v2(182.05,105.87) ; v2(106.37,157.14) 106.36,157.14 101.59,161.9 101.59,163.35 102.36,164.11 105.28,164.11 105.79,164.62 107.68,164.62 108.14,164.16 109.65,164.16 110.23,164.75 v2(111.88,164.75)
  BOTTOM w0.102: PR4416.2 106.85,156.66 v2(106.37,157.14) 106.17,157.33 PU4401.5
PWR_CHG_ACP: length 12.3
  TOP w0.203: PG4402.2 104.56,154.15 105.13,154.72 105.13,155.15 ; v1(104.97,155.15) 105.13,155.15 ; 105.13,155.15 105.13,155.37 105.9,156.14 107.61,156.14 108.73,155.02 109.29,155.02 v2(109.47,155.2)
  BOTTOM w0.203: PC4403.2 v2(109.47,155.2) 109.47,155.8 PC4402.2 PR4404.2 109.48,156.75 109.48,157.02 109.32,157.18 107.74,157.18 107.54,157.38 107.37,157.55 PU4401.2
PWR_CHG_AD_OFF_R: length 11.6
  TOP w0.102: v2(120.64,177.45) 121.55,176.54 PQ4304.B ; v2(115.82,176.56) 115.88,176.62 PR4310.2 PR4311.1 117.47,176.28 117.07,175.88 PQ4303.6
  L3 w0.102: v2(115.82,176.56) 118.52,176.56 118.75,176.79 119.98,176.79 v2(120.64,177.45)
  BOTTOM w0.102: v2(115.82,176.56) v1(116.46,176.56)
PWR_CHG_BATPRES#: length 3.5
  BOTTOM w0.203: 104.9,163.22 105.37,162.75 PU4401.15
  BOTTOM w0.254: 104.9,163.22 104.49,163.22 v1(103.97,163.75) 103.63,164.09 PG4416.2
PWR_CHG_BATSRC: length 2.6
  BOTTOM w0.203: PU4401.17 106.17,162.26 106.17,163.28 106.17,163.28
  BOTTOM w0.254: PR4414.1 v1(106.29,163.91) 106.29,163.58 106.17,163.46 106.17,163.28
PWR_CHG_BTST: length 4.8
  BOTTOM w0.203: PC4414.1 110.91,160.61 v1(110.39,160.61) 109.78,160.61 109.39,160.23 PU4401.25
  BOTTOM w0.508: PC4414.1 111.92,160.21 PD4403.K
PWR_CHG_CMPIN: length 4.2
  BOTTOM w0.203: PU4401.13 104.05,161.03 103.73,161.34 103.73,161.57
  BOTTOM w0.254: 103.73,161.57 103.73,161.95 103.47,162.21 v1(103.24,162.21) 102.84,162.21 102.48,161.85 PR4424.1 PR4421.2
PWR_CHG_CMPOUT: length 1.7
  TOP w0.254: v2(104.52,162.21) 104.52,161.45 TP4404.1
  BOTTOM w0.203: v2(104.52,162.21) 104.54,162.18 PU4401.14
PWR_CHG_CMSRC: length 3.1
  BOTTOM w0.203: PU4401.3 106.97,157.16 v1(107.1,157.04)
  BOTTOM w0.254: v1(107.1,157.04) 107.47,156.66 108.05,156.66 108.36,156.35 PR4410.2
PWR_CHG_HIDRV: length 19.4
  TOP w0.356: v3(125.47,156.24) v1(126.46,156.24)
  L4 w1.016: v3(109.98,159.92) 119.01,159.92 122.7,156.24 v3(125.47,156.24)
  BOTTOM w0.203: v3(109.98,159.92) 109.88,159.83 PU4401.26
PWR_CHG_IADP: length 3.2
  BOTTOM w0.203: 105.07,158.2 PU4401.7
  BOTTOM w0.254: 105.07,158.2 104.9,158.2 103.92,157.22 v1(103.92,156.86) PG4401.1
PWR_CHG_IDCHG: length 3.6
  BOTTOM w0.203: PU4401.8 104.2,159.03 103.63,158.47
  BOTTOM w0.254: 103.63,158.47 103.26,158.09 v1(103.26,157.99) 103.26,157.48 102.79,157 PG4414.1
PWR_CHG_ILIM: length 8.7
  TOP w0.102: v2(107.97,163.61) v1(107.97,164.17)
  L4 w0.102: v2(107.97,163.61) 107.97,163.61 v2(102.86,163.61)
  BOTTOM w0.102: v2(107.97,163.61) 107.77,163.42 PU4401.21 ; PR4423.1 PR4420.2 v2(102.86,163.61)
PWR_CHG_LODRV: length 14.4
  TOP w0.356: v3(121.03,163.73) v1(120.32,163.73)
  L4 w1.016: v3(121.03,163.73) 116.71,163.73 115.31,162.34 110.23,162.34 v3(109.85,161.95)
  BOTTOM w0.203: v3(109.85,161.95) 109.85,161.63 109.25,161.03 PU4401.23
PWR_CHG_PHASE: length 26.2
  L4 w1.016: v3(125.22,159.73) 126.86,158.09 126.86,155.59 126.14,154.87 122.07,154.87 118.31,158.63 v3(110.72,158.63)
  BOTTOM w0.203: 109.68,159.09 109.34,159.43 PU4401.27
  BOTTOM w0.508: PC4414.2 111.31,159.23 v3(110.72,158.63) 110.13,158.63 109.68,159.09
  vias: v1(127.15,164.24)
PWR_CHG_PHASE_1:
  vias: v1(133.57,157.43) v3(131.31,162.59) v3(132.2,161.45) v3(133.09,162.46) v3(134.11,161.45) v3(135,162.59) v3(135.25,160.68) v3(136.39,161.95) v3(136.77,160.68) v3(138.3,160.68)
PWR_CHG_PMON: length 3.4
  BOTTOM w0.203: PU4401.9 103.87,159.43 103.61,159.17 103.4,159.17
  BOTTOM w0.254: 103.4,159.17 v1(102.91,159.17) 102.54,159.17 102.15,158.78 PG4415.1
PWR_CHG_PROCHOT#: length 4.4
  BOTTOM w0.14: PU4401.10 102.28,159.83 101.7,159.25 v1(101.44,159.25) 100.81,159.25 PR4418.2
PWR_CHG_REGN: length 11.3
  TOP w0.254: v2(109.6,164.75) PR4435.1 110.34,164.71 PC4401.2
  BOTTOM w0.203: 110.11,161.23 109.9,161.02 109.67,161.02 109.28,160.63 PU4401.24
  BOTTOM w0.254: 110.11,161.23 110.54,161.66 PD4403.A 112.75,162.55 112.24,163.06 111.28,163.06 v1(111.11,163.24) v2(109.6,164.75)
PWR_CHG_SCL: length 4.7
  BOTTOM w0.14: PG4410.1 100.39,161.19 102.04,161.19 102.25,160.97 v1(103.22,160.97) 103.43,160.97 103.77,160.63 PU4401.12
PWR_CHG_SDA: length 4
  BOTTOM w0.14: PG4409.1 v1(101.59,160.48) 103.32,160.48 103.57,160.23 PU4401.11
PWR_CHG_SRN: length 2.8
  BOTTOM w0.203: 106.97,163.43 PU4401.19
  BOTTOM w0.254: 106.97,163.43 106.97,163.88 107.44,164.34 107.44,164.56 PR4419.1
PWR_CHG_SRN_1: length 28.8
  TOP w0.254: PG4413.1 129.44,166.02 v1(129.27,165.84) v2(128.85,165.43)
  L4 w0.254: v2(107.18,167.29) 107.51,167.62 107.51,168.41 108.61,169.51 109.94,169.51 110.26,169.19 118.07,169.19 119.72,167.54 126.51,167.54 128.62,165.43 v2(128.85,165.43)
  BOTTOM w0.254: PC4422.1 107.31,167.42 v2(107.18,167.29) 107.25,167.23 PC4420.2 107.18,166.46 PR4419.2
PWR_CHG_SRP: length 3.9
  BOTTOM w0.203: 107.37,163.29 PU4401.20
  BOTTOM w0.254: v1(108.99,164.46) 108.64,164.81 PR4417.1 107.82,164.56 107.82,164.18 107.35,163.72 107.35,163.31 107.37,163.29
PWR_CHG_SRP_1: length 28.2
  TOP w0.254: PG4412.1 129.33,164.24 v1(129.26,164.3) v2(128.83,164.74)
  L4 w0.254: v2(128.83,164.74) 128.77,164.74 126.35,167.16 119.56,167.16 117.91,168.81 110.1,168.81 109.78,169.13 108.77,169.13 107.9,168.25 107.9,167.59 v2(108.2,167.29)
  BOTTOM w0.254: PR4417.2 108.07,166.46 PC4420.1 108.14,167.23 v2(108.2,167.29) PC4421.1
PWR_CHG_STAT#: length 4.5
  BOTTOM w0.203: 105.77,163.05 PU4401.16
  BOTTOM w0.254: 105.77,163.05 105.77,163.24 105.47,163.54 TP4405.1
PWR_CHG_VCC: length 4.7
  BOTTOM w0.203: PU4401.28 108.61,158.73
  BOTTOM w0.254: PR4407.2 112.4,157.54 PC4412.2 110.23,157.54 v1(109.96,157.8) 109.52,158.25 109.09,158.25 108.61,158.73
PWR_DCBATOUT_1D0V: length 1.4
  TOP w0.508: v2(142.54,138.01) 142.54,137.98 142.55,137.97 EC5301.1
  vias: v1(141.45,138.82)
PWR_DCBATOUT_3D3V:
  vias: v1(30.32,48.69) v3(28.98,49.58) v3(28.98,48.69) v3(28.98,47.67)
PWR_DCBATOUT_5V:
  vias: v1(47.74,49.89) v3(46.76,47.77) v3(46.76,46.89) v3(47.77,46.89)
PWR_LED: length 5.1
  BOTTOM w0.508: R6409.1 184.57,120.8 EC6406.1 184.57,119.14 v1(184.11,118.68) 182.84,117.41 Q6405.C
PWR_LED#: length 27.7
  TOP w0.102: Q2416.S 183.91,57.29 R2498.1 183.38,58.62 v1(182.99,58.23) 182.36,57.6 v2(181.55,57.6) ; KBC24.4 186.68,69.41 185.31,70.78 183.72,70.78 183.48,71.01 181.97,71.01 181.47,70.51 181.07,70.51 v2(180.2,69.65)
  L4 w0.102: v2(180.2,69.65) 180.2,68.92 180.82,68.31 180.82,67.59 180.94,67.47 180.94,64.44 180.79,64.29 180.79,61.73 181.22,61.29 181.3,61.29 181.81,60.78 181.81,57.85 v2(181.55,57.6)
PWR_LED#_B: length 8.7
  BOTTOM w0.102: Q6407.D 180.46,121.08 182.03,119.51 v1(182.03,118.99) 182.03,117.41 180.94,116.32 Q6405.B
PWR_LED#_R: length 9.3
  TOP w0.305: LEDBD1.4 191.02,124.62 190.65,125 190.28,125
  TOP w0.508: 190.28,125 188.34,125 187.26,123.92 185.56,123.92 AFTP6305.1 v2(184.28,122.64)
  BOTTOM w0.508: v2(184.28,122.64) 184.28,121.98 R6409.2
PWR_LED#_S: length 75.7
  TOP w0.102: Q2416.D 181.85,56.08 v2(182.62,56.85)
  L4 w0.102: v2(182.62,56.85) 182.92,57.15 182.92,57.46 182.93,57.46 182.93,59.11 182.92,59.11 182.92,59.19 182.27,59.85 182.27,63.05 182.21,63.1 182.21,63.78 182.27,63.83 182.27,65.7 182.47,65.91 182.47,68.79 182.16,69.1 182.16,69.93 181.99,70.11 181.96,70.11 181.71,70.36 181.71,70.39 181.4,70.69 v2(181.4,71.66)
  BOTTOM w0.102: Q6407.S 175.65,122.07 174.79,121.2 v1(174.79,119.11) 174.79,115.83 174.96,115.67 174.96,114.72 176.48,113.2 176.48,109.03 176.06,108.61 176.06,105.81 177.01,104.86 177.01,100.46 180.8,96.67 180.8,92.24 180.54,91.98 180.54,91.25 180.13,90.84 180.13,89.78 179.31,88.96 179.31,88.25 176.2,85.13 176.2,82.38 177.47,81.11 177.47,80.53 177.45,80.5 177.45,79.49 177.81,79.13 177.81,77.35 178.52,76.64 178.52,74.8 178.64,74.68 178.64,74.61 179.28,73.98 179.28,72.94 180.55,71.66 v2(181.4,71.66)
PWR_LEVEL: length 8.6
  TOP w0.127: D7602.A 205.11,132.98 D7601.A v1(205.11,134.28) 205.11,135.24 R7605.2 204.06,135.62 v2(203.83,135.39)
  BOTTOM w0.127: v2(203.83,135.39) 203.5,135.71 203.3,135.71 203.09,135.92 203.09,136.13 202.77,136.45 201.57,136.45 201.15,136.87 GPU1.D7
PWR_VCCGT_BOOTA: length 1
  TOP w0.508: v3(113.05,132.82) 113.33,132.54 PR4802.1
  vias: v1(113.02,131.57)
PWR_VCCGT_BOOTA_RC: length 2.6
  TOP w0.356: PR4802.2 113.33,130.29 113.52,130.1 v1(113.52,129.44)
  TOP w0.508: PR4802.2 PC4809.1
PWR_VCCGT_COMP: length 5.7
  TOP w0.203: PU4601.4 109.6,144.79 v2(109.51,144.89)
  BOTTOM w0.254: PC4618.2 107.06,143.22 PC4617.2 107.66,143.98 107.78,143.87 v1(108.32,143.87) 108.99,143.87 109.51,144.39 v2(109.51,144.89)
PWR_VCCGT_COMP_R: length 1.8
  BOTTOM w0.254: PR4631.2 106.17,143.53 106.23,143.47 PC4618.1 105.77,143.16 105.71,143.22 v1(105.33,143.22)
PWR_VCCGT_CSCOMP: length 33.8
  TOP w0.203: PU4601.6 109.95,143.99
  TOP w0.254: v2(104.46,143.88) 104.46,144.5 104.83,144.87 v1(104.95,144.87) PR4639.2 106.33,144.74 PR4640.1 107.05,144.74 PC4620.1 PC4621.1 108.49,143.94 108.54,143.99 109.95,143.99
  L4 w0.254: v2(105.76,123.12) 105.59,123.3 104.31,123.3 101.72,125.88 101.72,142.06 103.47,143.8 104.38,143.8 v2(104.46,143.88)
  BOTTOM w0.254: v2(105.76,123.12) 106.38,123.12 PR4634.2
PWR_VCCGT_CSNA: length 30
  L4 w0.254: v2(104.13,141.15) 104.05,141.07 104.05,138.87 103.61,138.42 103.61,126.86 104.74,125.73 106.73,125.73 107.62,124.84 107.62,121.45 108.13,120.95 110.22,120.95 v2(110.31,121.04)
  BOTTOM w0.254: PG4809.1 110.87,120.48 v2(110.31,121.04) ; PR4646.2 106.05,141.99 105.68,141.62 105.68,141.03 v1(105.32,140.67) 105.24,140.59 104.51,140.59 104.13,140.97 v2(104.13,141.15)
PWR_VCCGT_CSP1: length 5
  TOP w0.203: PU4601.10 110.47,142.39 110.4,142.46 109.99,142.46 109.64,142.11 109.64,142.1 109.4,141.86 v2(109.4,141.7)
  BOTTOM w0.254: PR4651.2 107.96,141.16 PC4623.2 108.2,140.91 109.05,140.91 v1(109.14,141) 109.4,141.26 v2(109.4,141.7)
PWR_VCCGT_CSP2: length 3.5
  TOP w0.203: 109.84,142.84 110.56,142.84 110.61,142.79 PU4601.9
  TOP w0.254: PR4603.2 108.53,142.24 108.6,142.16 v1(109.08,142.16) 109.15,142.16 109.84,142.84
PWR_VCCGT_CSPA: length 33.2
  L4 w0.254: v2(103.5,141.15) 103.62,141.03 103.62,138.97 103.23,138.58 103.23,126.66 104.57,125.32 106.56,125.32 107.21,124.66 107.21,121.28 107.97,120.53 110.54,120.53 v2(111.07,121.06)
  BOTTOM w0.254: PR4651.1 106.3,140.78 105.73,140.21 103.89,140.21 v1(103.56,140.55) 103.5,140.61 v2(103.5,141.15) 103.5,142.07 PR4637.1 ; v2(111.07,121.06) 110.87,121.26 PG4808.1
PWR_VCCGT_CSREF: length 6.2
  TOP w0.203: PU4601.8 110.75,143.19 110.72,143.23 109.79,143.23
  TOP w0.254: 109.79,143.23 109.5,143.23 v2(109.28,143)
  BOTTOM w0.254: PC4626.1 109.54,143.27 v2(109.28,143) v1(108.87,142.59) 108.27,141.99 PC4623.1 PR4646.1
PWR_VCCGT_CSSUM: length 8.9
  TOP w0.203: 109.46,143.61 109.47,143.59 PU4601.7
  TOP w0.254: v2(104.85,141.13) PR4637.2 105.28,142.52 105.6,142.52 PR4638.2 106.65,143.16 106.76,143.05 PC4620.2 PC4621.2 108.4,143.05 v1(108.84,143.49) 108.95,143.61 109.46,143.61
  BOTTOM w0.254: PR4637.2 v2(104.85,141.13)
PWR_VCCGT_DIFFOUT: length 4.9
  TOP w0.203: 110.08,145.59 PU4601.2
  TOP w0.254: v2(108.64,145.65) 108.85,145.85 109.82,145.85 110.08,145.59
  BOTTOM w0.254: v1(109.41,145.67) 108.67,145.67 v2(108.64,145.65) 108.63,145.64 PR4626.1 107.18,145.64 PR4625.1
PWR_VCCGT_DISB#_A: length 3.3
  BOTTOM w0.203: 114.33,129.3 114.19,129.15 PU4801.2
  BOTTOM w0.254: 114.33,129.3 114.56,129.53 PR4808.2 115.76,128.88 v1(116.07,128.57)
PWR_VCCGT_FB: length 7.3
  TOP w0.203: 109.95,145.19 PU4601.3
  TOP w0.254: 109.95,145.19 109.93,145.21 109.69,145.44 109.2,145.44 v2(108.71,144.96)
  BOTTOM w0.254: v2(108.71,144.96) 108.5,144.75 PR4626.2 107.82,144.87 PC4617.1 PR4631.1 105.4,144.87 PC4614.2 104.4,144.75 v1(104.28,144.63)
PWR_VCCGT_FB_R: length 2.1
  BOTTOM w0.254: v1(104.22,145.87) 104.45,145.64 PC4614.1 106.17,145.64 PR4625.2
PWR_VCCGT_ICCMAX: length 3.9
  TOP w0.203: PU4601.18 113.71,140.44 113.43,140.16
  TOP w0.254: v2(113.48,138.99) 113.23,139.24 v1(113.23,139.65) 113.23,139.96 113.43,140.16
  BOTTOM w0.254: v2(113.48,138.99) 113.48,140.02 113.7,140.25 PR4662.1
PWR_VCCGT_ILIM: length 4.5
  TOP w0.203: 109.24,144.39 PU4601.5
  TOP w0.254: PR4640.2 107.25,145.63 v1(107.99,144.89) 108.48,144.39 109.24,144.39
PWR_VCCGT_ILIM_R: length 27.2
  TOP w0.254: PR4639.1 105.61,143.98 105.34,143.72 PR4638.1 104.51,143.16 v2(104.47,143.2)
  L4 w0.254: v2(104.47,143.2) 104.27,143.4 103.61,143.4 102.21,142.01 102.21,126.04 104.52,123.73 105.66,123.73 v2(105.74,123.81)
  BOTTOM w0.254: PR4634.1 106.31,123.81 v2(105.74,123.81) ; v2(104.47,143.2) 104.47,143.21 103.96,143.21 v1(103.91,143.26)
PWR_VCCGT_IOUT: length 4.9
  TOP w0.203: 110.57,145.99 PU4601.1
  TOP w0.254: v2(110.11,146.28) 110.4,145.99 110.57,145.99
  BOTTOM w0.254: v2(110.11,146.28) 110.33,146.06 110.33,145.16 110.52,144.97 PC4615.2 110.88,144.15 PR4632.2 110.14,144.12 v1(109.9,143.89)
PWR_VCCGT_NTC: length 26.2
  TOP w0.254: PR4655.1 107.04,140.58 PR4661.1 107.04,140.49 107.82,139.71 v2(107.82,139.5) ; v2(116.58,126.56) v1(116.58,125.91)
  L4 w0.254: v2(107.82,139.5) 107.67,139.35 107.67,138.56 108.5,137.73 115.79,137.73 117.67,135.85 117.67,128.1 116.58,127.01 v2(116.58,126.56)
  BOTTOM w0.254: PR4656.2 115.7,127.44 v2(116.58,126.56)
PWR_VCCGT_PHASEDA: length 1
  TOP w0.508: PC4809.2 112,132.56 v3(111.73,132.84)
  vias: v1(111.79,131.55)
PWR_VCCGT_PWMA: length 32.8
  TOP w0.203: PU4601.16 112.91,140.26 112.8,140.15 112.8,139.74 112.6,139.54 112.6,139.27 112.23,138.89 112.16,138.89 v2(111.98,138.71)
  L3 w0.254: v2(107.09,139.55) 107.56,140.02 108.66,140.02 109.39,139.29 109.65,139.29 110.23,138.71 v2(111.98,138.71)
  L4 w0.254: v2(107.09,139.55) 107.28,139.36 107.28,138.33 108.33,137.28 115.6,137.28 117.22,135.66 117.22,128.28 116.64,127.7 v2(116.23,127.7)
  BOTTOM w0.203: 114.9,128.35 PU4801.4
  BOTTOM w0.254: v1(112.65,138.49) 112.2,138.49 v2(111.98,138.71) ; v2(116.23,127.7) 115.87,128.06 115.61,128.06 115.32,128.35 114.9,128.35
PWR_VCCGT_SNUB_1: length 2.7
  TOP w0.508: v1(109.48,125.2) 109.22,125.2 109.22,125.2 PR4804.2 PC4810.1
PWR_VCCGT_SWA: length 2.7
  TOP w0.356: v1(110.04,122.46) v3(108.58,122.46)
  TOP w0.508: PR4804.1 108.07,122.97 v3(108.58,122.46)
PWR_VCCGT_TSENSE: length 4.9
  TOP w0.203: PU4601.11 110.24,141.99 v2(110.2,141.95)
  TOP w0.254: PR4655.2 108.34,141.41 108.86,140.88 v1(109.09,140.88) 109.43,140.88 110.2,141.65 v2(110.2,141.95)
  BOTTOM w0.254: v2(110.2,141.95) 110.63,142.38 PC4630.1
PWR_VCCGT_VCCA: length 4.3
  TOP w0.254: PC4808.1 116.12,126.9 v1(116.33,127.11) ; PC4808.1 115.37,126.89 PR4803.1 ; PC4808.1 115.38,127.48 115.09,127.77 v2(114.65,127.77)
  BOTTOM w0.203: 114.21,127.55 PU4801.6
  BOTTOM w0.254: 114.21,127.55 114.43,127.55 v2(114.65,127.77)
PWR_VCCGT_VSN: length 5.1
  TOP w0.203: PU4601.48 111.27,146.65 111.12,146.8
  TOP w0.254: PR4619.1 PC4612.2 108.33,146.44 v1(109.21,147.32) 110.59,147.32 111.12,146.8
PWR_VCCGT_VSN_R: length 4.1
  TOP w0.254: v1(106.08,146.03) 106.48,146.44 PC4612.1 PR4619.2 PC4611.2 106.67,148.06 106.36,147.74 PR4618.2
PWR_VCCGT_VSP: length 6.9
  TOP w0.203: PU4601.47 112.11,147.06 111.95,147.22 111.52,147.22 111.52,147.22 111.27,147.22 111.07,147.42
  TOP w0.254: PR4617.2 106.26,148.59 107.58,148.59 PC4611.1 110.43,148.06 v1(110.6,147.89) 111.07,147.42
PWR_VCCIO_EN: length 6
  BOTTOM w0.127: v1(150.68,127.21) PR5218.2 PR5216.2 PC5227.1 150.68,124.03 150.06,123.41 148.78,123.41 148.53,123.16 PU5203.4
PWR_VCCSA_BST: length 3.2
  TOP w0.305: PU5001.1 135.61,139.2 135.83,139.43 136.88,139.43 v1(137.03,139.27)
  TOP w0.508: PR5013.1 137.02,139.21 137.03,139.22 v1(137.03,139.27)
PWR_VCCSA_BST_RC: length 3.1
  TOP w0.508: PR5013.2 137.02,136.44 137.49,135.97 v1(137.49,135.54) 137.49,135.18 137.21,134.9 PC5008.1
PWR_VCCSA_COMP: length 5.1
  TOP w0.203: v2(113.41,148.11) 113.43,148.11 113.71,147.83 PU4601.43
  TOP w0.254: v2(113.41,148.11) 113.71,148.42 PC4602.2
  BOTTOM w0.254: PC4604.2 113.42,146.3 113.1,146.61 v1(113.1,146.97) 113.1,147.81 v2(113.41,148.11)
PWR_VCCSA_COMP_R: length 2.9
  TOP w0.254: v1(114.52,152.04) 114.15,152.04 113.59,151.48 PR4602.2 113.59,149.94 PC4602.1
PWR_VCCSA_CSN: length 59.3
  TOP w0.203: 114.51,147.73 PU4601.41
  TOP w0.254: v2(115.71,149.35) 115.89,149.53 PC4607.1 116.4,149.11 PC4606.1 115.48,148.7 114.51,147.73 ; v2(140.51,124.84) v1(139.94,124.84)
  L4 w0.254: v2(134.69,121.67) 134.84,121.82 138.96,121.82 139.81,122.67 139.81,124.14 v2(140.51,124.84) 140.51,126.12 141.09,126.7 141.09,132.87 140.2,133.76 140.2,137.79 135.24,142.76 135.24,145.24 133.57,146.91 126.74,146.91 124.46,149.19 115.87,149.19 v2(115.71,149.35)
  BOTTOM w0.254: PR4606.2 140.48,124.81 v2(140.51,124.84) ; v2(134.69,121.67) 135.25,121.11 PG5022.1
PWR_VCCSA_CSN_NTC: length 47.1
  TOP w0.254: v2(141.08,125.7) v1(141.08,126.42) ; v2(115.66,149.98) 115.81,149.98 116.18,150.35 PR4609.2
  L4 w0.254: v2(141.08,125.7) 141.08,126.14 141.47,126.54 141.47,133.03 140.58,133.92 140.58,137.95 135.62,142.92 135.62,145.4 133.69,147.33 126.85,147.33 124.61,149.57 116.42,149.57 116.01,149.98 v2(115.66,149.98)
  BOTTOM w0.254: PR4606.1 v2(141.08,125.7)
