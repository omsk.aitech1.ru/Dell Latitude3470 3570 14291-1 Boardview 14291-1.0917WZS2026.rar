# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TPM_GPIO4: length 3.7
  BOTTOM w0.127: v1(171.73,26.53) 171.04,26.53 R9116.1 169.68,25.18 U9101.13
TPM_VDD14: length 4.8
  BOTTOM w0.305: v1(170.18,24.27) 169.77,24.68 U9101.14
  BOTTOM w0.381: R9111.1 172.28,22.43 171.98,22.74 171.33,22.74 170.65,23.42 170.65,23.81 v1(170.18,24.27)
TPM_VDD22: length 2.9
  BOTTOM w0.305: U9101.22 165.36,21.9 v1(164.86,21.41) 164.81,21.35 R9112.1
TPM_VSB: length 2.9
  BOTTOM w0.305: U9101.1 164.36,28.35 163.6,29.11 v1(163.6,29.32) 163.57,29.34 163.57,30.55 R9113.1
TPS51216_PHS_SET:
  vias: v1(58.49,16.07)
UART0_CTS#: length 5.9
  BOTTOM w0.089: 136.55,87.11 136.26,87.11 136.22,87.15 135.58,87.15 135.49,87.19 135.22,87.19 135.04,87 135.04,86.81 134.78,86.55 134.04,86.55 CPU1.U4
  BOTTOM w0.114: TP2014.1 138.92,87.39 137.44,87.39 137.17,87.11 136.55,87.11
UART0_RTS#: length 9
  BOTTOM w0.089: CPU1.U3 134.67,86.01 135.16,86.01 135.25,86.04 135.53,86.04 135.61,86.01 137,86.01
  BOTTOM w0.14: TP2013.1 142,86.74 140.27,86.74 139.46,85.93 137.75,85.93 137.67,86.01 137,86.01
UART0_TXD: length 7.1
  BOTTOM w0.114: CPU1.U2 135.36,86.57 135.96,86.57 136.03,86.5 137.76,86.5 138,86.74
  BOTTOM w0.14: 138,86.74 138.28,87.02 138.69,87.02 138.83,86.87 139.91,86.87 140.04,87 141.05,87 TP2012.1
UART1_CTS#: length 4.8
  TOP w0.14: TP2017.1 137.18,84.02 v2(137.75,84.02)
  BOTTOM w0.089: CPU1.AB4 133.86,83.62 134.13,83.88 134.91,83.88 135.04,84.01 135.46,84.01 135.57,84.06 135.86,84.06 135.96,84.01 137.74,84.01 v2(137.75,84.02)
UART1_RTS#: length 7.6
  BOTTOM w0.089: 138.43,82.94 138.34,82.84 136.5,82.84 136.17,83.17 135.59,83.17 135.49,83.21 135.29,83.21 135.21,83.18 134.92,83.18 134.88,83.2 134.84,83.21 134.35,83.21 CPU1.AC3
  BOTTOM w0.14: 138.43,82.94 138.5,83.01 139.7,83.01 140.1,82.61 141.09,82.61 TP2016.1
UART1_RXD: length 4.3
  BOTTOM w0.089: 138.51,82.63 138.51,82.63 136.41,82.63 136.08,82.95 CPU1.AC1
  BOTTOM w0.14: TP2015.1 138.54,82.66 138.51,82.63
USB3_PRX_CTX_N1_C: length 10.4
  BOTTOM w0.127: R3608.1 19.06,41.74 18.84,41.95 18.73,42.06 18.69,42.06 18.38,42.06 18.11,42.33 17.93,42.33 17.81,42.21 U3601.10 U3601.1 15.71,42.21 15.59,42.33 15.03,42.33 ; USB1.5 10.57,41.62 10.7,41.75 11.18,41.75 11.76,42.33 15.03,42.33 ; 15.03,42.33 v1(15.03,42.16)
USB3_PRX_CTX_N2_C: length 18.7
  BOTTOM w0.127: R3612.1 19.33,32.04 17.82,32.04 17.7,31.92 U3602.10 U3602.1 15.61,31.92 15.5,32.04 15.02,32.04 14.73,31.74 14.73,31.04 ; 14.73,31.04 14.73,24.61 12.58,22.46 11.73,22.46 11.02,21.75 10.73,21.75 10.57,21.59 USB2.5 ; 14.73,31.04 v1(14.9,31.04)
USB3_PRX_CTX_P1_C: length 10.3
  BOTTOM w0.127: USB1.6 10.57,42.12 10.7,41.99 11.08,41.99 11.66,42.57 15.59,42.57 15.71,42.69 U3601.2 U3601.9 17.81,42.69 17.93,42.57 18.21,42.57 18.48,42.3 18.69,42.3 18.73,42.3 18.83,42.4 18.98,42.55 R3607.1
USB3_PRX_CTX_P2_C: length 18.7
  BOTTOM w0.127: USB2.6 10.57,22.12 10.7,21.99 10.92,21.99 11.63,22.7 12.48,22.7 14.49,24.71 14.49,31.84 14.92,32.28 15.5,32.28 15.62,32.4 U3602.2 U3602.9 17.69,32.4 17.81,32.28 18.27,32.28 ; 18.27,32.28 19.33,32.28 R3611.1 ; 18.27,32.28 v1(18.27,32.47)
USB3_PTX_CRX_N1_C: length 12.3
  BOTTOM w0.127: R3606.1 19.07,43.9 18.76,44.2 18.61,44.2 18.25,43.85 17.93,43.85 17.81,43.73 U3601.7 U3601.4 15.71,43.73 15.59,43.85 14.37,43.85 13.48,44.73 13.48,45.75 12.45,46.78 12.02,46.78 11.05,47.75 10.7,47.75 10.57,47.62 USB1.8
USB3_PTX_CRX_N1_R: length 1.8
  BOTTOM w0.127: R3606.2 20.91,43.9 21.17,44.16 21.54,44.16 C3601.2
USB3_PTX_CRX_N2_C: length 16.4
  BOTTOM w0.127: R3610.1 19.21,34.17 18.87,34.51 18.58,34.51 18.47,34.4 18.47,33.95 18.05,33.53 17.8,33.53 17.71,33.44 U3602.7 U3602.4 15.66,33.44 15.54,33.57 14.39,33.57 13.84,33.02 13.84,28.16 12.95,27.28 11.62,27.28 11.15,27.74 10.7,27.74 10.57,27.6 USB2.8
USB3_PTX_CRX_N2_R: length 1.8
  BOTTOM w0.127: R3610.2 20.96,34.17 21.3,34.51 21.72,34.51 C3604.2
USB3_PTX_CRX_P1_C: length 12.5
  BOTTOM w0.127: USB1.9 10.57,48.12 10.7,47.99 11.15,47.99 12.12,47.03 12.55,47.03 13.72,45.85 13.72,44.83 14.47,44.09 15.13,44.09 ; R3605.1 19.03,44.71 18.76,44.44 18.51,44.44 18.15,44.09 17.93,44.09 17.81,44.21 U3601.6 U3601.5 15.71,44.21 15.59,44.09 15.13,44.09 ; 15.13,44.09 v1(15.13,44.3)
USB3_PTX_CRX_P1_R: length 1.8
  BOTTOM w0.127: R3605.2 20.86,44.71 21.17,44.4 21.54,44.4 C3602.2
USB3_PTX_CRX_P2_C: length 16.6
  BOTTOM w0.127: 14.49,33.81 v1(14.49,34) ; 14.49,33.81 14.29,33.81 13.6,33.12 13.6,28.26 12.85,27.52 11.72,27.52 11.25,27.98 10.71,27.98 10.57,28.12 USB2.9 ; 14.49,33.81 15.44,33.81 15.55,33.92 U3602.5 U3602.6 17.61,33.92 17.77,33.77 17.95,33.77 18.23,34.05 18.23,34.5 18.48,34.75 18.88,34.75 19.16,35.03 R3609.1
USB3_PTX_CRX_P2_R: length 1.7
  BOTTOM w0.127: R3609.2 20.9,35.03 21.18,34.75 21.8,34.75 C3605.2
USB20_VCCA:
  vias: v3(180.71,39.38) v3(181.76,39.41) v3(182.02,29.42) v3(184.36,38.09)
USB30_RX_CPU_N1: length 153.4
  L4 w0.089: v2(131.68,90.08) 131.88,89.89 131.88,89.56 132.22,89.23 132.64,89.23 133.07,88.8 133.07,88.48 132.83,88.24 127.64,88.24 127.62,88.26 127.6,88.26
  L4 w0.114: v2(22.73,56.18) 22.73,55.99 22.96,55.77 23.69,55.77 24.38,56.45 24.38,59.9 28.62,64.14 59.94,64.14 82.47,86.67 88.73,86.67 89.91,87.85 94.65,87.85 96.01,86.49 104.52,86.49 107.88,83.13 108.93,83.13 109.4,83.6 115.66,83.6 116.26,83 121.38,83 121.51,83.13 124.29,83.13 126.53,85.38 126.53,87.48 127.31,88.26 127.6,88.26
  BOTTOM w0.127: v2(22.73,56.18) 23,55.91 24,55.91 24.36,55.55 24.36,43.99 24.08,43.71 ; 24.08,43.71 22.42,42.05 21.26,42.05 20.94,41.74 R3608.2 ; 24.08,43.71 v1(24.23,43.57) ; v2(131.68,90.08) 131.55,90.08 CPU1.H8
USB30_RX_CPU_N2: length 163.6
  L4 w0.089: v2(132.6,90.08) 132.83,90.32 133.13,90.32 134.1,89.35 134.1,88.12 133.59,87.61 132.63,87.61 132.19,87.16 128.51,87.16 128.39,87.27 127.8,87.27 127.78,87.29 127.76,87.29
  L4 w0.114: v2(25.08,36.9) 24.79,37.19 24.58,37.19 24.31,37.46 24.31,40.54 23.83,41.02 23.83,53.6 25.13,54.9 25.13,59.59 28.93,63.39 60.28,63.39 82.79,85.9 92.6,85.9 93.28,86.58 94.86,86.58 95.53,85.91 95.53,85.63 95.82,85.33 103.87,85.33 106.95,82.25 121.15,82.25 121.59,81.81 122.5,81.81 122.87,81.44 123.55,81.44 123.74,81.26 124.17,81.26 125.52,82.6 125.52,82.93 127.22,84.63 127.22,86.98 127.53,87.29 127.76,87.29
  BOTTOM w0.127: v2(25.08,36.9) 24.9,37.08 24.69,37.08 24.54,36.92 24.54,35.99 24.89,35.63 24.89,34.56 23.32,33 ; R3612.2 20.95,31.73 21.26,32.04 22.37,32.04 23.32,33 ; 23.32,33 v1(23.44,32.88) ; CPU1.J6 132.46,90.08 v2(132.6,90.08)
USB30_RX_CPU_P1: length 153.4
  L4 w0.089: 127.6,88.03 127.62,88.03 127.64,88.05 132.91,88.05 133.26,88.4 133.26,88.88 132.72,89.42 132.3,89.42 132.07,89.64 132.07,90.35 v2(131.68,90.73)
  L4 w0.114: v2(22.73,55.37) 22.9,55.54 23.79,55.54 24.61,56.36 24.61,59.8 28.72,63.91 60.04,63.91 82.56,86.44 88.83,86.44 90.01,87.62 94.56,87.62 95.92,86.26 104.42,86.26 107.78,82.9 109.02,82.9 109.49,83.37 115.57,83.37 116.17,82.77 121.47,82.77 121.6,82.9 124.38,82.9 126.76,85.28 126.76,87.38 127.41,88.03 127.6,88.03
  BOTTOM w0.127: 22.65,42.62 24.12,44.09 24.12,55.45 23.9,55.67 23.03,55.67 22.97,55.6 v2(22.73,55.37) ; 22.65,42.62 22.32,42.29 21.17,42.29 20.91,42.55 R3607.2 ; 22.65,42.62 v1(22.52,42.75) ; CPU1.G8 131.55,90.73 v2(131.68,90.73)
USB30_RX_CPU_P2: length 163.6
  L4 w0.089: 127.76,87.06 127.78,87.06 127.8,87.08 128.31,87.08 128.43,86.97 132.27,86.97 132.71,87.42 133.67,87.42 134.29,88.04 134.29,89.43 133.21,90.51 132.82,90.51 v2(132.6,90.73)
  L4 w0.114: 127.76,87.06 127.62,87.06 127.44,86.89 127.44,84.54 125.74,82.84 125.74,82.51 124.27,81.03 123.65,81.03 123.46,81.22 122.77,81.22 122.4,81.58 121.5,81.58 121.06,82.02 106.85,82.02 103.77,85.1 95.73,85.1 95.3,85.53 95.3,85.82 94.76,86.35 93.37,86.35 92.7,85.68 82.88,85.68 60.37,63.16 29.03,63.16 25.36,59.49 25.36,54.8 24.06,53.51 24.06,41.11 24.54,40.64 24.54,37.55 24.68,37.41 24.79,37.41 v2(25.08,37.7)
  BOTTOM w0.127: 21.99,32.28 21.26,32.28 20.95,32.59 R3611.2 ; 21.99,32.28 22.27,32.28 24.65,34.66 24.65,35.53 24.29,35.89 24.29,37.02 24.59,37.32 24.75,37.32 25.08,37.65 v2(25.08,37.7) ; 21.99,32.28 v1(21.99,32.47) ; v2(132.6,90.73) 132.46,90.73 CPU1.H6
USB30_TX_CPU_N1: length 157.8
  L4 w0.089: 127.36,89.67 127.39,89.67 127.41,89.65 129.11,89.65 129.57,90.11 129.57,93.59 130.26,94.28 130.26,95.79 129.58,96.47 129.58,96.66 129.46,96.78 v2(129.31,96.78)
  L4 w0.114: v2(20.89,58.06) 20.7,57.87 20.7,57.67 20.81,57.56 21.35,57.56 22.38,58.59 22.38,60.09 27.93,65.64 59.22,65.64 82.63,89.06 86.34,89.06 86.86,89.58 92.92,89.58 93.56,90.22 100.81,90.22 101.26,90.67 106.43,90.67 108.24,88.85 108.24,88.73 111.31,85.66 115.79,85.66 116.96,84.5 120.47,84.5 120.95,84.97 122.34,84.97 122.69,84.63 123.24,84.63 123.4,84.78 123.4,85.29 123.79,85.68 124.68,85.68 125.25,86.26 125.25,87.79 127.14,89.67 127.36,89.67
  BOTTOM w0.089: v2(129.31,96.78) 129.15,96.78 129.01,96.92 128.89,96.92 128.8,96.84 128.8,95.95 128.32,95.46 128.32,95.02 128.36,94.88 128.38,94.82 128.38,94.69 128.32,94.51 128.32,94.37 128.38,94.16 128.38,94.08 CPU1.C13
  BOTTOM w0.127: 21.3,57.33 20.89,57.75 v2(20.89,58.06) ; 21.3,57.33 21.85,56.78 21.85,54.84 23.57,53.12 23.57,44.51 23.34,44.27 23.05,44.27 22.75,43.97 C3601.1 ; 21.3,57.33 v1(21.43,57.46)
USB30_TX_CPU_N2: length 167
  TOP w0.127: v2(130.28,96.87) 130.04,97.12 v1(129.77,97.12)
  L4 w0.089: v2(130.28,96.87) 130.28,96.95 130.6,97.27 130.89,97.27 131.01,97.15 131.01,93.88 130.14,93.01 130.14,89.72 129.65,89.23 127.91,89.23 127.89,89.25 127.87,89.25
  L4 w0.114: v2(23.77,36.91) 23.77,37 23.58,37.19 23.26,37.19 22.94,37.51 22.94,53.54 21.94,54.55 21.94,57.03 23.14,58.24 23.14,59.73 28.31,64.89 59.58,64.89 82.53,87.84 87.17,87.84 88,88.67 94.8,88.67 96.36,87.11 100.26,87.11 100.97,87.82 101.16,87.82 101.59,87.82 101.81,87.6 106,87.6 109.24,84.35 115.97,84.35 116.57,83.75 121.19,83.75 121.34,83.9 122.19,83.9 122.5,83.6 124.02,83.6 125.88,85.46 125.88,87.61 127.53,89.25 127.87,89.25
  BOTTOM w0.127: CPU1.B13 128.59,94.64 129.21,95.26 129.21,95.69 130.28,96.75 v2(130.28,96.87) ; v2(23.77,36.91) 23.64,37.03 23.21,37.03 23.03,36.85 23.03,36.35 23.94,35.43 23.94,34.73 23.68,34.47 23.24,34.47 C3604.1
USB30_TX_CPU_P1: length 158.6
  TOP w0.127: v2(129.25,97.43) 129.12,97.3 v1(128.3,97.3)
  L4 w0.089: v2(129.25,97.43) 129.35,97.43 129.77,97 129.77,96.54 130.45,95.87 130.45,94.21 129.76,93.51 129.76,90.03 129.19,89.46 127.41,89.46 127.39,89.44 127.36,89.44
  L4 w0.114: 127.36,89.44 127.23,89.44 125.48,87.69 125.48,86.16 124.77,85.45 123.88,85.45 123.62,85.19 123.62,84.69 123.34,84.4 122.59,84.4 122.25,84.75 121.04,84.75 120.57,84.27 116.86,84.27 115.7,85.43 111.21,85.43 111.08,85.57 108.02,88.63 108.02,88.76 106.34,90.44 101.35,90.44 100.91,89.99 93.65,89.99 93.01,89.35 86.96,89.35 86.43,88.83 82.73,88.83 59.31,65.41 28.03,65.41 22.61,59.99 22.61,58.49 21.45,57.33 21.11,57.33 v2(20.89,57.12)
  BOTTOM w0.089: CPU1.D13 128.29,93.51 128.2,93.8 128.2,94.13 128.14,94.34 128.14,94.54 128.19,94.68 128.19,94.84 128.14,94.99 128.14,95.56 128.61,96.03 128.61,96.91 128.81,97.11 128.93,97.11 v2(129.25,97.43)
  BOTTOM w0.127: C3602.1 22.96,44.51 23.24,44.51 23.33,44.61 23.33,53.02 21.61,54.74 21.61,56.68 21.18,57.12 v2(20.89,57.12)
USB30_TX_CPU_P2: length 167.1
  TOP w0.127: v1(130.42,98.16) 130.29,98.02 v2(130.29,97.58)
  L4 w0.089: 127.87,89.03 127.89,89.03 127.91,89.04 129.73,89.04 130.33,89.65 130.33,92.93 131.2,93.8 131.2,97.23 130.97,97.46 130.59,97.46 130.47,97.58 v2(130.29,97.58)
  L4 w0.114: v2(23.77,37.71) 23.77,37.61 23.58,37.42 23.36,37.42 23.17,37.6 23.17,53.64 22.17,54.64 22.17,56.94 23.37,58.14 23.37,59.63 28.4,64.66 59.67,64.66 82.62,87.61 87.27,87.61 88.1,88.44 94.71,88.44 96.26,86.88 100.35,86.88 101.06,87.59 101.5,87.59 101.72,87.37 105.91,87.37 109.02,84.26 109.15,84.13 115.87,84.13 116.48,83.52 121.28,83.52 121.43,83.67 122.1,83.67 122.4,83.37 124.12,83.37 126.11,85.37 126.11,87.51 127.63,89.03 127.87,89.03
  BOTTOM w0.127: CPU1.A13 128.69,95.08 128.97,95.36 128.97,95.79 129.82,96.63 129.82,97.11 v2(130.29,97.58) ; v2(23.77,37.71) 23.77,37.54 23.5,37.28 23.11,37.28 22.79,36.95 22.79,36.25 23.7,35.33 23.7,34.83 23.58,34.71 23.24,34.71 C3605.1
USB30_VCCB: length 11.6
  TOP w0.508: v3(22.66,29.9) 22.66,29.73 23.07,29.32 EU3602.5
  TOP w0.635: USB2.1 12.07,29.08 ; USB2.1 12.07,27.66 ; USB2.1 12.78,28.37
  L4 w0.508: v3(22.66,29.9) 21.51,29.9 18.43,32.98 v3(18.43,35.57)
  vias: v1(20.04,36.02)
USB30_VCCC: length 1.4
  BOTTOM w0.635: 12.78,48.37 USB1.1 12.07,49.08
  vias: v1(17.98,39.15) v2(18.74,39.56) v2(18.76,38.89) v3(14.65,45.27) v3(15.72,45.24)
USB_CAMERA_PN4: length 5.7
  TOP w0.127: 79.31,161.82 79.31,162.3 78.91,162.69 78.61,162.69 78.48,162.82 LCD1.30 ; 79.31,161.82 79.31,161.38 80.09,160.6 80.09,160.1 80.26,159.94 81.04,159.94 81.26,160.15 TR5501.2 ; 79.31,161.82 v1(79.48,161.82)
USB_CAMERA_PP4: length 5.7
  TOP w0.127: TR5501.3 81.25,159.47 81.03,159.69 80.16,159.69 79.85,160 79.85,160.16 ; 79.85,160.16 v1(79.69,160.16) ; 79.85,160.16 79.85,160.5 79.07,161.28 79.07,162.2 78.81,162.45 78.65,162.45 78.52,162.32 LCD1.31
USB_CON_PN6: length 6.9
  TOP w0.127: 80.01,158.25 v1(80.17,158.25) ; 80.01,158.25 80.01,156.97 80.15,156.83 80.87,156.83 81.16,157.13 R5535.1 ; 80.01,158.25 80.01,159.07 79.15,159.92 79.15,160.42 78.87,160.7 78.62,160.7 78.5,160.82 LCD1.34
USB_CON_PN7: length 8.7
  TOP w0.127: AFTP5806.1 158.24,62.16 v2(158.22,62.15)
  BOTTOM w0.127: R6110.1 156.72,66.51 156.72,65.33 156.78,65.27 156.78,62.8 157.25,62.33 158.04,62.33 v2(158.22,62.15) 158.4,62.32 158.93,62.32 159.1,62.15 159.57,62.15 159.7,62.02 WLAN1.5
USB_CON_PP6: length 7
  TOP w0.127: 79.77,157.1 79.77,156.87 80.05,156.59 80.8,156.59 81.2,156.19 R5536.1 ; 79.77,157.1 v1(79.6,157.1) ; 79.77,157.1 79.77,158.97 78.91,159.82 78.91,160.32 78.77,160.46 78.63,160.46 78.5,160.32 LCD1.35
USB_CON_PP7: length 8.8
  TOP w0.127: v2(158.21,62.79) 158.14,62.86 AFTP5807.1
  BOTTOM w0.127: WLAN1.3 159.7,62.52 159.57,62.39 159.2,62.39 159.03,62.56 158.44,62.56 v2(158.21,62.79) 157.99,62.57 157.35,62.57 157.03,62.9 157.03,64.95 157.17,65.1 157.48,65.1 157.66,65.28 157.66,66.51 R6111.1
USB_CPU_PN0: length 146.9
  L4 w0.089: 128.04,84.02 128.05,84.02 128.07,84 130.91,84 131.11,83.81 131.11,83.63 v2(131.36,83.39)
  L4 w0.114: v2(24.91,46.27) 25.44,46.8 25.44,54.02 25.9,54.48 25.9,59.29 29.26,62.64 60.63,62.64 83.13,85.15 94.59,85.15 95.04,84.7 102.9,84.7 106.1,81.5 113.99,81.5 114.65,80.84 119.62,80.84 120.1,81.32 120.82,81.32 121.74,80.4 123.48,80.4 123.78,80.7 124.7,80.7 126.36,82.35 126.36,82.7 127.68,84.02 128.04,84.02
  BOTTOM w0.127: v2(131.36,83.39) 131.03,83.71 CPU1.AB9 ; 25.14,40.67 25.75,41.28 25.75,45.8 25.47,46.07 25.1,46.07 v2(24.91,46.27) ; 25.14,40.67 v1(25.27,40.54) ; 25.14,40.67 21.76,37.29 21.55,37.29 21.34,37.08 TR3601.1
USB_CPU_PN1: length 154.8
  TOP w0.127: 26.82,32.5 26.59,32.73 26.59,33.38 26.84,33.63 27.09,33.63 v2(27.49,34.03) ; 26.82,32.5 28.35,30.96 28.35,29.55 28.03,29.23 27.8,29.23 27.64,29.39 27.64,29.51 27.54,29.61 TR3602.1 ; 26.82,32.5 v1(26.72,32.39)
  L4 w0.089: v2(132.8,82.31) 132.19,81.7 127.74,81.7 127.73,81.68 127.7,81.68
  L4 w0.114: 127.7,81.68 127.13,81.68 124.78,79.33 123.81,79.33 123.42,79.72 123.07,79.72 122.51,79.16 105.12,79.16 104.08,80.2 104.08,80.91 103.36,81.63 101.05,81.63 99.42,83.26 95.05,83.26 94.8,83.51 82.92,83.51 61.07,61.67 29.67,61.67 26.89,58.89 26.89,54.06 26.43,53.6 26.43,45.6 25.79,44.96 25.79,39.09 26.43,38.45 26.43,34.4 27.04,33.79 27.25,33.79 v2(27.49,34.03)
  BOTTOM w0.127: v2(132.8,82.31) 132.99,82.5 CPU1.AD6
USB_CPU_PN2: length 85.4
  L4 w0.114: v2(136.63,81.42) 137.15,81.93 138.52,81.93 138.78,81.67 139.94,81.67 140.82,80.78 140.98,80.78 141.39,80.37 154.04,80.37 156.25,78.16 156.25,76.02 156.52,75.75 156.92,75.35 156.92,74.47 157.45,73.94 157.45,71.23 158.34,70.34 158.34,66.46 158.99,65.8 158.99,60.2 160.6,58.59 160.6,49.23 159.91,48.54 159.91,41.98 160.62,41.27 160.62,38.97 164.12,35.47 164.12,34.66 168.17,30.61 168.17,29.83 168.83,29.17 169.47,29.17 v2(169.75,29.44)
  BOTTOM w0.089: 136.22,80.74 136.2,80.74 136.17,80.71 135.61,80.71 135.52,80.75 135.27,80.75 135.17,80.71 135.15,80.71 134.96,80.71 134.95,80.71 134.86,80.75 134.63,80.75 134.4,80.65 134.39,80.65 134.09,80.35 CPU1.AH3
  BOTTOM w0.127: 171.57,27.92 v1(171.7,28.05) ; 171.57,27.92 172.28,27.2 172.48,27.2 172.7,27.42 TR3406.1 ; 171.57,27.92 170.37,29.11 170.08,29.11 v2(169.75,29.44) ; 136.22,80.74 136.57,80.74 136.77,80.93 136.77,81.29 v2(136.63,81.42)
USB_CPU_PN3: length 80.5
  TOP w0.127: 151.81,97.86 153.74,97.86 154.67,98.79 159.44,98.79 163.12,102.48 163.12,104.13 166.47,107.47 166.47,108.11 167.62,109.26 171.3,109.26 177.95,115.9 177.95,121.09 177.36,121.68 177.36,123.82 R9203.1 ; 151.81,97.86 v1(151.81,98) ; 151.81,97.86 151.16,97.86 147.22,93.92 147.22,93.58 147.06,93.42 146.87,93.42 v2(146.63,93.66)
  L4 w0.114: v2(146.63,93.66) 146.63,93.5 147.18,92.96 147.18,92.41 147.67,91.91 147.67,89.14 148.02,88.79 148.02,84.62 146.01,82.6 141.36,82.6 140.6,83.36 134.91,83.36 134.05,82.51 133.16,82.51 132.96,82.71 130.94,82.71 130.8,82.57 v2(130.8,82.3)
  BOTTOM w0.127: CPU1.AD9 130.9,82.84 130.72,82.66 130.72,82.38 v2(130.8,82.3)
USB_CPU_PN4: length 187.3
  TOP w0.127: v2(84.68,159.44) 83.96,159.44 83.82,159.59 83.82,160.16 83.69,160.29 83.41,160.29 83.28,160.15 TR5501.1
  L4 w0.114: v2(162.29,81.83) 161.95,81.83 161.53,82.25 161.53,82.86 159.87,84.52 159.87,86.24 158.24,87.87 158.24,94.28 157.45,95.06 157.45,103.25 155.45,105.26 155.45,110.01 153.85,111.6 152.2,111.6 151.25,112.56 137.39,112.56 137.22,112.39 128.28,112.39 126.74,110.84 114.93,110.84 112.51,108.43 99.59,108.43 98.14,106.97 94.42,106.97 92.95,108.45 92.95,112.75 97.54,117.34 97.54,131.65 93.52,135.67 93.52,136.52 92.93,137.12 92.93,139.7 92.43,140.19 92.43,143.74 85.56,150.61 85.56,158.56 v2(84.68,159.44)
  BOTTOM w0.127: v2(162.29,81.83) 160.71,80.25 ; 160.71,80.25 v1(160.57,80.39) ; 160.71,80.25 160.4,79.95 150.24,79.95 149.66,79.36 147.07,79.36 146.85,79.58 144.54,79.58 144.31,79.35 142.23,79.35 141.6,78.73 136.86,78.73 136.4,79.18 135.98,79.18 135.71,79.44 CPU1.AJ1
USB_CPU_PN5: length 87.8
  TOP w0.127: v2(169.18,30.58) 169.06,30.7 v1(168.54,30.7)
  L4 w0.114: v2(133.3,81.28) 133.12,81.46 133.12,81.61 133.25,81.75 135.33,81.75 135.89,82.3 137.94,82.3 138.31,82.67 140.19,82.67 141.14,81.71 153.44,81.71 156.8,78.36 156.8,76.22 157.44,75.58 157.44,74.69 157.98,74.15 157.98,71.46 158.87,70.57 158.87,66.72 159.6,65.99 159.6,60.35 161.12,58.83 161.12,48.99 160.48,48.34 160.48,43.32 161.15,42.64 161.15,39.42 164.64,35.93 164.64,35.06 165.73,33.96 166.81,33.96 169.57,31.2 169.57,30.73 169.42,30.58 v2(169.18,30.58)
  BOTTOM w0.127: CPU1.AF6 132.99,81.59 v2(133.3,81.28) ; TR3301.1 172.85,30.28 172.63,30.07 172.34,30.07 170.69,31.72 169.88,31.72 169.57,31.41 169.57,30.77 169.39,30.58 v2(169.18,30.58)
USB_CPU_PN6: length 183.4
  TOP w0.127: v2(84.26,157.01) 84.26,156.92 84.01,156.67 83.18,156.67 82.72,157.13 R5535.2
  L4 w0.114: v2(160.17,81.6) 160.46,81.6 160.55,81.7 160.55,82.45 158.86,84.14 158.86,85.12 158.55,85.43 157.86,85.43 156.89,86.4 156.89,92.21 157.24,92.56 157.24,93.74 156.04,94.94 156.04,96.59 155.44,97.19 155.44,103.85 154.47,104.82 154.47,109.57 153.43,110.61 151.81,110.61 150.87,111.56 137.77,111.56 137.62,111.41 128.69,111.41 127.15,109.87 115.44,109.87 112.86,107.29 100.11,107.29 98.81,106 94.01,106 91.93,108.08 91.93,113.11 96.56,117.75 96.56,131.21 92.48,135.3 92.48,136.18 91.95,136.71 91.95,139.29 91.45,139.78 91.45,143.34 84.58,150.21 84.58,152.53 83.59,153.53 83.59,155.86 83.81,156.08 83.81,156.56 v2(84.26,157.01)
  BOTTOM w0.127: 159,80.72 149.92,80.72 149.34,80.14 147.39,80.14 147.17,80.35 144.14,80.35 144.07,80.28 142.27,80.28 141.44,79.45 136.91,79.45 136.15,80.21 135.48,80.21 CPU1.AH1 ; 159,80.72 159.7,80.72 160.17,81.19 v2(160.17,81.6) ; 159,80.72 v1(159,80.93)
USB_CPU_PN7: length 70.4
  TOP w0.127: v1(155.75,68.54) 155.45,68.84 v2(155.22,68.84)
  L4 w0.114: v2(155.22,68.84) 155.22,68.99 155.47,69.24 155.74,69.24 156.02,69.51 156.02,70.08 155,71.1 155,72.06 154.75,72.31 151.4,72.31 151.27,72.44 151.27,72.71 151.4,72.83 154.32,72.83 154.57,73.09 154.57,73.76 154,74.34 153.6,74.34 153.47,74.46 153.47,75.81 153.18,76.11 147.27,76.11 146.6,76.79 146.6,78.35 146.75,78.51 153.31,78.51 153.57,78.77 153.57,79.36 153.31,79.62 140.49,79.62 140.25,79.86 140.25,80.47 139.98,80.73 139.53,80.73 139.27,80.47 139.27,79.4 139.14,79.28 138.87,79.28 138.75,79.4 138.75,80.32 138.49,80.58 138.03,80.58 137.77,80.32 137.77,79.39 137.64,79.27 137.38,79.27 137.25,79.39 137.25,80.66 137,80.91 136.52,80.91 136.27,80.66 136.27,79.37 136.14,79.24 135.88,79.24 135.75,79.37 135.75,80.93 135.49,81.19 135.03,81.19 134.77,80.93 134.77,79.61 134.66,79.5 134.37,79.5 134.25,79.61 134.25,80.59 133.96,80.88 133.17,80.88 132.98,80.68 131.98,80.68 131.87,80.8 131.87,81.04 v2(132.03,81.2)
  BOTTOM w0.127: v2(155.22,68.84) 155.41,69.02 156.8,69.02 157.07,68.75 157.07,68.1 156.72,67.75 156.72,67.48 R6110.2 ; CPU1.AF8 132.03,81.42 v2(132.03,81.2)
USB_CPU_PP0: length 146.9
  L4 w0.089: v2(130.68,83.39) 130.92,83.62 130.92,83.73 130.84,83.81 128.06,83.81 128.04,83.79
  L4 w0.114: v2(24.9,45.34) 24.9,45.63 25.36,46.09 25.36,46.39 25.67,46.7 25.67,53.92 26.13,54.39 26.13,59.19 29.35,62.41 60.72,62.41 83.23,84.92 94.5,84.92 94.94,84.47 102.8,84.47 106,81.27 113.89,81.27 114.55,80.61 119.72,80.61 120.19,81.09 120.72,81.09 121.65,80.17 123.57,80.17 123.87,80.47 124.8,80.47 126.59,82.26 126.59,82.61 127.77,83.79 128.04,83.79
  BOTTOM w0.127: 23.62,39.49 25.51,41.38 25.51,45.7 25.37,45.83 25.02,45.83 24.9,45.71 v2(24.9,45.34) ; 23.62,39.49 21.66,37.53 21.5,37.53 21.27,37.76 TR3601.4 ; 23.62,39.49 v1(23.49,39.63) ; CPU1.AB10 130.56,83.9 130.7,83.76 130.7,83.4 v2(130.68,83.39)
USB_CPU_PP1: length 154.9
  TOP w0.127: TR3602.4 27.4,28.92 27.47,28.99 28.13,28.99 28.6,29.45 28.6,31.06 28.09,31.57 ; 28.09,31.57 26.83,32.83 26.83,33.28 26.94,33.39 27.33,33.39 v2(27.49,33.22) ; 28.09,31.57 v1(28.19,31.68)
  L4 w0.089: v2(132.15,82.3) 132.27,82.18 132.27,82.05 132.11,81.89 127.74,81.89 127.73,81.9 127.7,81.9
  L4 w0.114: 127.7,81.9 127.03,81.9 124.68,79.55 123.91,79.55 123.52,79.95 122.98,79.95 122.42,79.39 105.21,79.39 104.3,80.29 104.3,81.01 103.45,81.86 101.14,81.86 99.51,83.49 95.15,83.49 94.9,83.74 82.82,83.74 60.98,61.89 29.58,61.89 26.66,58.98 26.66,54.16 26.2,53.69 26.2,45.69 25.56,45.05 25.56,38.99 26.2,38.35 26.2,34.31 26.95,33.56 27.16,33.56 v2(27.49,33.22)
  BOTTOM w0.127: v2(132.15,82.3) 132.34,82.49 CPU1.AD7
USB_CPU_PP2: length 85.4
  L4 w0.114: v2(169.75,28.64) 169.45,28.94 168.74,28.94 167.94,29.74 167.94,30.52 163.89,34.57 163.89,35.38 160.39,38.87 160.39,41.17 159.68,41.89 159.68,48.63 160.37,49.32 160.37,58.5 158.76,60.1 158.76,65.71 158.11,66.37 158.11,70.24 157.22,71.13 157.22,73.85 156.69,74.38 156.69,75.25 156.02,75.92 156.02,78.07 153.95,80.14 141.29,80.14 140.88,80.56 140.73,80.56 139.84,81.44 138.68,81.44 138.42,81.7 137.56,81.7 v2(137.27,81.42)
  BOTTOM w0.089: 136.22,80.5 136.2,80.5 136.17,80.53 135.57,80.53 135.48,80.57 135.31,80.57 135.23,80.54 135.19,80.53 134.92,80.53 134.82,80.57 134.66,80.57 134.5,80.5 134.43,80.44 134.43,79.66 CPU1.AJ3
  BOTTOM w0.127: TR3406.4 172.7,26.74 172.48,26.96 172.18,26.96 170.56,28.58 ; 136.22,80.5 136.67,80.5 137.01,80.83 137.01,81.16 v2(137.27,81.42) ; 170.56,28.58 v1(170.43,28.45) ; 170.56,28.58 170.27,28.87 169.98,28.87 v2(169.75,28.64)
USB_CPU_PP3: length 80.6
  TOP w0.127: 153.11,97.62 153.84,97.62 154.77,98.55 159.54,98.55 163.37,102.38 163.37,104.02 166.71,107.37 166.71,108.01 167.72,109.01 171.4,109.01 178.19,115.8 178.19,121.19 177.6,121.78 177.6,123.79 R9204.1 ; 153.11,97.62 v1(153.11,97.49) ; 153.11,97.62 151.26,97.62 147.47,93.82 147.47,93.48 147.16,93.18 146.68,93.18 v2(146.51,93)
  L4 w0.114: v2(130.09,82.32) 130.23,82.32 130.85,82.94 133.05,82.94 133.26,82.73 133.96,82.73 134.81,83.59 140.7,83.59 141.46,82.83 145.91,82.83 147.79,84.71 147.79,88.69 147.44,89.04 147.44,91.82 146.95,92.31 146.95,92.86 146.81,93 v2(146.51,93)
  BOTTOM w0.127: v2(130.09,82.32) 130.38,82.61 CPU1.AD10
USB_CPU_PP4: length 187.3
  TOP w0.127: v2(84.68,158.79) 84.28,159.2 83.86,159.2 83.59,159.47 TR5501.4
  L4 w0.114: v2(84.68,158.79) 85.01,158.79 85.33,158.47 85.33,150.52 92.2,143.65 92.2,140.09 92.7,139.6 92.7,137.02 93.29,136.43 93.29,135.58 97.31,131.56 97.31,117.43 92.72,112.84 92.72,108.35 94.33,106.75 98.23,106.75 99.69,108.2 112.61,108.2 115.02,110.61 126.84,110.61 128.38,112.16 137.31,112.16 137.48,112.33 151.16,112.33 152.11,111.38 153.76,111.38 155.22,109.91 155.22,105.16 157.22,103.16 157.22,94.97 158.01,94.18 158.01,87.78 159.65,86.14 159.65,84.42 161.3,82.76 161.3,82.15 162.26,81.2 v2(162.29,81.2)
  BOTTOM w0.127: v2(162.29,81.2) 161.99,81.2 160.5,79.71 157.86,79.71 ; 157.86,79.71 150.34,79.71 149.76,79.12 146.97,79.12 146.75,79.34 144.64,79.34 144.41,79.11 142.33,79.11 141.7,78.48 136.76,78.48 136.3,78.94 135.88,78.94 135.18,79.64 CPU1.AJ2 ; 157.86,79.71 v1(157.86,79.53)
USB_CPU_PP5: length 87.8
  TOP w0.127: v1(169.7,31.08) 169.98,30.8 v2(169.98,30.58)
  L4 w0.114: v2(169.98,30.58) 169.8,30.77 169.8,31.29 166.9,34.19 165.83,34.19 164.87,35.15 164.87,36.02 161.38,39.51 161.38,42.74 160.71,43.41 160.71,48.25 161.35,48.89 161.35,58.93 159.83,60.45 159.83,66.08 159.1,66.81 159.1,70.67 158.21,71.56 158.21,74.24 157.67,74.78 157.67,75.67 157.02,76.32 157.02,78.45 153.53,81.94 141.24,81.94 140.28,82.89 138.21,82.89 137.85,82.53 135.79,82.53 135.24,81.97 133.15,81.97 132.89,81.71 132.89,81.45 v2(132.67,81.22)
  BOTTOM w0.127: v2(132.67,81.22) 132.34,81.55 CPU1.AF7 ; v2(169.98,30.58) 169.82,30.75 169.82,31.31 169.98,31.48 170.59,31.48 172.24,29.83 172.68,29.83 172.9,29.6 TR3301.4
USB_CPU_PP6: length 183.4
  TOP w0.127: R5536.2 82.85,156.19 83.1,156.43 84.03,156.43 v2(84.26,156.21)
  L4 w0.114: v2(160.61,81.13) 160.61,81.44 160.78,81.61 160.78,82.54 159.09,84.24 159.09,85.21 158.65,85.66 157.95,85.66 157.12,86.49 157.12,92.11 157.47,92.46 157.47,93.84 156.26,95.04 156.26,96.68 155.67,97.28 155.67,103.95 154.7,104.91 154.7,109.67 153.52,110.84 151.91,110.84 150.97,111.78 137.68,111.78 137.53,111.64 128.6,111.64 127.05,110.09 115.34,110.09 112.77,107.52 100.01,107.52 98.72,106.22 94.11,106.22 92.16,108.18 92.16,113.02 96.79,117.65 96.79,131.31 92.7,135.39 92.7,136.28 92.18,136.81 92.18,139.38 91.68,139.88 91.68,143.43 84.81,150.3 84.81,152.63 83.81,153.63 83.81,155.76 v2(84.26,156.21)
  BOTTOM w0.127: 143.35,80.04 142.37,80.04 141.54,79.21 136.81,79.21 136.05,79.97 135.07,79.97 CPU1.AH2 ; 143.35,80.04 v1(143.35,79.86) ; 143.35,80.04 144.17,80.04 144.24,80.11 147.07,80.11 147.29,79.9 149.44,79.9 150.02,80.48 159.8,80.48 160.45,81.13 v2(160.61,81.13)
USB_CPU_PP7: length 70.5
  TOP w0.127: v2(155.22,69.64) 155.8,69.64 v1(155.93,69.78)
  L4 w0.114: v2(155.22,69.64) 155.41,69.46 155.65,69.46 155.79,69.6 155.79,69.98 154.77,71 154.77,71.97 154.65,72.08 151.31,72.08 151.05,72.34 151.05,72.8 151.31,73.06 154.22,73.06 154.34,73.18 154.34,73.67 153.9,74.11 153.51,74.11 153.25,74.37 153.25,75.72 153.08,75.88 147.18,75.88 146.37,76.69 146.37,78.45 146.66,78.74 153.21,78.74 153.34,78.86 153.34,79.26 153.21,79.39 140.39,79.39 140.02,79.76 140.02,80.37 139.89,80.5 139.62,80.5 139.5,80.37 139.5,79.31 139.24,79.05 138.78,79.05 138.52,79.31 138.52,80.22 138.39,80.35 138.12,80.35 138,80.22 138,79.3 137.74,79.04 137.28,79.04 137.02,79.3 137.02,80.57 136.91,80.68 136.61,80.68 136.5,80.57 136.5,79.27 136.24,79.01 135.78,79.01 135.52,79.27 135.52,80.84 135.39,80.96 135.13,80.96 135,80.84 135,79.52 134.75,79.27 134.27,79.27 134.02,79.52 134.02,80.49 133.87,80.65 133.26,80.65 133.07,80.46 131.89,80.46 131.64,80.7 131.64,81.04 v2(131.4,81.28)
  BOTTOM w0.127: R6111.2 157.66,67.4 157.66,67.71 157.31,68.06 157.31,68.85 156.9,69.26 155.61,69.26 v2(155.22,69.64) ; CPU1.AF9 131.4,81.4 v2(131.4,81.28)
USB_EN#: length 4.3
  TOP w0.127: v1(192.83,71.53) 192.81,71.56 192.27,71.56 R2479.1 191.92,72.06 191.56,72.42 191.14,72.42 190.55,73.01 KBC24.13
USB_OC0#: length 312.5
  TOP w0.102: U3501.3 22.35,38.67 21.72,38.04 v1(21.72,37.37) 21.72,36.77 v2(21.88,36.61)
  L3 w0.102: v2(135.12,149.41) 134.69,149.84 120.31,149.84 119.85,150.29 118.98,150.29 116.57,152.7 113.8,152.7 112.18,151.08 104.8,151.08 102.11,148.4 96.12,148.4 90.19,142.47 90.19,138.28 v2(90.62,137.85) ; v2(131.78,97.01) 132.1,96.69 132.7,96.69 132.97,96.95 132.97,98.17 134.45,99.65 135.35,99.65 135.7,100 135.7,100.36 136.14,100.8 137.63,100.8 139.21,102.38 146.78,102.38 147.16,102 150.38,102 151.5,103.12 154.4,103.12 156.14,104.86 158.18,104.86 v2(158.47,105.15)
  L4 w0.102: v2(158.47,105.15) 158.47,105.88 156.98,107.36 156.98,112.41 151.25,118.14 151.25,120.13 151.27,120.15 151.27,123.11 151.25,123.13 151.25,127.12 153.12,128.99 153.12,134.62 153.53,135.04 153.53,137.03 152.01,138.55 150.33,138.55 149.51,139.36 145.59,139.36 136.22,148.73 136.22,149.06 135.97,149.31 135.22,149.31 v2(135.12,149.41) ; v2(21.88,36.61) 21.88,37.36 22.42,37.9 22.42,53.32 19.74,56 19.74,57.81 18.41,59.14 18.41,66.93 19.9,68.42 24.63,68.42 25.36,69.15 47.96,69.15 48.79,69.98 55.14,69.98 57.07,71.92 59.54,71.92 82.83,95.21 82.83,98.63 85.61,101.41 v2(85.61,103.97)
  BOTTOM w0.102: v2(85.61,103.97) 85.61,104.66 86.57,105.61 86.57,107.51 88.94,109.88 88.94,114.25 94.04,119.36 94.04,124.34 96.83,127.13 96.83,130.9 91.79,135.95 91.79,135.95 91.79,136.68 v2(90.62,137.85) ; CPU1.A9 131.06,95.6 131.78,96.32 v2(131.78,97.01) 132.29,97.52 132.29,97.69 132.54,97.95 RN1602.7
USB_OC1#: length 315.4
  TOP w0.102: U3502.3 22.36,32.16 22.71,32.51 v2(22.71,33.49)
  L3 w0.102: v2(135.79,148.88) 135.01,148.88 134.26,149.63 120.22,149.63 119.77,150.09 118.89,150.09 116.48,152.5 113.88,152.5 112.26,150.88 104.9,150.88 102.15,148.13 96.23,148.13 90.47,142.38 90.47,138.84 v2(90.62,138.69) ; v2(158.45,104.52) 156.09,104.52 154.49,102.92 151.58,102.92 150.46,101.79 147.08,101.79 146.7,102.17 139.29,102.17 137.71,100.59 136.22,100.59 135.9,100.28 135.9,99.92 135.43,99.45 134.54,99.45 133.41,98.32 v2(133.41,97.66)
  L4 w0.102: v2(158.45,104.52) 158.21,104.52 156.72,106.02 156.72,112.3 151.01,118.01 151.01,127.16 152.85,129.01 152.85,134.64 153.33,135.12 153.33,136.94 151.99,138.28 150.27,138.28 149.46,139.1 145.57,139.1 v2(135.79,148.88) ; v2(86.15,104.41) 86.09,104.47 85.29,104.47 82.63,101.8 82.63,95.29 59.47,72.13 56.98,72.13 55.05,70.2 48.7,70.2 47.86,69.36 25.28,69.36 24.54,68.62 19.81,68.62 19.73,68.54 19.72,68.54 18.21,67.03 18.21,67.02 18.21,59.05 19.53,57.73 19.53,55.91 22.22,53.22 22.22,38.02 21.45,37.25 21.45,36.79 21.45,36.79 21.45,36.43 21.45,36.42 21.45,36.1 22.71,34.85 v2(22.71,33.49)
  BOTTOM w0.102: v2(86.15,104.41) 89.24,107.5 v1(89.24,108.13) 89.24,114.27 94.24,119.27 94.24,124.26 97.04,127.05 97.04,131.12 92.16,135.99 92.16,137.15 v2(90.62,138.69) ; CPU1.C9 131.06,93.96 131.68,94.58 131.68,95.51 133.41,97.24 v2(133.41,97.66) 133.69,97.94 RN1602.5
USB_OC2#: length 142.8
  TOP w0.102: v2(131.84,97.68) 131.85,97.68 v1(132.25,98.08)
  L3 w0.102: v2(131.84,97.68) 131.84,97.84 134.6,100.6 134.6,100.87 135.08,101.36 135.73,101.36 135.85,101.48 137.35,101.48 138.95,103.08 147.05,103.08 147.45,102.68 150.09,102.68 151.21,103.8 154.12,103.8 157,106.68 163.18,106.68 164.79,108.3 166.1,108.3 167.13,107.27 168.93,107.27 169.37,107.72 175.2,107.72 176.61,106.31 182.22,106.31 184.87,103.66 185.36,103.66 190.05,98.97 190.05,97.39 191.49,95.95 192.78,95.95 198.16,90.58 198.16,90.41 198.16,73.9 197.1,72.84 197.1,62.1 192.87,57.87 192.87,49.99 185.39,42.52 v2(184.46,42.52)
  BOTTOM w0.102: CPU1.D9 130.65,93.55 130.65,93.83 130.73,93.9 130.73,96.04 131.39,96.71 131.39,97.23 v2(131.84,97.68) 131.84,97.69 131.89,97.75 RN1602.8 ; U3503.3 185.19,41.78 v2(184.46,42.52)
USB_OC3#: length 109.6
  TOP w0.102: v2(192.86,69.39) 191.99,68.51 R2457.2
  L3 w0.102: v2(192.86,69.39) 193.35,69.39 193.89,69.93 196.05,69.93 196.3,70.18 196.3,74.03 197.47,75.2 197.47,89.96 197.14,90.29 197.14,90.29 192.89,94.54 191.93,94.54 189.36,97.11 189.36,98.69 185.11,102.94 181.16,102.94 180.3,103.8 178.43,103.8 175,107.23 169.57,107.23 169.13,106.79 166.9,106.79 166.27,107.42 164.21,107.42 163.26,106.48 157.08,106.48 154.2,103.6 151.3,103.6 150.18,102.48 147.36,102.48 146.96,102.88 139.03,102.88 137.43,101.28 135.94,101.28 135.81,101.15 135.17,101.15 134.8,100.79 134.8,100.52 132.53,98.25 v2(132.53,97.14)
  BOTTOM w0.102: v1(193.16,69.92) 193.16,69.69 v2(192.86,69.39) ; RN1602.6 133.04,97.89 132.53,97.38 v2(132.53,97.14) 132.53,96.71 131.48,95.65 131.48,95.01 131.06,94.6 CPU1.B9
USB_PN0_C: length 17
  TOP w0.127: 14.67,42.61 15.12,42.16 15.12,39.2 14.81,38.89 14.36,38.89 v2(14.08,38.61) ; 14.67,42.61 13.42,43.86 13.42,44.4 12.83,44.99 12.2,44.99 12.07,45.12 USB1.2 ; 14.67,42.61 AFTP3402.1
  BOTTOM w0.127: TR3601.2 19.18,37.08 18.96,37.3 18.72,37.3 18.35,36.93 17.15,36.93 16.82,37.27 16.82,37.93 16.52,38.22 16.05,38.22 15.83,38 EU3601.1 14.54,38 14.08,38.46 v2(14.08,38.61)
USB_PN1_C: length 20.8
  TOP w0.127: USB2.2 12.07,24.94 12.24,24.77 12.85,24.77 15.13,27.06 15.13,27.52 ; AFTP3405.1 15.13,27.52 ; 15.13,27.52 15.13,27.84 15.74,28.45 18.32,28.45 18.62,28.75 18.62,29.96 18.93,30.27 EU3602.1 21.41,30.27 21.69,30.55 21.69,30.93 22.3,31.55 24.05,31.55 24.67,30.93 24.67,29.61 24.88,29.4 25.14,29.4 25.34,29.61 TR3602.2
USB_PN2_C: length 16.2
  TOP w0.127: 184.93,26.56 185.22,26.56 185.56,26.9 186.08,26.9 186.22,26.77 IOBD1.3 ; 184.93,26.56 182.29,26.56 182.16,26.43 182.16,26.15 v2(182.46,25.85) ; 184.93,26.56 AFTP6301.1
  BOTTOM w0.127: v2(182.46,25.85) 182.18,26.13 182.18,27.01 181.78,27.41 180.91,27.41 EU3404.6 180.48,27.65 180.24,27.41 179.83,27.41 179.12,28.12 177.33,28.12 176.42,27.22 175.1,27.22 174.9,27.42 TR3406.2
USB_PN3_C: length 12.9
  TOP w0.127: 174.58,133.8 AFTP8903.1 ; 174.58,133.8 174.58,132.73 174.95,132.37 174.95,130.73 177.16,128.51 EC9202.2 177.36,126.29 177.36,125.27 R9203.2 ; 174.58,133.8 174.58,134.29 175.43,135.14 175.75,135.14 175.85,135.24 FPR1.4
USB_PN5_C: length 15.7
  TOP w0.127: 183.44,29.43 182.6,28.58 179.06,28.58 178.06,29.59 176.96,29.59 176.52,30.03 176.52,30.42 v2(176.24,30.71) ; 183.44,29.43 AFTP6304.1 ; 183.44,29.43 184.22,30.21 186.25,30.21 186.69,29.77 IOBD1.6
  BOTTOM w0.127: TR3301.2 174.98,30.28 175.2,30.06 176.29,30.06 176.52,30.3 176.52,30.42 v2(176.24,30.71)
USB_PP0_C: length 17
  TOP w0.127: 14.88,40.23 14.88,39.3 14.71,39.13 14.39,39.13 v2(14.1,39.42) ; 14.88,40.23 AFTP3403.1 ; 14.88,40.23 14.88,42.06 13.18,43.76 13.18,44.3 12.73,44.75 12.2,44.75 12.07,44.62 USB1.3
  BOTTOM w0.127: v2(14.1,39.42) 14.58,39.91 EU3601.3 15.95,39.91 17.06,38.8 17.06,37.37 17.25,37.17 18.25,37.17 18.62,37.54 18.96,37.54 19.18,37.76 TR3601.3
USB_PP1_C: length 20.8
  TOP w0.127: 14.25,25.83 15.37,26.96 15.37,27.74 15.84,28.21 18.42,28.21 18.77,28.56 20.3,28.56 20.5,28.37 EU3602.3 21.49,28.37 21.93,28.81 21.93,30.83 22.4,31.31 23.95,31.31 24.43,30.83 24.43,29.51 24.78,29.16 25.15,29.16 25.39,28.92 TR3602.3 ; 14.25,25.83 AFTP3406.1 ; 14.25,25.83 12.95,24.53 12.24,24.53 12.07,24.37 USB2.3
USB_PP2_C: length 16.2
  TOP w0.127: v2(181.65,25.85) 181.92,26.11 181.92,26.53 182.19,26.8 183.13,26.8 ; 183.13,26.8 185.12,26.8 185.46,27.15 185.94,27.15 186.56,27.77 IOBD1.4 ; 183.13,26.8 AFTP6302.1
  BOTTOM w0.127: v2(181.65,25.85) 181.93,26.13 181.93,26.91 181.68,27.17 179.73,27.17 179.02,27.88 178.63,27.88 178.4,27.65 EU3404.1 177.2,27.65 176.52,26.98 175.1,26.98 174.86,26.74 TR3406.3
USB_PP3_C: length 12.8
  TOP w0.127: 175.19,132.12 175.19,132.47 174.82,132.83 174.82,134.19 175.53,134.9 175.68,134.9 175.84,134.74 FPR1.3 ; 175.19,132.12 AFTP8904.1 ; 175.19,132.12 175.19,130.83 177.4,128.61 177.4,127.04 EC9201.2 177.6,126.11 177.6,125.29 R9204.2
USB_PP5_C: length 15.7
  TOP w0.127: 184.97,30.45 186.25,30.45 186.57,30.77 IOBD1.7 ; 184.97,30.45 AFTP6303.1 ; 184.97,30.45 184.12,30.45 182.5,28.82 179.16,28.82 178.16,29.83 177.06,29.83 176.76,30.13 176.76,30.42 v2(177.04,30.71)
  BOTTOM w0.127: TR3301.3 174.98,29.6 175.2,29.82 176.39,29.82 176.76,30.2 176.76,30.42 v2(177.04,30.71)
USB_PWR_EN#: length 269.1
  TOP w0.127: R2434.2 191.03,71.5 191.03,71.5 R2479.2 190.65,72.29 v2(190.4,72.29) ; v2(25.86,33.15) 25.85,33.14 24.19,33.14 23.84,32.79 U3502.4 ; v2(22.32,37.17) 22.32,37.74 23.66,39.09 U3501.4
  L3 w0.127: v2(196.76,22.16) 195.68,21.08 187.14,21.08 186.51,21.71 180.74,21.71 178.56,19.53 174.92,19.53 174.82,19.43 169.23,19.43 168.67,20 149.44,20 143.42,13.98 143.42,13.29 140.36,10.24 140.09,10.24 136.27,6.41 93.82,6.41 90.64,9.59 87.01,9.59 84.89,11.72 76.5,11.72 69.68,18.53 69.68,21.98 64.04,27.62 62.38,27.62 61.2,28.79 51.67,28.79 49.81,26.93 47.79,26.93 47.45,26.59 43.88,26.59 42.82,27.65 32.44,27.65 30.53,29.56 30.53,31.25 29.09,32.69 27.4,32.69 26.95,33.14 25.87,33.14 v2(25.86,33.15)
  L4 w0.127: v2(25.86,33.15) 23.11,35.9 23.11,36.38 v2(22.32,37.17)
  BOTTOM w0.127: v2(190.4,72.29) v1(190.4,71.05) 190.4,69.79 190.56,69.63 190.56,67.91 190.65,67.81 190.65,62.8 188.72,60.87 188.72,60.66 187.56,59.49 187.56,55.79 187.57,55.78 187.57,54.76 187.11,54.3 187.11,41.15 U3503.4 188.85,40.77 190.15,42.07 193.36,42.07 194.91,40.52 194.91,26.63 196.76,24.78 v2(196.76,22.16)
USB_UART_SEL_D9: length 5.5
  BOTTOM w0.089: TP2006.1 139.45,87.39 139.2,87.63 138.88,87.63 138.85,87.61 137.39,87.61 137.12,87.33 135.61,87.33 135.53,87.37 135.29,87.37 CPU1.P2
USBCOMP: length 8.5
  TOP w0.254: 134.68,83.35 134.43,83.6 133.04,83.6 v2(132.81,83.37)
  TOP w0.508: 134.68,83.35 135.29,82.74 v1(135.91,82.74) 137.09,82.74 137.35,83.01 139.36,83.01 R1603.1
  BOTTOM w0.305: CPU1.AB6 132.99,83.55 v2(132.81,83.37)
V_SM_VREF_CNT: length 61.9
  TOP w0.508: R4208.2 57.31,40 C4201.1 58,40.01 59.99,41.99 59.99,43.84 v1(63.76,47.62) 70.05,53.9 84.65,53.9 87.73,56.98 87.73,62.3 92.99,67.57 92.99,69.97 93.46,70.44 v2(94.27,70.44)
  BOTTOM w0.089: CPU1.AY67 97.78,73.47 97.78,73.04 97.74,72.89 97.74,72.64 97.76,72.56 97.76,72.19 96.9,71.33
  BOTTOM w0.127: v2(94.27,70.44) 94.95,71.12 96.7,71.12 96.9,71.33
VCI_IN1#: length 7.8
  TOP w0.102: KBC24.126 186.88,65.67 187.25,65.3 v1(187.25,61.88) 187.25,61.42 187.07,61.25 187.07,60.16 187.46,59.77 188.01,59.77 R2452.1
VCREF0: length 4.8
  TOP w0.102: v1(193.63,76.82) 193.63,76.82 193.2,77.25 R2424.1 192.64,77.33 C2409.1 191.89,77.33 R2448.1 190.45,77.33 189.98,77.81 KBC24.25
VD_IN1_C: length 77.8
  TOP w0.14: C2613.2 R2611.1 194.5,70.26 195.19,70.95 196.11,70.95 196.66,70.4 v2(197.7,70.4)
  L3 w0.127: v2(156.54,102.37) 156.68,102.51 159.28,102.51 159.8,103.03 171.56,103.03 172.33,103.8 175.36,103.8 175.79,103.36 177.57,103.36 178.78,102.15 182.26,102.15 185.01,99.41 186.4,99.41 187.94,97.86 187.94,96.52 191.7,92.76 192.58,92.76 195.66,89.68 195.66,89.62 v2(196.05,89.23)
  BOTTOM w0.14: v2(156.54,102.37) 155.42,102.37 R2610.2 152.97,99.92 C2612.2 ; v2(196.05,89.23) 196.2,89.23 197.1,88.33 197.1,87.3 196.54,86.74 196.54,83.94 197.34,83.14 197.34,82.25 197.97,81.62 197.97,78.19 198.6,77.57 v1(198.6,73.49) 198.6,73.16 198.17,72.73 198.17,70.95 197.7,70.48 v2(197.7,70.4)
VGA_CORE: length 44.3
  L3 w0.508: v2(202.04,96.08) 202.51,96.08 204.78,93.81 213.22,93.81 214.03,93 214.9,93 215.89,94 215.89,95.04 218.6,97.75 v2(218.6,99.65)
  BOTTOM w0.508: 217.89,117.76 220.09,115.56 220.09,100.21 219.52,99.65 v2(218.6,99.65) 217.94,99.65 PR8309.1 ; v2(202.04,96.08) PR8212.1
  vias: v1(192.97,138.31) v1(196.24,139.18) v1(209.5,120.97) v1(209.52,118.24) v2(189.31,145.13) v2(189.33,143.24) v2(189.33,141.21) v2(189.31,139.16) v2(189.35,147.2) v2(190.27,142.24) v2(190.39,138.13) v2(191.16,147.12) v2(191.22,145.13) v2(191.22,143.22) v2(191.22,141.19) v2(191.22,139.16) v2(192.35,138.16) v2(193.16,147.1) v2(193.25,145.13) v2(193.25,143.22) v2(193.26,141.23) v2(193.31,139.27) v2(193.39,137.55) v2(194.23,146.19) v2(195.23,145.13) v2(195.23,143.22) v2(195.28,141.19) v2(195.28,139.16) v2(196.24,146.18) v2(196.18,140.14) v2(196.26,138.34) v2(198.76,130.87) v3(193.1,129.1) v3(194.12,130.16) v3(194.37,129.1) v3(195.39,130.16) v3(195.64,129.1) v3(196.66,130.16) v3(196.67,129.04) v3(197.93,130.16) v3(203.02,122.68) v3(203.69,123.65) v3(203.69,122) v3(204.72,121.31) v3(204.97,125.89) v3(205.73,121.31) v3(205.86,119.16) v3(206.24,125.89) v3(206.24,120.17) v3(206.88,118.9) v3(207.39,125.89) v3(207.77,120.3) v3(208.02,122.58) v3(208.4,124.24) v3(208.78,118.9) v3(208.99,125.34) v3(209.29,122.58) v3(209.67,124.24) v3(209.67,120.3) v3(209.93,125.89) v3(210.63,126.79) v3(210.56,122.58) v3(210.56,118.9) v3(210.81,124.24) v3(211.2,125.89) v3(211.45,120.3) v3(211.83,127.28) v3(211.83,122.58) v3(211.83,118.27) v3(212.13,128.29) v3(212.47,125.89) v3(212.47,119.41) v3(212.72,132.74) v3(212.99,128.69) v3(213.1,134.01) v3(213.1,127.28) v3(213.1,122.58) v3(213.1,118.27) v3(213.23,120.3) v3(213.74,125.89) v3(213.99,135.28) v3(213.99,132.74) v3(214.05,128.67) v3(214.37,134.01) v3(214.37,127.28) v3(214.37,122.58) v3(214.37,121.06) v3(215.03,129.17) v3(215.01,125.89) v3(215.26,135.28) v3(215.39,132.74) v3(215.46,127.13) v3(215.64,134.01) v3(215.73,128.23) v3(215.77,121.06)
VGA_CORE_DISCHG: length 3.5
  BOTTOM w0.102: PR8309.2 216.39,100.31 216.11,100.31 v1(215.81,100) 215.51,99.71 215.51,98.87 215.78,98.6 PQ8305.3
VGA_CORE_PSI: length 55.5
  TOP w0.127: v2(216.31,96.43) v1(216.71,96.83)
  L3 w0.127: v2(204.4,132.36) 204.93,132.36 207.44,129.85 215.29,129.85 216.95,128.19 218.17,128.19 218.51,127.85 218.51,116.82 220.37,114.96 220.37,100.43 220.23,100.3 218.41,100.3 217.84,99.73 217.84,97.96 v2(216.31,96.43)
  BOTTOM w0.127: v2(204.4,132.36) 204.4,133.42 203.82,134 203.05,134 202.68,134.37 GPU1.B4 ; PR8257.1 216.2,96.32 v2(216.31,96.43)
VGA_CORE_VID: length 66.7
  L3 w0.127: v2(198.95,134.78) 199.59,134.78 201.01,133.35 204.71,133.35 207.58,130.48 215.64,130.48 216.48,129.65 218.12,129.65 219.12,128.64 219.12,117.12 220.95,115.3 220.95,98.84 219.06,96.95 v2(219.06,96.11)
  BOTTOM w0.14: GPU1.E7 200.25,136.86 199.79,136.4 199.79,135.06 199.51,134.78 v2(198.95,134.78) ; v2(219.06,96.11) 219.06,95.43 217.46,93.83 215.48,93.83 v1(215.17,93.52) 214.99,93.33 PR8207.1
VGACORE_GND_SENSE_1: length 42.8
  BOTTOM w0.203: v1(198.37,96.96) 198.48,97.07 ; 198.48,97.07 199.52,96.02 199.52,94.64 199.92,94.24 PR8220.2 ; 198.48,97.07 197.24,98.3 197.24,100.38 197.63,100.77 197.63,112.43 198.61,113.42 198.61,119.71 196.48,121.84 196.48,124.96 198.82,127.3 198.82,130.14 199.45,130.77 199.45,131.87 GPU1.F1
VGACORE_VDD_SENSE_1: length 43.5
  BOTTOM w0.203: GPU1.F2 199.78,132.34 199.78,130.63 199.15,130 199.15,127.17 196.81,124.83 196.81,121.98 198.94,119.84 198.94,113.28 197.96,112.29 197.96,100.63 197.57,100.24 197.57,99.17 ; 197.57,99.17 197.57,98.44 199.85,96.16 199.85,94.78 200.06,94.57 200.54,94.57 201.03,95.06 PR8221.2 ; 197.57,99.17 v1(197.78,99.17)
VIDEO_CLK_XTAL_SS: length 4
  BOTTOM w0.14: GPU1.A10 203.53,139.27 204.13,139.27 205.06,138.35 v1(205.68,138.35) R7601.1
VIDEO_THERM_OVERT#: length 2
  BOTTOM w0.127: TP7606.1 190.02,127.52 Q7602.6
VR_CAP: length 3.9
  TOP w0.203: 190.51,74.48 190.37,74.62 190.37,74.85 190.21,75.01 KBC24.18
  TOP w0.254: 190.51,74.48 191.18,73.81 C2418.1 192.38,73.81 v1(192.48,73.72)
VR_EN: length 54.5
  TOP w0.102: PR4630.2 119.22,149.83 R4002.2 119.88,150.4 121.34,151.86 129.29,151.86 132.63,148.51 132.63,148.15 134.2,146.58 v1(134.21,146.58) 134.21,146.58 v2(136.27,144.51)
  L4 w0.102: v2(151.13,127.9) 152.65,129.42 152.65,134.73 153.12,135.2 153.12,136.86 151.91,138.08 150.14,138.08 149.4,138.82 140.14,138.82 136.27,142.69 v2(136.27,144.51)
  BOTTOM w0.102: PR5218.1 151.57,127.46 v2(151.13,127.9)
VR_RDY: length 2.2
  TOP w0.102: PR4670.2 118.1,150.82 PR4614.2 v1(119.09,151.8)
VR_SVID_ALERT#: length 88.3
  TOP w0.14: PR4666.1 120.78,146.77 v2(121.43,146.77)
  L3 w0.127: v2(121.43,146.77) 120.89,146.77 119.97,147.69 119.97,148.47 119.39,149.04 116.69,149.04 116.54,148.9 114.9,148.9 114.49,149.31 109.68,149.31 108.47,148.1 104.19,148.1 100.44,144.35 95.95,144.35 92.95,141.34 92.95,134.48 96.54,130.89 96.54,126.88 95.65,125.99 95.65,124.83 v2(96.12,124.36)
  BOTTOM w0.14: PR4622.2 121.58,146.92 v2(121.43,146.77) ; R728.1 R727.2 99.03,100.5 99.03,101.21 98.01,102.23 98.01,104.39 95.83,106.56 91.88,106.56 90.41,108.04 v1(90.41,112.09) 90.41,113.88 95.56,119.03 95.56,124.05 95.86,124.36 v2(96.12,124.36)
VR_SVID_CLK: length 89.3
  TOP w0.14: PR4665.1 120.94,147.5 v2(121.43,147.5)
  L3 w0.127: v2(96.12,123.72) 95.91,123.72 95.17,124.46 95.17,126.27 95.83,126.93 95.83,130.84 92.44,134.23 92.44,141.55 96.59,145.69 98.02,145.69 98.85,144.85 100.23,144.85 103.96,148.58 108.27,148.58 109.51,149.83 112.07,149.83 114.2,151.95 116.3,151.95 118.7,149.56 119.57,149.56 121.43,147.7 v2(121.43,147.5)
  BOTTOM w0.14: v2(121.43,147.5) 121.69,147.76 PR4621.2 ; R732.2 100.18,101.08 100.18,101.66 99.85,101.99 99.58,101.99 99.21,102.37 99.21,102.64 R723.2 98.67,104.43 95.98,107.12 92.37,107.12 90.97,108.52 v1(90.97,113.21) 90.97,113.65 96.12,118.8 v2(96.12,123.72)
VR_SVID_DATA: length 87.8
  TOP w0.14: PR4623.2 v2(121.4,146.08) 121.33,146.14 PR4667.1
  L3 w0.127: v2(96.12,125.15) 96.82,125.15 97.04,125.37 97.04,131.14 93.46,134.73 93.46,141.03 96.26,143.84 100.65,143.84 104.43,147.62 108.67,147.62 109.88,148.82 114.23,148.82 114.65,148.4 116.82,148.4 116.94,148.52 119.17,148.52 119.37,148.32 119.37,147.58 120.87,146.08 v2(121.4,146.08)
  BOTTOM w0.14: R709.2 97.46,101.96 97.46,102.03 97.32,102.17 96.85,102.17 96.73,102.3 96.73,102.6 96.85,102.73 97.32,102.73 97.46,102.87 97.46,103.15 97.32,103.29 96.88,103.29 96.75,103.42 96.75,103.72 96.88,103.85 97.32,103.85 97.46,103.99 97.46,104.17 95.63,106 91.73,106 89.85,107.89 v1(89.85,110.27) 89.85,114.11 95,119.26 95,124.21 95.94,125.15 v2(96.12,125.15)
VRAM_ID1: length 20.9
  TOP w0.102: v1(146.81,75.09) 147.2,74.7 v2(147.2,74.51) 147.2,74.41 147.56,74.05 R2023.2 147.83,74.05 R2024.1
  L3 w0.102: v2(147.2,74.51) 146.91,74.79 145.99,74.79 145.34,75.44 132.5,75.44 132.08,75.86 132.08,77.45 v2(131.68,77.85)
  BOTTOM w0.102: v2(131.68,77.85) 131.35,77.52 CPU1.AP8
VRAM_ID2: length 29
  TOP w0.102: v1(145.26,65.72) 145.42,65.55 R2034.1 146.26,64.73 R2033.2 146.95,64.74 v2(147.45,65.23)
  L3 w0.102: v2(146.38,72.18) 144.44,74.12 137.98,74.12 137.54,73.67 135.55,73.67 134.26,74.97 v2(131.96,74.97)
  L4 w0.102: v2(146.38,72.18) 147.71,72.18 148.37,71.52 148.37,68.76 147.06,67.44 147.06,65.62 v2(147.45,65.23)
  BOTTOM w0.102: CPU1.AW7 131.96,74.92 131.96,74.92 v2(131.96,74.97)
WHITE_LED_BAT: length 3.7
  BOTTOM w0.508: Q6404.C EC6403.1 R6406.1 184.21,108.43 v1(184.54,108.76)
WIFI_RF_EN: length 87.8
  TOP w0.102: R6114.1 162.52,55.98 163.02,56.48 v1(163.37,56.48) 164.29,56.48 165.76,57.95 v2(165.76,58.22)
  L3 w0.102: v2(164.45,85.26) 160.75,85.26 158.73,87.29 158.06,87.29 156.81,86.04 156.37,86.04 155.24,84.91 151.62,84.91 151.19,85.34 147.01,85.34 v2(146.68,85.67)
  L4 w0.102: v2(141.02,100.67) 143.38,98.31 143.38,97.69 145.55,95.53 145.55,94.06 145.55,94.06 145.55,92.71 146.92,91.34 146.92,88.81 147.27,88.46 147.27,87.8 146.68,87.21 v2(146.68,85.67) ; v2(164.45,85.26) 164.19,85 164.19,84.37 165.11,83.45 165.11,83.39 165.26,83.24 165.26,80.93 165.46,80.74 165.46,79.98 165.46,76.48 166,75.93 166,73 166.23,72.78 166.23,70.52 166.17,70.46 166.17,67.85 166.67,67.34 166.67,66.21 166.42,65.96 166.19,65.96 164.55,64.33 164.55,63.13 165.96,61.72 165.96,58.42 v2(165.76,58.22)
  BOTTOM w0.102: v2(141.02,100.67) 140.47,101.22 139.83,101.22 139.39,101.66 137.74,101.66 137.2,102.21 R1503.2 136.75,101.78 136.75,98.05 136.32,97.63 136.32,97.55 135.7,96.93 134.07,96.93 132.6,95.46 132.6,94.86 132.19,94.45 CPU1.B7
WLAN_CLKREQ_WLAN#: length 5.8
  TOP w0.14: R6112.1 162.18,50.16 v2(162.18,50.76) 160.43,52.51 AFTP5802.1
  BOTTOM w0.14: v2(162.18,50.76) 161.44,50.02 WLAN1.53
WLAN_DISABLE#1: length 11.4
  TOP w0.102: R6114.2 162.27,54.55 161.93,54.21 161.93,53.62 162.27,53.28 AFTP5803.1 162.27,52.77 161.92,52.42 161.92,51.93 164.77,49.07 v2(165.93,49.07)
  BOTTOM w0.102: WLAN1.56 167.31,49.27 167.09,49.05 167.09,48.79 166.83,48.53 166.47,48.53 v2(165.93,49.07)
XCLK_BIASREF: length 17
  TOP w0.203: v1(122,89.52) 122,89.04 122.07,88.97 R1803.1 121.99,88.47 v2(121.38,87.87)
  L4 w0.203: v2(121.38,87.87) 121.33,87.92 117.99,87.92 117.54,88.36 112.58,88.36 112.33,88.61 112.32,88.61 112.1,88.83 112.1,89.27 111.12,90.25 111.12,91.96 111.68,92.53 v2(111.68,92.86)
  BOTTOM w0.203: CPU1.E42 111.68,92.7 v2(111.68,92.86)
XDP_BPM0: length 5.3
  TOP w0.14: v2(106.5,97.44) 106.5,97.45 TP9947.1
  BOTTOM w0.089: v2(106.5,97.44) 106.29,97.44 105.91,97.06 105.22,97.06 104.37,96.2 CPU1.C55
XDP_BPM1: length 1.6
  TOP w0.14: TP9944.1 105.42,93.59 v2(105.39,93.57)
  BOTTOM w0.14: CPU1.D55 105.28,93.46 v2(105.39,93.57)
XDP_BPM2: length 3.6
  TOP w0.14: v2(106.37,96.55) TP9946.1
  BOTTOM w0.089: CPU1.B54 104.93,94.66 105.2,94.92 105.2,95.23 105.18,95.25 105.18,95.84 105.4,96.07 105.89,96.07 v2(106.37,96.55)
XDP_BPM3: length 7.2
  TOP w0.14: v2(105.2,99.55) 105.18,99.52 TP9945.1
  BOTTOM w0.114: 104.95,97.92 104.82,97.78 104.82,97.5 103.53,96.21 103.53,94.17 103.81,93.89 CPU1.C56
  BOTTOM w0.14: 104.95,97.92 105.2,98.17 v2(105.2,99.55)
XDP_DBRESET#: length 10.9
  TOP w0.14: TP9923.1 133.66,94.96 v2(134.3,95.59)
  L4 w0.127: v2(134.3,95.59) 134.3,100.69 v2(134.14,100.84)
  BOTTOM w0.14: R1701.2 EC1706.1 134.92,101.63 v2(134.14,100.84) ; v2(134.3,95.59) 134.02,95.59 133.76,95.33 133.76,94.75 CPU1.B5
XDP_PRDY#: length 5
  TOP w0.14: TP9919.1 105.44,96.66 v2(105.43,96.65)
  BOTTOM w0.089: v2(105.43,96.65) 105.2,96.65 104.67,96.12 104.67,93.98 104.49,93.81 104.31,93.81 103.81,93.3 CPU1.D56
XDP_PREQ#: length 1.7
  TOP w0.14: TP9918.1 101.51,92.58 v2(101.51,92.04)
  BOTTOM w0.14: CPU1.D61 101.51,92.95 v2(101.51,92.04)
XDP_PWRBTN#: length 2.1
  BOTTOM w0.102: TP9904.1 129.77,63.12 129.77,64.54 R9926.2
XDP_SMBCLK: length 1.2
  TOP w0.14: TP9907.1 126.49,29.37 R9920.2
XDP_SMBDAT: length 1.1
  TOP w0.14: R9918.2 TP9906.1
XDP_SPI0_IO2: length 1.3
  BOTTOM w0.14: TP9921.1 138.6,66.29 R1827.1
XDP_TCK_JTAGX: length 16.2
  L4 w0.127: v2(100.91,105.34) 101.11,105.34 101.94,104.51 103.6,104.51 103.7,104.62 v2(104.73,104.62)
  BOTTOM w0.089: 102.81,96.55 102.36,96.09 102.36,95.18 CPU1.A59
  BOTTOM w0.114: 104,98.73 104,98.07 103.56,97.63 103.38,97.63 103,97.25 103,96.74 102.81,96.55
  BOTTOM w0.14: v2(104.73,104.62) 104.95,104.39 R417.1 103.62,102.63 103.62,101.91 104,101.53 TP9915.1 104,98.73 ; R9930.2 v2(100.91,105.34)
