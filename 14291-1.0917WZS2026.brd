# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
L_BKLT_EN: length 65.3
  TOP w0.102: v2(167.86,72.72) 167.91,72.72 169.09,71.54 171.36,71.54 171.77,71.13 R2435.1
  L3 w0.102: v2(145.47,90.55) 146.1,89.91 148.55,89.91 148.83,89.63 151.04,89.63 151.58,90.17 153.9,90.17 154.41,90.68 154.73,90.68 154.93,90.48 155.99,90.48 156.47,90.96 160.22,90.96 160.75,91.49 164.83,91.49 165.4,90.92 v2(165.4,90.39)
  L4 w0.102: v2(129.43,86.57) 130.04,85.96 134.33,85.96 136.95,88.58 138.86,88.58 140.23,89.95 144.87,89.95 v2(145.47,90.55) ; v2(165.4,90.39) 165.4,89.97 165.94,89.43 165.94,86.15 166.6,85.49 166.6,85.29 166.74,85.16 166.74,84.06 166.89,83.91 166.89,82.23 167.6,81.52 167.6,79.28 167.35,79.02 167.35,77.05 167.3,77 167.3,74.13 167.68,73.75 167.68,73.53 v1(167.86,73.34) v2(167.86,72.72)
  BOTTOM w0.102: v2(167.86,72.72) v1(167.86,73.34) ; CPU1.R12 129.08,86.92 v2(129.43,86.57)
L_BKLT_EN_EC: length 3.9
  TOP w0.102: KBC24.91 172.99,70.21 172.74,69.96 R2435.2 171.76,69.97 R2436.1 170.54,69.97 170.21,70.29 v1(170.02,70.29)
LAN_EN: length 17.1
  TOP w0.127: KBC24.3 188.47,69.01 188.31,69.17 186.56,69.17 185.23,70.5 183.4,70.5 183.19,70.72 182.33,70.72 v2(182.15,70.54)
  BOTTOM w0.127: v2(182.15,70.54) 182.17,70.57 182.17,70.85 182.45,71.13 182.45,72.15 v1(181.07,73.53) 180.66,73.94 180.46,73.94 180.1,74.29 180.1,74.32 180.06,74.36 180.06,76 180.06,76.27 178.9,77.43 178.9,77.87 178.86,77.9 R2491.1
LAN_ENABLE_R_C: length 4.9
  TOP w0.127: Q3101.D 60.05,170.78 60.74,171.47 R3110.1 61.49,172.18 61.66,172.35 v1(61.66,172.61) 61.66,172.86 61.46,173.06 R3109.2
LAN_MDI0N: length 30
  TOP w0.089: v2(28.38,167.57) 28.38,167.41 27.99,167.02 27.76,167.02 27.57,167.21 27.57,168.66 29.73,170.82 29.73,174.03 30.49,174.78 31.48,174.78 31.64,174.62 U3201.2 U3201.9 33.56,174.62 33.69,174.76 33.91,174.76 34.67,175.52 35.48,175.52 36.28,174.73 36.56,174.73 EC3102.2 37.17,174.71 38.2,174.71 38.53,174.38 ; LOM31.2 43.98,169.97 43.29,170.65 41.26,170.65 40.06,171.85 38.87,173.04 38.87,174.05 38.53,174.38 ; 38.53,174.38 v1(38.4,174.25)
  BOTTOM w0.089: v2(28.38,167.57) 28.38,167.35 28.28,167.25 28.02,167.25 27.5,167.77 XF3103.11
LAN_MDI0P: length 30
  TOP w0.089: v2(28.38,166.81) 27.67,166.81 27.36,167.12 27.36,168.75 29.51,170.91 29.51,174.11 30.4,175 31.53,175 31.64,175.1 U3201.1 U3201.10 33.56,175.1 33.69,174.97 33.82,174.97 34.58,175.73 35.57,175.73 36.37,174.94 36.59,174.94 EC3101.2 37.17,174.93 38.29,174.93 39.08,174.14 39.08,173.13 40.22,172 ; LOM31.1 43.89,170.37 43.38,170.87 41.35,170.87 40.22,172 ; 40.22,172 v1(40.33,172.11)
  BOTTOM w0.089: v2(28.38,166.81) 28.16,167.03 27.86,167.03 27.59,166.77 XF3103.12
LAN_MDI1N: length 25.8
  TOP w0.089: v2(31.35,170.6) 31.35,170.38 31.25,170.27 30.98,170.27 30.82,170.43 30.82,173.04 31.14,173.37 31.46,173.37 31.73,173.1 U3201.5 U3201.6 33.7,173.1 33.84,173.23 34.6,173.23 34.8,173.43 35,173.43 EC3104.2 35.6,173.4 35.9,173.4 36.79,172.51 37.87,172.51 39.56,170.82 39.56,169.56 40.22,168.9 41.27,168.9 ; LOM31.5 43.88,168.77 43.75,168.9 41.27,168.9 ; 41.27,168.9 v1(41.27,168.74)
  BOTTOM w0.089: XF3103.8 28.12,170.77 28.63,170.25 31.19,170.25 31.35,170.41 v2(31.35,170.6)
LAN_MDI1P: length 25.9
  TOP w0.089: 39.78,170.77 39.78,169.65 40.31,169.11 43.86,169.11 43.92,169.17 LOM31.4 ; 39.78,170.77 v1(39.92,170.77) ; 39.78,170.77 39.78,170.91 37.96,172.72 36.88,172.72 35.99,173.62 35.6,173.62 EC3103.2 35.06,173.64 34.71,173.64 34.51,173.45 33.84,173.45 33.7,173.58 U3201.7 U3201.4 31.05,173.58 30.6,173.13 30.6,170.34 30.89,170.05 31.15,170.05 v2(31.35,169.85)
  BOTTOM w0.089: v2(31.35,169.85) 31.16,170.04 28.42,170.04 28.16,169.77 XF3103.9
LAN_MDI2N: length 28.4
  TOP w0.089: v2(41.5,167.4) 41.71,167.61 42.58,167.61 ; LOM31.7 43.85,167.97 43.85,167.97 43.47,167.97 43.11,167.61 42.58,167.61 ; v1(42.58,167.45) 42.58,167.61
  BOTTOM w0.089: v2(41.5,167.4) 41.66,167.55 41.97,167.55 42.27,167.85 42.27,168.64 41.81,169.11 41.81,174.05 40.72,175.15 EC3106.2 36.54,175.15 36.03,174.63 35.03,174.63 34.85,174.81 34.85,175.34 34.63,175.56 34.28,175.56 34.18,175.66 U3202.9 U3202.2 32.43,175.66 32.3,175.52 31.49,175.52 29.33,173.37 28.36,173.37 27.96,173.77 XF3103.5
LAN_MDI2P: length 28.4
  TOP w0.089: LOM31.6 43.94,168.37 43.76,168.18 43.38,168.18 43.02,167.82 41.6,167.82 41.5,167.92 v2(41.5,168.17)
  BOTTOM w0.089: 38.02,174.93 37.42,174.93 EC3105.2 36.58,174.6 36.3,174.6 36.12,174.42 34.94,174.42 34.63,174.72 34.63,175.25 34.54,175.34 34.34,175.34 34.18,175.18 U3202.10 U3202.1 32.45,175.18 32.32,175.31 31.58,175.31 29.42,173.15 28.25,173.15 27.87,172.77 XF3103.6 ; 38.02,174.93 v1(38.02,174.76) ; 38.02,174.93 40.63,174.93 41.59,173.97 41.59,169.02 42.06,168.55 42.06,167.94 41.88,167.77 41.73,167.77 41.5,168 v2(41.5,168.17)
LAN_MDI3N: length 32.7
  TOP w0.089: LOM31.10 45.53,166.46 45.08,166.01 44.1,166.01 v2(43.87,165.79)
  BOTTOM w0.089: 39.82,176.96 40.42,176.96 42.54,174.84 42.54,169.41 43.06,168.89 43.06,167.41 42.87,167.22 42.87,165.99 43.73,165.13 43.99,165.13 44.42,165.56 44.42,165.97 44.28,166.11 43.99,166.11 43.87,165.99 v2(43.87,165.79) ; 39.82,176.96 35.93,176.96 35.76,177.13 EC3108.2 35.23,177.13 35.02,176.92 34.59,176.92 34.33,177.18 U3202.6 U3202.5 32.43,177.18 32.17,176.92 30.06,176.92 29.41,176.26 28.43,176.26 27.92,176.77 XF3103.2 ; 39.82,176.96 v1(39.82,177.14)
LAN_MDI3P: length 32.7
  TOP w0.089: LOM31.9 45.13,166.37 44.99,166.23 44.22,166.23 v2(43.89,166.55)
  BOTTOM w0.089: 38.55,176.74 v1(38.55,176.59) ; 38.55,176.74 40.33,176.74 42.32,174.75 42.32,169.32 42.84,168.8 42.84,167.5 42.65,167.31 42.65,165.9 43.64,164.92 44.08,164.92 44.63,165.47 44.63,166.06 44.37,166.33 44.12,166.33 v2(43.89,166.55) ; 38.55,176.74 35.93,176.74 EC3107.2 34.97,176.7 U3202.7 U3202.4 30.15,176.7 29.5,176.05 28.37,176.05 28.09,175.77 XF3103.3
LANXIN: length 7.5
  TOP w0.14: X3101.1 45.99,177.37 45.63,177.01 45.63,175.2 46.27,174.56 C3101.1 46.27,173.43 46.73,172.97 v1(46.73,172.7) 46.73,171.05
LANXOUT: length 5.8
  TOP w0.14: X3101.3 44.49,175.86 45.05,175.3 45.05,174.96 45.46,174.54 C3107.1 45.65,174.22 v1(45.65,173.38) 45.65,172.97 46.33,172.29 LOM31.29
LCD_BRIGHTNESS: length 3.8
  TOP w0.14: v2(76.83,167.48) 77.06,167.48 77.4,167.82 LCD1.20
  BOTTOM w0.14: v1(77.83,167.48) v2(76.83,167.48) 76.53,167.18 RN5503.2
LCD_CBL_DET#: length 199.7
  TOP w0.127: R2047.2 142.54,87.94 141.71,87.94 v2(141.34,88.31) 141.07,88.31 140.75,87.99 136.05,87.99 v1(134.82,86.77) 133.57,85.52 v2(133.42,85.52) ; R5539.2 81.54,166.24 81.75,166.03 v2(81.75,165.76)
  L3 w0.127: v2(160.1,163.31) 159.69,163.72 159.07,163.72 155.2,167.59 152.86,167.59 148.2,172.25 136.99,172.25 135.16,170.43 129.82,170.43 129.19,169.79 126.77,169.79 124.88,171.68 121.59,171.68 121.42,171.85 120.28,171.85 120.04,171.6 114.92,171.6 113.68,172.84 109.93,172.84 108.66,174.11 105.97,174.11 105.8,173.94 102.17,173.94 102,174.11 91.08,174.11 88.3,171.34 87.71,171.34 82.14,165.76 v2(81.75,165.76) ; v2(141.34,88.31) 141.34,88.31 141.34,88.55 141.62,88.84 143.03,88.84 143.95,89.76 145.72,89.76 145.87,89.62 148.43,89.62 148.66,89.39 151.18,89.39 151.7,89.9 154.12,89.9 154.27,89.76 155.61,89.76 156.53,90.68 157.83,90.68 159.46,90.68 161.01,90.68 161.21,90.48 v2(161.21,90.49)
  L4 w0.127: v2(160.1,163.31) 160.9,162.51 160.9,160.3 161.47,159.73 161.47,154.86 160.34,153.73 160.34,153.53 160.34,151.59 160.73,151.19 160.73,149.03 159.66,147.96 159.66,140.12 159.66,138.77 160.82,137.61 160.82,131.91 162.56,130.17 162.56,119.73 161.95,119.13 161.95,109.62 162.62,108.96 162.62,103.2 161.93,102.51 161.93,101.51 161.16,100.74 161.16,99.78 161.63,99.32 161.63,93.15 161.68,93.1 161.68,91.4 161.21,90.93 v2(161.21,90.49)
  BOTTOM w0.127: v2(133.42,85.52) 133.76,85.17 CPU1.W4
LCD_CBL_DET#_R: length 2.7
  TOP w0.127: LCD1.23 78.55,166.32 79.19,165.68 v1(79.5,165.68) 79.75,165.68 R5539.1
LCD_TST: length 213.2
  TOP w0.102: v2(73.67,167.83) 72.98,167.14 70.84,167.14 67.54,163.84 v2(65.46,163.84) ; R2419.1 191.01,77.8 190.31,77.8 189.9,78.21 KBC24.26 188.27,78.21 187.82,78.66 187.82,79.42 187.12,80.13 187.12,80.67 v2(187.1,80.69)
  L3 w0.102: v2(73.67,167.83) 76.57,167.83 76.65,167.91 78.89,167.91 79.19,168.21 80.37,168.21 81.47,167.11 82.47,167.11 87.35,171.99 88,171.99 90.84,174.82 102.2,174.82 102.44,174.58 105.53,174.58 105.75,174.8 108.89,174.8 110.19,173.49 113.95,173.49 114.69,172.75 115.43,172.75 115.87,173.2 117.75,173.2 118.01,172.94 118.94,172.94 119.38,172.5 121.69,172.5 121.86,172.33 125.69,172.33 126.67,171.35 128.35,171.35 128.63,171.07 129.3,171.07 134.89,171.07 136.72,172.9 148.47,172.9 152.99,168.38 155.32,168.38 159.34,164.37 160.23,164.37 160.73,163.87 v2(164.85,163.87)
  L4 w0.102: v2(164.85,163.87) 166.14,162.58 166.14,159.38 167.89,157.63 167.89,147.65 167.52,147.27 167.52,144.82 167.85,144.5 167.85,141.86 168.27,141.44 168.27,140.5 170.75,138.02 170.75,133.31 172.71,131.34 172.71,129.36 177.83,124.24 177.83,122.81 181.4,119.24 181.4,118.57 182.05,117.92 182.05,112.46 182.91,111.6 182.91,99.99 183.71,99.19 183.71,97.79 183.53,97.6 183.53,90.49 184.98,89.04 184.98,87.96 185.3,87.64 185.47,87.64 186.96,86.16 186.96,82.47 187.1,82.34 v2(187.1,80.69)
  BOTTOM w0.102: v2(164.85,163.87) v1(164.24,163.87) ; D5503.2 v2(65.46,163.84) ; RN5503.8 v2(73.67,167.83)
LCD_TST_C: length 6.9
  TOP w0.102: LCD1.10 v2(77.01,172.82)
  BOTTOM w0.102: RN5503.1 76.08,167.83 76.73,168.48 v1(76.73,168.94) 76.73,172.54 v2(77.01,172.82)
LCD_TST_EN: length 252.2
  TOP w0.102: v2(151.96,175.03) 151.83,175.03 150.5,173.7 150.5,163.41 v1(152.22,161.69) v2(152.77,161.14) ; v2(199.84,97.98) 199.84,97.69 198.98,96.83 198.98,94.76 195.53,91.3 195.53,88.08 195.64,87.97 195.64,87.63 196.64,86.64 199.71,86.64 200.08,86.27 200.08,80.42 198.99,79.34 198.99,77.86 195.63,74.5 194.49,74.5 194.11,74.89 194.11,76.85 193.83,77.12 193.82,77.12 193.14,77.8 192.62,77.8 R2419.2
  L3 w0.102: v2(199.84,97.98) 199.61,97.98 199.3,98.29 198.54,98.29 192.21,104.63 190.66,104.63 180.3,114.98 180.3,115.71 179.35,116.66 176.42,116.66 175.82,117.26 174.7,117.26 174.39,116.96 172.2,116.96 171.97,116.73 171.3,116.73 167.01,121.01 v2(167.01,121.17) ; v2(152.77,161.14) 154.39,159.52 154.39,158.35 157.92,154.82 157.92,150.93 163.64,145.22 v2(163.64,145.17)
  L4 w0.102: v2(151.96,175.03) 150.92,176.06 140.26,176.06 138.74,177.59 128.85,177.59 126.92,175.67 120.04,175.67 119.69,176.01 118.49,176.01 116.58,177.92 95.76,177.92 95.68,177.85 87.52,177.85 86.58,176.91 86.58,175.87 89.18,173.27 89.18,163.58 86.33,160.73 86.33,152.08 89.1,149.31 89.1,147.88 89.78,147.2 v2(89.89,147.2)
  BOTTOM w0.102: v2(167.01,121.17) 167.92,121.17 168.76,122.01 168.76,125.2 168.42,125.54 167.12,125.54 167.11,125.54 166.94,125.72 166.94,129.01 166.24,129.7 166.24,134.79 162.98,138.05 162.98,144.51 v2(163.64,145.17) ; v2(89.89,147.2) 84.98,147.2 84.74,146.95 D5502.2
LCDVDD:
  vias: v1(79.69,159.68)
LCDVDD_EN: length 11.3
  BOTTOM w0.102: U5501.1 79.51,155.9 79.43,155.98 R5506.2 78.85,155.48 80.32,154.02 80.32,153.8 82.82,151.29 v1(82.82,150.83) D5502.3
LCDVDD_LCD:
  vias: v1(80.61,167.24) v2(79.39,175.95) v2(80.13,176.21) v2(80.89,176.23)
LDO1_CAP: length 4.6
  TOP w0.203: 23.26,17.71 23.7,17.27 HDA27.27
  TOP w0.254: R2711.2 21.17,19.03 C2702.2 22.36,18.62 v1(22.79,18.19) 23.26,17.71
LDO2_CAP: length 4.8
  TOP w0.203: HDA27.39 25.95,12.2 25.48,11.72
  TOP w0.254: C2712.2 22.83,11.74 23.74,11.74 v1(23.91,11.57) 24.01,11.47 25.23,11.47 25.48,11.72
LDO3_CAP: length 3.8
  TOP w0.203: 31.43,16.13 31.01,16.13 30.95,16.07 HDA27.7
  TOP w0.254: 31.43,16.13 32.01,16.13 33.31,17.43 C2718.1
LED0: length 2
  TOP w0.102: TP3103.1 47.13,171.89 LOM31.27
LED1: length 5.8
  TOP w0.102: R3114.1 49.2,175.49 48.1,174.39 v1(48.1,174.24) 48.1,173.62 48.34,173.38 48.34,172.46 47.53,171.65 LOM31.26
LED2: length 3.8
  TOP w0.102: TP3101.1 49.16,174.09 49.16,172.86 47.93,171.64 LOM31.25
LED_SATA_DIAG_OUT#: length 40.2
  TOP w0.14: v2(188.01,80.75) 188.01,80.28 188.48,79.81 KBC24.30
  L4 w0.127: v2(188.01,80.75) 187.55,81.2 187.55,82.47 187.38,82.65 187.38,83.57 187.38,84.79 187.41,84.83 187.41,86.58 186.95,87.04 186.95,87.88 186.53,88.29 186.53,89.3 184.81,91.03 184.81,97.07 185,97.26 185,99.78 184.24,100.54 184.24,114.26 v2(184.16,114.33)
  BOTTOM w0.14: Q6408.4 183.07,114.11 R6402.2 v2(184.16,114.33) ; v1(188.14,81.34) 188.01,81.21 v2(188.01,80.75)
LID_CL_SIO#: length 189.7
  TOP w0.102: R6408.1 219.29,152.39 219.86,152.96 219.86,163.94 218.89,164.9 218.89,167.07 219.76,167.93 219.76,178.23 219.25,178.74 186.79,178.74 186,179.53 168.11,179.53 v2(168.01,179.43) ; v2(186.5,87.68) 186.5,87.78 v1(186.16,88.13) ; R2433.1 185.16,84.05 v2(184.57,83.45) 184.48,83.36 KBC24.41
  L4 w0.102: v2(186.5,87.68) 186.5,87.73 186.11,88.12 186.11,89.13 184.39,90.85 184.39,97.24 184.58,97.43 184.58,99.54 183.82,100.3 183.82,113.59 182.91,114.49 182.91,118.28 182.27,118.92 182.27,119.44 182.27,119.64 179.92,121.98 179.92,123.54 177.1,126.36 177.1,127.2 176.35,127.95 176.1,127.95 173.58,130.48 173.58,131.7 172.46,132.81 172.28,132.99 172.28,134.5 173.42,135.64 173.42,136.56 172.87,137.12 172.32,137.12 171.9,137.54 171.9,138.09 169.29,140.7 169.29,141.68 168.77,142.21 168.77,144.91 168.43,145.24 168.43,157.5 167.67,158.27 167.67,179.08 v2(168.01,179.43)
  BOTTOM w0.102: v2(186.5,87.68) 186.5,87.68 186.56,87.68 187.04,87.21 187.04,85.89 185.55,84.4 185.52,84.4 v2(184.57,83.45) 184.57,83.24 184.48,83.14 D2402.K
LID_CLOSE#_C: length 18.7
  TOP w0.102: PWR1.3 217.2,166.02 219.32,163.89 219.32,156.43 218.84,155.95 AFTP6104.1 218.84,154.36 219.27,153.93 R6408.2 218.81,152.82 218.81,151.9 EC6405.1
LINE1-L_C: length 2.7
  TOP w0.254: C2907.2 19.99,22.52 v1(19.96,22.48) 19.93,22.51 19.45,22.51 19.35,22.41 19.22,22.41 18.78,21.97 R2922.1
LINE1-L_R: length 2.3
  TOP w0.254: R2921.1 19.81,23.82 19.93,23.7 v1(19.96,23.7) 20.11,23.7 20.23,23.82 C2908.2
LINE1_L: length 5.6
  TOP w0.203: 25.26,19.68 25.69,19.68 25.95,19.42 HDA27.22
  TOP w0.254: 25.26,19.68 24.79,19.68 v1(23.72,20.75) 23.04,21.43 23.04,21.91 C2907.1
LINE1_R: length 7.2
  TOP w0.203: HDA27.21 26.35,19.47 25.64,20.19 25.35,20.19
  TOP w0.254: 25.35,20.19 25,20.19 23.62,21.57 v1(23.62,23.02) 22.81,23.82 C2908.1
LINE1_VREFO_L: length 3.1
  TOP w0.203: 23.55,15.67 HDA27.31
  TOP w0.254: 23.55,15.67 22.58,15.67 22.47,15.78 v1(22.35,15.78) 21.6,15.78 R2912.1
LINE1_VREFO_R: length 8.4
  TOP w0.203: HDA27.30 23.55,16.07
  TOP w0.254: 23.55,16.07 22.78,16.07 22.57,16.29 22.09,16.29 21.83,16.54 19.55,16.54 19.27,16.82 19.27,17.28 v1(19.22,17.33) 19.25,17.33 19.58,17.66 19.58,18.29 19.3,18.57 19.28,18.57 19.08,18.78 R2913.1
LOM_CABLE_DETECT#: length 239.7
  TOP w0.127: v2(48.31,175.27) 48.31,175.97 R3114.2 ; R1609.2 141.58,91.11 140.71,91.11 140.08,91.74 137.75,91.74 v2(137.33,91.32)
  L3 w0.127: v2(137.33,91.32) 137.79,91.78 137.8,91.78 137.93,91.91 138.93,91.91 139.92,92.89 140.94,92.89 141.61,93.57 143.39,93.57 143.41,93.56 143.83,93.56 144.09,93.82 145.49,93.82 145.78,94.11 149.09,94.11 149.61,93.59 154.09,93.59 155.46,94.95 158.64,94.95 159.01,94.58 162.56,94.58 162.89,94.91 v2(162.89,94.96) ; v2(48.31,175.27) 48.31,175.97 49.41,177.07 52.83,177.07 58.07,171.83 64.04,171.83 66.21,174 77.5,174 77.56,173.94 81.16,173.94 81.67,174.45 81.67,174.65 82.36,175.34 84.61,175.34 85.51,174.44 88.42,174.44 90.39,176.41 102.65,176.41 103,176.05 104.97,176.05 105.15,176.23 114.09,176.23 115.19,175.13 117.77,175.13 118.25,174.65 126.54,174.65 126.6,174.59 135.23,174.59 135.42,174.4 148.99,174.4 152.68,170.71 155.05,170.71 155.42,170.34 158.65,167.12 159.73,167.12 160.18,166.67 v2(161.5,166.67)
  L4 w0.127: v2(161.5,166.67) 161.59,166.58 161.59,163.97 162.17,163.39 162.17,163 161.86,162.69 161.86,160.69 162.15,160.39 162.15,158.52 164.58,156.1 164.58,151.91 160.34,147.67 160.34,139.84 160.34,139.83 160.34,139.06 162.8,136.6 162.8,136 164.68,134.13 165.08,133.72 165.08,130.8 164.4,130.12 164.4,128.25 164.4,127.11 164.79,126.72 164.79,121.15 164.69,121.05 164.69,118.27 163.7,117.29 163.7,108.46 163.94,108.23 163.94,106.63 163.69,106.38 163.69,102.75 163.12,102.19 163.12,100.21 162.69,99.78 162.69,95.55 162.89,95.35 v2(162.89,94.96)
  BOTTOM w0.089: v2(137.33,91.32) 137.04,91.32 136.23,90.51 135.61,90.51 135.52,90.47 135.25,90.47 135.16,90.51 134.96,90.51 134.87,90.47 134.64,90.47 CPU1.J3
  BOTTOM w0.127: v2(161.5,166.67) v1(161.5,166.07)
LOM_TCT: length 19
  TOP w0.508: v2(28.81,171.76) v1(28.81,173.18) v2(28.81,174.76) 28.95,174.76 29.73,175.54 29.73,177.63 C3119.1 29.59,177.76 v2(28.81,177.76)
  L4 w0.508: v2(28.32,168.76) 28.81,169.25 v2(28.81,171.76)
  BOTTOM w0.508: v2(28.81,177.76) 28.8,177.77 XF3103.1 ; v2(28.81,174.76) 28.8,174.77 XF3103.4 ; v2(28.32,168.76) 28.32,168.77 XF3103.10 ; v2(28.81,171.76) 28.8,171.77 XF3103.7
LPC_FRAME#_DEBUG: length 5.3
  BOTTOM w0.14: v1(166.48,41.24) R6801.2 166.48,39.33 164.34,37.19 DB1.6
LPC_LAD0: length 113.9
  TOP w0.14: v2(142.39,48.67) 142.49,48.57 143.18,48.57 146.76,44.99 160.46,44.99 161.81,43.64 162.53,43.64 163.95,45.06 171.72,45.06 172.1,45.06 173.83,45.06 v1(176.15,47.39) v2(177.12,48.35) ; v2(177.97,83.38) 177.75,83.38 177.28,82.9 KBC24.59
  L4 w0.127: v2(177.12,48.35) 177.21,48.35 180.55,51.69 180.55,55.16 180.73,55.33 180.73,58.46 180.98,58.7 180.98,61.01 180.41,61.57 180.41,62.43 180.04,62.8 180.04,65.08 180,65.12 180,67.34 179.62,67.72 179.62,73.56 179.32,73.87 179.32,74.58 178.68,75.21 178.68,76.84 178.49,77.03 178.49,78.55 178.93,78.99 178.93,80.15 178.65,80.42 178.3,80.42 177.97,80.75 v2(177.97,83.38)
  BOTTOM w0.14: RN6801.4 177.74,39.43 178.53,40.22 178.53,43.75 177.01,45.27 177.01,48.24 v2(177.12,48.35) ; RN1806.8 130.57,63.59 130.93,63.23 130.93,61 131.87,60.06 132.38,60.06 133.95,58.49 133.95,56.33 133.11,55.5 133.11,53.02 135.23,50.9 139.96,50.9 141.63,49.23 142.13,49.23 142.39,48.98 v2(142.39,48.67)
LPC_LAD0_C: length 9.1
  BOTTOM w0.14: DB1.2 169.34,38.28 169.6,38.53 170.7,38.53 172.19,40.02 v1(173.58,40.02) 174.77,40.02 175.36,39.43 RN6801.5
LPC_LAD0_R: length 9.9
  BOTTOM w0.089: 128.46,70.48 v1(128.47,70.48) 128.46,70.48 ; 128.46,70.48 128.46,71.77 128.13,72.1 128.13,72.56 128.18,72.67 128.18,72.86 128.13,73.03 128.13,73.42 128.39,73.68 CPU1.AY13 ; 128.46,70.48 128.46,70.48 ; 128.46,70.48 128.46,70.11 128.61,69.97 128.61,68.96 128.84,68.73
  BOTTOM w0.14: RN1806.1 130.57,65.53 129.22,66.88 129.22,68.35 128.84,68.73
LPC_LAD1: length 108.9
  TOP w0.14: v2(142.06,50.2) 142.06,49.5 142.34,49.21 142.51,49.21 142.69,49.03 143.32,49.03 146.93,45.41 160.63,45.41 161.98,44.06 162.36,44.06 163.78,45.48 171.89,45.48 172.28,45.48 172.28,45.48 173.57,45.48 v1(174.34,46.26) 177.38,49.3 v2(177.38,49.3) ; KBC24.60 176.88,81.28 v2(176.61,81.01)
  L4 w0.127: v2(177.38,49.3) 178,49.91 178,56.46 178.45,56.91 178.45,57.35 178.33,57.46 178.33,58.58 178.91,59.16 178.91,62.31 178.75,62.47 178.36,62.86 178.36,62.86 178.36,66.1 178.48,66.22 178.48,73 178.15,73.33 178.15,74.07 176.95,75.27 176.95,78.23 177.24,78.52 177.24,79.1 177.38,79.24 177.38,80.25 v2(176.61,81.01)
  BOTTOM w0.14: RN6801.3 177.76,40.08 178.11,40.43 178.11,43.57 176.59,45.09 176.59,48.88 177,49.3 v2(177.38,49.3) ; RN1806.6 131.72,63.66 131.77,63.61 131.77,61.35 132.22,60.9 132.73,60.9 134.79,58.84 134.79,55.99 133.95,55.15 133.95,53.37 135.58,51.74 140.52,51.74 v2(142.06,50.2)
LPC_LAD1_C: length 10.4
  BOTTOM w0.14: DB1.3 168.09,38.26 168.78,38.95 170.48,38.95 172.01,40.48 v1(174.71,40.48) 174.95,40.48 175.34,40.08 RN6801.6
LPC_LAD1_R: length 9.5
  BOTTOM w0.114: 129.11,69.37 129.08,69.4 129.08,70.97 128.86,71.19 128.86,71.94 128.75,72.04 128.75,72.53 128.39,72.89 CPU1.BA13
  BOTTOM w0.14: 129.11,69.37 v1(129.27,69.21) 129.78,68.69 129.78,67.54 131.72,65.6 RN1806.3
LPC_LAD2: length 113.8
  TOP w0.14: v2(179.06,50.83) 179.06,50.47 178.37,49.77 177.01,49.77 v1(174.91,47.67) 173.14,45.9 172.45,45.9 172.06,45.9 163.31,45.9 162.56,45.15 162.18,45.15 161.49,45.15 160.81,45.83 147.11,45.83 143.48,49.46 142.86,49.46 142.65,49.66 v2(142.53,49.66) ; KBC24.61 176.48,82.96 177,83.48 v2(177.21,83.48)
  L4 w0.127: v2(177.21,83.48) 177.58,83.12 177.58,80.58 177.76,80.41 177.76,79.06 177.73,79.04 177.73,76.67 177.85,76.56 177.85,74.93 178.53,74.25 178.53,73.51 178.86,73.18 178.86,65.16 179.27,64.75 179.27,62.46 179.29,62.44 179.29,59 178.72,58.43 178.72,57.62 178.83,57.51 178.83,56.59 178.51,56.27 178.51,51.5 179.06,50.95 v2(179.06,50.83)
  BOTTOM w0.14: v2(179.06,50.83) 179.06,50.47 178.35,49.75 176.77,49.75 176.17,49.14 176.17,44.92 177.69,43.4 177.69,40.8 177.47,40.58 RN6801.2 ; RN1806.7 131.22,63.55 131.35,63.42 131.35,61.17 132.04,60.48 132.55,60.48 134.37,58.66 134.37,56.16 133.53,55.32 133.53,53.19 135.41,51.32 140.15,51.32 141.8,49.66 v2(142.53,49.66)
LPC_LAD2_C: length 11.6
  BOTTOM w0.14: DB1.4 166.84,37.85 168.36,39.37 170.22,39.37 171.75,40.9 v1(172.39,40.9) 175.19,40.9 175.5,40.58 RN6801.7
LPC_LAD2_R: length 8.6
  BOTTOM w0.114: 129.01,68.89 128.88,69.03 128.88,70.89 128.65,71.11 128.65,71.85 128.54,71.96 128.54,72.31 CPU1.BB13
  BOTTOM w0.14: 129.01,68.89 129.5,68.41 129.5,67.23 v1(130.55,66.17) 131.22,65.5 RN1806.2
LPC_LAD3: length 105.4
  TOP w0.14: KBC24.62 176.08,80.81 v2(176.58,80.3) ; v2(177.51,50.23) 176.67,50.23 v1(176.61,50.17) 176.6,50.17 172.76,46.32 172.24,46.32 163.13,46.32 162.38,45.57 162.01,45.57 161.33,46.25 147.35,46.25 v2(144.61,48.99)
  L4 w0.127: v2(176.58,80.3) 176.99,79.89 176.99,79.42 176.86,79.28 176.86,78.69 176.57,78.41 176.57,75.06 177.77,73.86 177.77,73.16 178.1,72.83 178.1,66.4 177.98,66.28 177.98,61.71 178.32,61.37 178.32,59.97 177.93,59.58 177.93,57.88 177.51,57.47 v2(177.51,50.23)
  BOTTOM w0.14: v2(177.51,50.23) 176.66,50.23 175.75,49.32 175.75,44.75 176.98,43.51 RN6801.1 ; v2(144.61,48.99) 143.84,48.99 142.68,50.15 142.68,50.52 141.04,52.15 135.75,52.15 134.37,53.54 134.37,54.97 135.21,55.81 135.21,59.01 132.9,61.32 132.39,61.32 132.21,61.5 132.21,63.49 132.37,63.65 RN1806.5
LPC_LAD3_C: length 12.9
  BOTTOM w0.14: RN6801.8 175.49,41.23 175.39,41.33 170.93,41.33 v1(170.67,41.07) 170.53,40.94 170.53,40.29 170.03,39.79 168.14,39.79 165.59,37.24 DB1.5
LPC_LAD3_R: length 10.9
  BOTTOM w0.089: 128.95,72.62 128.95,72.97 128.63,73.29 128.63,73.57 128.78,73.72 128.78,73.9 CPU1.AY12
  BOTTOM w0.114: 129.74,69.3 129.28,69.75 129.28,71.06 129.06,71.28 129.06,72.02 128.96,72.12 128.96,72.61 128.95,72.62
  BOTTOM w0.14: 129.74,69.3 130.05,68.98 130.05,67.89 131.93,66.01 v1(132.08,66.01) 132.21,66.01 132.37,65.85 RN1806.4
LPC_LFRAME#: length 111.6
  TOP w0.14: v2(178.96,51.98) 178.06,51.08 176.92,51.08 v1(175,49.15) 172.59,46.74 162.66,46.74 162.59,46.67 147.58,46.67 144.8,49.45 v2(144.16,49.45) ; v2(178.48,79.96) 178.48,79.99 177.68,80.79 KBC24.58
  L4 w0.127: v2(178.96,51.98) 178.96,52.52 179.65,53.21 179.65,55.34 179.61,55.38 179.61,58.23 180.09,58.71 180.09,59.55 179.7,59.95 179.7,60.33 180.03,60.66 180.03,62.26 179.65,62.64 179.65,62.95 179.66,62.96 179.66,64.91 179.24,65.33 179.24,73.39 178.93,73.69 178.93,74.4 178.23,75.11 178.23,76.74 178.11,76.85 178.11,78.86 178.48,79.23 v2(178.48,79.96)
  BOTTOM w0.14: R1801.1 133.03,61.79 135.63,59.18 135.63,55.64 134.79,54.8 134.79,53.71 135.93,52.57 140.87,52.57 141.39,52.57 143.1,50.86 143.1,50.33 143.98,49.45 v2(144.16,49.45) ; R6801.1 167.64,40.24 169.14,40.24 170.67,41.77 173.33,41.77 174.49,42.93 174.49,48.65 177.81,51.98 v2(178.96,51.98)
LPC_LFRAME#_R: length 13.5
  BOTTOM w0.089: 129.26,71.36 129.26,72.1 129.15,72.22 129.15,73.25 CPU1.BA12
  BOTTOM w0.114: 129.7,69.69 129.5,69.89 129.5,71.13 129.26,71.36
  BOTTOM w0.14: 129.7,69.69 130.3,69.09 130.3,67.99 131.87,66.41 132.9,66.41 v1(133.4,65.92) 133.4,64.6 132.88,64.08 132.88,63.23 132.68,63.03 132.68,62.68 R1801.2
LPSS_UART2_CTS#: length 17.1
  TOP w0.14: TP2009.1 134.11,83.13 v2(133.47,83.13)
  L4 w0.127: v2(133.47,83.13) 134.42,84.08 136.15,84.08 137.08,85.02 140.64,85.02 141.51,84.15 144.06,84.15 v2(144.49,83.72)
  BOTTOM w0.14: CPU1.AD4 133.47,82.58 v2(133.47,83.13) ; v2(144.49,83.72) 144.71,83.72 145.28,83.15 145.47,83.15 145.66,82.96 v1(145.74,82.96) 145.66,82.87 145.66,82.58 R2046.1
LPSS_UART2_RXD: length 162
  L3 w0.127: v2(183.84,78.29) 183.45,78.68 177.79,78.68 176.95,77.84 174.6,77.84 172.66,79.78 171.46,79.78 170.74,80.51 167.82,80.51 166.69,81.63 164.29,81.63 162.76,80.1 160.07,80.1 159.57,80.6 150.45,80.6 150.05,80.19 144.67,80.19 144.48,80.01 141.42,80.01 140.15,81.27 v2(138.2,81.27) ; v2(160.19,23.53) 163.71,23.53 166.18,21.06 172.18,21.06 172.48,20.76 174.53,20.76 175.59,21.82 175.59,22.39 176.21,23.01 182.12,23.01 182.81,22.31 183.92,22.31 184.12,22.51 v2(184.75,22.51)
  L4 w0.127: v2(183.84,78.29) 184.08,78.05 184.08,74.7 184.38,74.4 184.38,73.65 185.61,72.42 185.61,70.65 186.03,70.23 186.03,69.58 186.56,69.05 186.56,66.15 187.04,65.68 187.04,62.03 186.52,61.51 186.52,58.43 185.34,57.25 185.34,54.49 184.96,54.1 184.96,45.46 184.17,44.67 184.17,43.91 186.43,41.65 186.43,31.46 184.75,29.78 v2(184.75,22.51)
  BOTTOM w0.089: CPU1.AD1 135.97,82.29 136.25,82.01 137.44,82.01
  BOTTOM w0.14: v2(160.19,23.53) 160.19,23.52 158.74,22.08 156.59,22.08 v1(156.54,22.03) 156.54,22.02 152.34,17.83 152.34,14.9 153.45,13.78 153.45,10.39 152.87,9.8 DB2.3 ; R2048.1 138.67,80.8 v2(138.2,81.27) 138.2,81.41 137.61,82.01 137.44,82.01
LPSS_UART2_TXD: length 113.6
  TOP w0.14: v2(152.42,81.22) v1(151.54,80.35) 150.61,79.42 148,79.42 147.08,78.5 147.08,76.58 147.53,76.13 152.55,76.13 153.57,75.11 v2(153.98,75.11)
  L3 w0.127: v2(152.42,81.22) 151.79,81.22 151.72,81.16 150.48,81.16 149.94,80.62 144.55,80.62 144.32,80.39 142,80.39 v2(141.57,80.82)
  L4 w0.127: v2(160.19,22.73) 160.06,22.73 159.6,23.19 159.6,27.41 160.17,27.98 160.17,31.84 159.03,32.98 159.03,37.28 157.95,38.36 157.95,43.23 158.74,44.03 158.74,48.76 158.34,49.16 158.34,52.01 159.09,52.76 159.09,53.99 158.64,54.44 158.64,56.37 158.73,56.46 158.73,58.85 156.86,60.71 156.86,65.28 156.64,65.5 156.64,70.28 155.55,71.37 155.55,73.54 v2(153.98,75.11)
  BOTTOM w0.089: 138.28,82 138.06,82.23 136.28,82.23 136.03,82.48 136.01,82.48 135.9,82.51 135.82,82.55 135.62,82.55 135.45,82.49 135.26,82.49 CPU1.AD2
  BOTTOM w0.14: v2(141.57,80.82) 141.57,81.25 140.75,82.07 139.87,82.07 139.43,81.63 R2049.1 138.66,81.63 138.28,82 ; DB2.2 152.84,9 154,10.16 154,14.01 152.88,15.12 152.88,17.6 156.8,21.52 159,21.52 160.19,22.71 v2(160.19,22.73)
M_A_A0: length 53.6
  TOP w0.216: v2(94.99,31.55) v1(94.99,30.99)
  L3 w0.089: v2(105.53,65.14) 105.95,65.14 106.09,64.99 106.09,62.73 105.45,62.09 105.3,62.09 104.96,61.75
  L3 w0.203: 104.96,61.75 103.15,59.95 103.15,56.43 102.81,56.09 101.93,56.09 98.79,52.95 98.79,52.53 99.34,51.98 99.34,51.64 93.8,46.1 93.8,40.9 92.84,39.93 92.84,39.55 93.16,39.22 93.16,33.37 v2(94.99,31.55)
  BOTTOM w0.089: 106.9,68.13 106.9,68.24 106.8,68.35 106.8,69.3 107.71,70.21 107.71,71.98 107.72,71.99 107.72,72.02 107.93,72.23 107.93,73.09 107.48,73.54 CPU1.AY50
  BOTTOM w0.216: 106.9,68.13 106.9,66.51 v2(105.53,65.14) ; v2(94.99,31.55) 94.75,31.31 DM1.98
M_A_A1: length 53.9
  TOP w0.216: v1(94.16,35.36) 93.85,35.05 v2(93.69,35.05)
  L3 w0.089: v2(105.53,67.09) 105.53,67.17 105.85,67.49 106.1,67.49 106.45,67.15 106.45,62.34 104.27,60.16 104.27,59.79
  L3 w0.203: 104.27,59.79 104.27,54.99 94.92,45.64 94.92,40.43 94.4,39.91 94.4,39.21 94.29,39.1 94.29,35.03 94.15,34.89 93.85,34.89 v2(93.69,35.05)
  BOTTOM w0.089: 106.27,68.05 106.42,68.21 106.42,69.43 106.44,69.45 106.44,69.46 107.26,70.28 107.26,71.92 107.34,72.14 107.37,72.17 CPU1.BB50
  BOTTOM w0.216: 106.27,68.05 106.08,67.87 106.08,67.64 v2(105.53,67.09) ; v2(93.69,35.05) 93.96,35.05 95.4,33.61 95.69,33.61 96.05,33.97 96.05,34.26 94.45,35.86 DM1.97
M_A_A2: length 56.9
  TOP w0.216: v2(91.01,35.02) 91.1,35.02 v1(91.73,35.65)
  L3 w0.089: v2(105.53,67.74) 105.53,67.88 105.4,68.01 105.18,68.01 105.05,67.88 105.05,63.68 105.05,63.68 105.05,63.54 104.61,63.1 104.54,63.1 101.48,60.04 101.48,59.86
  L3 w0.203: 101.48,59.86 101.48,58.01 96.99,53.52 96.99,51.66 92.13,46.8 92.13,41.59 91.36,40.82 91.18,40.82 90.57,40.21 90.57,39.35 91.49,38.43 91.49,35.74 91.48,35.74 91.48,35.05 91.36,34.93 91.11,34.93 v2(91.01,35.02)
  BOTTOM w0.089: CPU1.AY51 106.92,74.15 107.12,74.15 107.21,74.06 107.21,73.04 107.25,72.91 107.25,72.68 107.19,72.41 107.07,72.29 107.07,70.35 106.17,69.45 106.17,68.38 v2(105.53,67.74)
  BOTTOM w0.216: v2(91.01,35.02) 91.01,35.02 91.22,35.23 91.88,35.23 92.08,35.02 92.08,33.52 92.69,32.91 93.93,32.91 94.15,32.69 DM1.96
M_A_A3: length 54.6
  TOP w0.216: v2(93.64,36.44) v1(93.64,37.01)
  L3 w0.089: v2(105.53,65.79) 105.53,65.88 105.91,66.27 105.91,66.82 106.02,66.92 106.17,66.92 106.27,66.82 106.27,62.49 103.71,59.93 103.71,59.8
  L3 w0.203: v2(93.64,36.44) 93.73,36.53 93.73,39.44 93.84,39.55 93.84,40.14 94.36,40.67 94.36,45.87 100.15,51.67 100.15,51.95 99.51,52.59 99.51,52.88 99.8,53.17 100.09,53.17 100.76,52.49 100.98,52.49 101.34,52.85 101.34,53.07 100.66,53.74 100.66,54.03 100.95,54.32 101.24,54.32 101.9,53.66 102.15,53.66 102.47,53.98 102.47,54.23 101.81,54.89 101.81,55.18 102.1,55.47 102.39,55.47 103.03,54.83 103.32,54.83 103.71,55.22 103.71,59.8
  BOTTOM w0.089: CPU1.BA50 107.64,73.11 107.74,73.01 107.74,72.29 107.54,72.09 107.54,72.08 107.54,72.07 107.53,72.07 107.52,72.06 107.52,70.29 106.61,69.38 106.61,69.37 106.6,69.36 106.6,67.81 106.51,67.72
  BOTTOM w0.216: v2(93.64,36.44) 93.85,36.64 DM1.95 ; v2(105.53,65.79) 105.53,65.79 106.51,66.77 106.51,67.72
M_A_A4: length 54.3
  TOP w0.216: v1(91.79,34.17) 91.79,34.1 v2(91.24,33.55)
  L3 w0.089: v2(105.53,63.83) 105.53,63.75 102.04,60.25 102.04,59.8
  L3 w0.203: 102.04,59.8 102.04,57.77 97.67,53.41 97.67,51.55 92.69,46.57 92.69,41.36 91.59,40.26 91.41,40.26 91.13,39.98 91.13,39.58 92.04,38.66 92.04,32.91 91.68,32.55 91.25,32.55 90.84,32.96 90.84,33.15 v2(91.24,33.55)
  BOTTOM w0.089: 104.76,68.34 104.76,69.19 106.15,70.58 CPU1.BB52
  BOTTOM w0.216: DM1.92 92.95,31.84 v2(91.24,33.55) ; 104.76,68.34 104.76,64.6 v2(105.53,63.83)
M_A_A5: length 55.4
  TOP w0.216: v1(93.68,33.13) 93.68,33.14 v2(93.68,33.7)
  L3 w0.089: 104.83,59.75 104.83,60.34 106.62,62.13 106.62,68.13 106.36,68.39 v2(105.53,68.39)
  L3 w0.203: 104.83,59.75 104.83,54.76 95.48,45.41 95.48,39.5 94.85,38.87 94.85,34.63 95.83,33.65 95.83,33.26 95.53,32.96 95.14,32.96 94.4,33.7 v2(93.68,33.7)
  BOTTOM w0.089: v2(105.53,68.39) 105.99,68.85 105.99,69.52 106.85,70.38 106.85,72.34 107.03,72.52 107.08,72.7 107.08,72.88 107.03,73 107.03,73.15 CPU1.BA51
  BOTTOM w0.216: DM1.91 92.65,34.33 93.28,33.7 v2(93.68,33.7)
M_A_A6: length 56.3
  TOP w0.216: v2(88.98,33.09) 89.12,33.22 89.25,33.22 v1(89.44,33.41)
  L3 w0.089: 98.33,58.82 98.54,59.02 98.54,59.61 101.98,63.05 102.77,63.05 103.3,63.58 103.3,68.25 103.5,68.46 v2(104.31,68.46)
  L3 w0.203: 98.33,58.82 90.83,51.31 90.83,49.46 89.33,47.96 89.33,45.86 87.71,44.23 87.71,42.16 87.09,41.55 87.09,38.9 87.8,38.19 87.8,37.21 87.98,37.02 87.98,33.44 88.34,33.09 v2(88.98,33.09)
  BOTTOM w0.089: CPU1.BA52 105.88,72.83 105.88,70.56 104.31,68.99 v2(104.31,68.46)
  BOTTOM w0.216: DM1.90 92.35,31.38 90.56,33.16 90.55,33.16 90.33,33.38 89.48,33.38 89.19,33.09 v2(88.98,33.09)
M_A_A7: length 56.7
  TOP w0.216: v1(90.59,32.45) 90.26,32.78 v2(90.13,32.78)
  L3 w0.089: v2(105.53,64.49) 105.78,64.49 105.91,64.35 105.91,62.87 105.46,62.42 104.92,62.42 104.72,62.22
  L3 w0.203: 104.72,62.22 102.59,60.09 102.59,57 102.24,56.65 101.7,56.65 98.23,53.18 98.23,52.3 98.53,51.99 98.53,51.62 93.24,46.34 93.24,41.13 92.28,40.16 92.28,39.32 92.6,38.99 92.6,32.44 92.11,31.94 91.05,31.94 90.22,32.78 v2(90.13,32.78)
  BOTTOM w0.089: 105.07,68.48 105.07,69.25 106.43,70.61 106.43,73.33 106.54,73.65 106.54,74.12 CPU1.AW52
  BOTTOM w0.216: DM1.86 91.15,31.77 90.33,32.59 90.31,32.59 v2(90.13,32.78) ; 105.07,68.48 105.07,64.94 v2(105.53,64.49)
M_A_A8: length 56.8
  TOP w0.216: v2(91,36.4) 91,36.94 v1(91.29,37.23)
  L3 w0.089: v2(104.31,67.1) 104.31,67.21 104.48,67.39 104.54,67.39 104.65,67.49 104.81,67.49 104.87,67.43 104.87,63.76 104.87,63.75 104.87,63.61 104.54,63.28 104.31,63.28 100.85,59.82 100.85,59.46
  L3 w0.203: 100.85,59.46 100.85,58.17 96.43,53.75 96.43,51.89 96.03,51.5 95.75,51.5 95.11,52.14 94.82,52.14 94.53,51.85 94.53,51.56 95.17,50.92 95.17,50.64 94.89,50.35 94.6,50.35 93.96,50.99 93.67,50.99 93.38,50.7 93.38,50.41 94.02,49.77 94.02,49.49 91.57,47.03 91.57,41.82 91.12,41.38 90.19,41.38 90.01,41.2 90.01,39.12 90.91,38.22 90.91,37.48 90.31,36.88 90.31,36.38 90.47,36.22 90.82,36.22 v2(91,36.4)
  BOTTOM w0.089: CPU1.AY52 106.25,73.68 105.7,73.13 105.7,70.63 103.91,68.84 103.91,67.5 v2(104.31,67.1)
  BOTTOM w0.216: v2(91,36.4) 91.06,36.4 91.64,35.81 91.96,35.81 92.08,35.93 92.08,37.13 92.05,37.16 DM1.89
M_A_A9: length 55
  TOP w0.216: v1(89.02,35.01) 88.94,34.93 v2(88.94,34.45)
  L3 w0.089: v2(104.31,65.15) 104.31,65.22 103.77,65.75 103.65,65.75 103.56,65.66 103.56,63.56 102.72,62.73 102.12,62.73 99.52,60.13
  L3 w0.203: 99.52,60.13 99.1,59.7 99.1,58.79 91.49,51.18 91.49,49.94 91.6,49.82 91.6,49.44 89.89,47.73 89.89,45.23 89.52,44.86 89.12,44.86 88.27,44 88.27,41.93 87.65,41.31 87.65,39.13 88.36,38.43 88.36,38.2 88.54,38.01 88.54,34.85 v2(88.94,34.45)
  BOTTOM w0.089: CPU1.BB54 105.12,70.61 103.51,69 103.51,66.65 103.67,66.49 103.67,66.35
  BOTTOM w0.216: 103.67,66.35 103.67,65.78 v2(104.31,65.15) ; v2(88.94,34.45) 89.24,34.45 89.44,34.24 89.44,34.15 89.64,33.95 90.12,33.95 90.32,34.15 90.32,36.55 90.85,37.08 DM1.85
M_A_A10: length 55.5
  TOP w0.216: v1(97.46,37.28) 97.65,37.09 v2(97.65,36.71)
  L3 w0.089: 108.22,60.73 108.61,61.11 108.61,69.8 106.18,72.23 106.18,73.87 106.19,73.88 106.19,74.63 106.35,74.8 107.21,74.8 107.48,75.07 107.48,75.78 107.37,75.89 v2(106.97,75.89)
  L3 w0.203: 108.22,60.73 107.41,59.92 107.41,53.76 100.46,46.81 100.46,46.57 100.79,46.24 101.03,46.24 102.34,47.54 102.62,47.54 102.91,47.26 102.91,46.97 100.81,44.87 99.71,44.87 99.17,44.87 98.94,44.64 98.94,39.3 97.38,37.73 97.38,37.2 97.57,37 97.57,36.78 v2(97.65,36.71)
  BOTTOM w0.216: CPU1.AT50 107.11,75.89 v2(106.97,75.89) ; DM1.107 97.45,37.34 97.25,37.13 97.25,36.87 97.41,36.71 v2(97.65,36.71)
M_A_A11: length 54.5
  TOP w0.216: v1(90.14,30.87) 90.14,30.87 v2(90.14,31.44)
  L3 w0.089: 99.65,59.65 102.37,62.36 102.68,62.36 103.85,63.53 103.85,64.6 103.96,64.7 104.1,64.7 v2(104.3,64.5)
  L3 w0.203: v2(90.14,31.44) 89.96,31.62 89.92,31.62 89.55,31.99 89.55,33.04 90.03,33.52 90.03,34.73 89.79,34.97 89.34,34.97 89.1,35.21 89.1,38.24 88.91,38.43 88.91,38.66 88.21,39.36 88.21,41.08 88.82,41.7 88.82,43.77 89.35,44.3 90.14,44.3 90.45,44.61 90.45,47.49 92.3,49.34 92.3,49.92 92.05,50.17 92.05,50.95 99.65,58.55 99.65,59.65
  BOTTOM w0.089: CPU1.BA54 104.97,72.95 104.85,72.48 104.85,70.59 103.33,69.07 103.33,66.36
  BOTTOM w0.216: 103.33,66.36 103.33,65.47 v2(104.3,64.5) ; DM1.84 90.55,31.03 v2(90.14,31.44)
M_A_A12: length 55.2
  TOP w0.216: v2(89.75,36.58) 89.23,36.58 v1(89.18,36.63)
  L3 w0.089: v2(104.31,66.45) 104.43,66.57 104.56,66.57 104.69,66.44 104.69,64.12 104.69,64.12 104.69,63.68 104.46,63.46 104.03,63.46 100.36,59.79
  L3 w0.203: v2(89.75,36.58) 89.67,36.65 89.67,37.41 89.79,37.53 90.11,37.53 90.3,37.72 90.3,38.04 89.45,38.88 89.45,39.03 88.77,39.71 88.77,40.85 89.38,41.47 89.38,43.54 89.59,43.74 89.99,43.74 90.2,43.54 90.2,42.18 90.4,41.98 90.81,41.98 91.01,42.18 91.01,47.26 93.26,49.51 93.26,49.75 92.61,50.4 92.61,50.72 94.45,52.56 94.6,52.71 95.54,52.71 95.86,53.04 95.86,53.97 100.21,58.32 100.21,58.79 100.21,59.64 100.36,59.79
  BOTTOM w0.089: CPU1.AW54 105.22,74.41 105.33,74.3 105.33,73.33 105.47,73.19 105.47,70.68 103.7,68.91 103.7,66.78 104.03,66.45 v2(104.31,66.45)
  BOTTOM w0.216: v2(89.75,36.58) 89.75,36.85 90.25,37.35 DM1.83
M_A_A13: length 58
  TOP w0.216: v1(100.8,37.28) 100.8,37.28 v2(100.8,36.71)
  L3 w0.203: v2(100.8,36.71) 100.8,37.19 102.95,39.34 102.95,39.79 102.68,40.06 102.68,40.37 104.76,42.45 104.76,42.7 104.45,43.01 104.17,43.01 102.94,41.77 102.57,41.77 102.38,41.96 102.38,42.37 110.41,50.39 110.41,50.68 110.12,50.97 109.84,50.97 108.05,49.18 107.76,49.18 107.47,49.47 107.47,49.76 110.41,52.7 110.41,63.45 111.04,64.07 111.04,70.18 110.24,70.98 110.24,71.83 109.86,72.21 109.86,72.8 110.24,73.19 110.24,73.58 109.74,74.09 v2(109.74,75.25)
  BOTTOM w0.216: v2(109.74,75.25) 109.67,75.18 109.45,75.18 109.28,75.35 CPU1.AU46 ; DM1.119 101.05,36.82 100.94,36.71 v2(100.8,36.71)
M_A_A14: length 55.6
  TOP w0.216: v1(87.67,32.84) 87.53,32.7 v2(87.12,32.7)
  L3 w0.089: 96.2,59.92 97.89,61.62 98.78,61.62 100.56,63.39 100.56,64.24 v2(102.72,66.41)
  L3 w0.203: 96.2,59.92 86.95,50.67 86.95,46.69 84.85,44.6 84.85,37.97 85.56,37.27 85.56,35.08 86.11,34.53 86.11,33.71 v2(87.12,32.7)
  BOTTOM w0.089: v2(102.72,66.41) 103.13,66.82 103.13,69.13 104.67,70.67 104.67,72.5 104.76,72.86 104.76,73.21 CPU1.AY54
  BOTTOM w0.216: v2(87.12,32.7) 87.97,32.7 89.35,31.32 DM1.80
M_A_A15: length 55.9
  TOP w0.216: v2(87.12,31.38) 87.12,30.81 v1(87.12,30.81)
  L3 w0.089: 95.06,59.57 97.65,62.17 98.88,62.17 100.13,63.42 100.13,65.12 v2(102.72,67.72)
  L3 w0.203: v2(87.12,31.38) 87.1,31.38 85.55,32.93 85.55,34.16 85,34.71 85,37.04 84.3,37.74 84.3,45.06 86.29,47.06 86.29,50.81 95.06,59.57
  BOTTOM w0.089: v2(102.72,67.72) 102.33,68.11 102.33,68.6 102.59,68.86 102.59,69.16 104.24,70.81 104.24,72.56 104.2,72.69 104.2,72.86 104.25,73.05 104.25,73.15 CPU1.BA55
  BOTTOM w0.216: DM1.78 88.75,30.77 88.14,31.38 v2(87.12,31.38)
M_A_BS0: length 54.6
  TOP w0.216: v1(98.11,35.07) 97.79,35.39 v2(97.65,35.39)
  L3 w0.089: 108.11,61.26 108.42,61.57 108.42,69.64 105.37,72.68 105.37,74.38 106.24,75.25 v2(106.99,75.25)
  L3 w0.203: v2(97.65,35.39) 97.41,35.15 97.12,35.15 97.02,35.26 97.02,36.77 96.82,36.97 96.82,37.96 98.38,39.53 98.38,45.53 98.83,45.97 99.11,45.97 99.66,45.43 99.94,45.43 100.23,45.71 100.23,46 99.69,46.55 99.69,46.83 106.85,54 106.85,60 108.11,61.26
  BOTTOM w0.216: DM1.109 98.05,37.16 98.13,37.07 98.13,35.32 98.02,35.2 97.76,35.2 97.65,35.32 v2(97.65,35.39) ; CPU1.AU52 106.86,75.25 v2(106.99,75.25)
M_A_BS1: length 56.5
  TOP w0.216: v1(99.72,35.57) 99.41,35.26 v2(99.24,35.26)
  L3 w0.203: v2(107.91,76.55) 108.23,76.55 108.81,75.96 108.81,73.38 108.36,72.93 108.36,71.44 109.72,70.08 109.72,64.3 109.46,64.04 109.46,59.77 109.09,59.4 109.09,53.06 106.26,50.23 106.26,47.93 101.43,43.1 100.82,43.1 100.62,42.9 100.62,41.14 101.29,40.47 101.29,39.26 99.68,37.65 99.68,36.12 99.7,36.1 99.7,35.27 99.58,35.16 99.34,35.16 v2(99.24,35.26)
  BOTTOM w0.216: DM1.108 97.75,32.94 98.22,33.41 99.41,33.41 99.79,33.78 99.79,34.19 99.78,34.2 99.78,34.82 99.35,35.26 v2(99.24,35.26) ; v2(107.91,76.55) 108.04,76.55 CPU1.AT48
M_A_BS2: length 55.5
  TOP w0.216: v1(87.5,37.26) 87.5,36.79 v2(87.4,36.69)
  L3 w0.089: 97.83,59.11 98.09,59.36 98.09,59.57 101.94,63.42 102.88,63.42 103.11,63.64 103.11,65.68 103.04,65.76 v2(102.72,65.76)
  L3 w0.203: 97.83,59.11 90.37,51.64 89.66,50.93 89.66,50.59 90.26,49.99 90.26,49.7 89.97,49.42 89.68,49.42 89.08,50.01 88.9,50.01 88.73,49.85 88.73,46.05 87.15,44.46 87.15,42.39 86.53,41.78 86.53,38.67 87.24,37.96 87.24,36.86 v2(87.4,36.69)
  BOTTOM w0.089: CPU1.AY55 104.07,73.48 104.07,73.08 104.02,72.88 104.02,72.67 104.06,72.54 104.06,70.89 102.38,69.21 102.38,68.99 102.02,68.63 102.02,68.08
  BOTTOM w0.216: v2(102.72,65.76) 102.37,65.76 102.02,66.1 102.02,68.08 ; v2(87.4,36.69) 87.44,36.73 87.84,36.73 88.04,36.53 88.04,35.33 88.25,35.13 88.85,35.13 89.05,35.33 DM1.79
M_A_CAS#: length 55.5
  TOP w0.216: v2(99.19,36.56) 99.19,36.56 v1(99.19,37.13)
  L3 w0.203: v2(99.19,36.56) 99.09,36.45 98.88,36.45 98.76,36.57 98.76,37.54 100.72,39.5 100.72,40.25 100.53,40.44 100.23,40.44 100.06,40.61 100.06,43.36 100.36,43.66 101.2,43.66 105.7,48.16 105.7,48.45 105.42,48.74 105.13,48.74 104.24,47.85 103.95,47.85 103.66,48.14 103.66,48.42 108.53,53.29 108.53,59.63 109.08,60.19 109.08,64.28 109.25,64.45 109.25,69.93 107.33,71.86 107.33,73.19 107.59,73.45 108.14,73.45 108.37,73.68 108.37,75.64 108.11,75.9 v2(107.91,75.9)
  BOTTOM w0.216: v2(107.91,75.9) 108.04,75.9 CPU1.AU48 ; DM1.115 99.85,37.14 100.31,36.68 100.31,36.55 99.92,36.15 99.76,36.15 99.35,36.56 v2(99.19,36.56)
M_A_CKE0: length 53.8
  TOP w0.216: v2(87.4,35.37) 87.74,35.37 v1(87.93,35.56)
  L3 w0.089: v2(102.72,63.8) 102.49,64.04 102.18,64.04 101.85,63.71 101.65,63.71 97.59,59.65
  L3 w0.203: v2(87.4,35.37) 87.22,35.19 87.03,35.19 86.68,35.54 86.68,37.73 85.97,38.44 85.97,42.09 86.59,42.71 86.59,43.15 86.05,43.69 86.05,44.15 88.18,46.28 88.18,50.24 97.59,59.65
  BOTTOM w0.089: CPU1.BA56 103.69,73 103.69,72.89 103.61,72.72 103.53,72.54 103.53,72.42 103.53,70.87 102.03,69.37 102.03,69.29 101.82,69.09
  BOTTOM w0.216: DM1.73 87.25,37.37 86.94,37.06 86.49,37.06 86.21,36.77 86.21,35.48 86.5,35.18 87.21,35.18 v2(87.4,35.37) ; 101.82,69.09 101.41,68.68 101.41,65.11 v2(102.72,63.8)
M_A_CKE1: length 54.2
  TOP w0.216: v2(87.4,34.05) 87.19,34.05 v1(86.91,34.33)
  L3 w0.089: 97.28,60.14 98.33,61.18 98.73,61.18 100.91,63.36 100.91,63.95 101.45,64.49 102.69,64.49 v2(102.72,64.45)
  L3 w0.203: 97.28,60.14 87.62,50.47 87.62,46.51 85.41,44.31 85.41,38.21 86.12,37.5 86.12,35.31 87.2,34.23 87.22,34.23 v2(87.4,34.05)
  BOTTOM w0.089: CPU1.BB56 103.8,70.88 102.2,69.28 102.2,69.1 101.72,68.61 101.72,68.22
  BOTTOM w0.216: DM1.74 86.61,30.91 86.61,33.31 87.35,34.05 v2(87.4,34.05) ; 101.72,68.22 101.72,65.46 v2(102.72,64.45)
M_A_CLK0: length 55.1
  TOP w0.127: v2(96.52,35.53) 96.06,35.53 v1(95.96,35.43)
  L3 w0.089: v2(105.19,75.86) 104.68,75.35 104.68,72.74 108.05,69.37 108.05,62.75 107.61,62.32 107.61,61.99 107.59,61.96 107.59,61.94
  L3 w0.114: 107.59,61.94 107.59,61.66 106.09,60.16 106.09,54.3 96.99,45.2 96.99,44.65 97.21,44.43 97.51,44.43 97.64,44.3 97.64,44.09 97.51,43.96 97.04,43.96 96.81,43.72 96.81,43.27 97.05,43.03 97.47,43.03 97.58,42.92 97.58,42.67 97.47,42.56 97.05,42.56 96.79,42.3 96.79,41.87 97.03,41.63 97.46,41.63 97.58,41.51 97.58,41.26 97.49,41.16 97.05,41.16 96.8,40.91 96.8,40.32 97.15,39.96 97.15,39.35 96.06,38.26 96.06,35.99 v2(96.52,35.53)
  BOTTOM w0.127: v2(105.19,75.86) 105.55,76.22 CPU1.AT53 ; v2(96.52,35.53) 96.31,35.74 96.07,35.74 95.55,36.26 95.55,37.03 95.65,37.12 DM1.101
M_A_CLK1: length 54.9
  TOP w0.127: v2(96.55,32.33) 96.71,32.33 v1(97.02,32.65)
  L3 w0.114: v2(96.55,32.33) 96.89,32.33 97.14,32.59 97.14,33.06 95.36,34.84 95.36,38.66 96.04,39.34 96.04,45.24 105.38,54.58 105.38,60.32 106.93,61.87 106.93,69 103.76,72.18 103.76,75.34 v2(104.3,75.88)
  BOTTOM w0.127: CPU1.AT55 104.64,76.22 v2(104.3,75.88) ; v2(96.55,32.33) 95.82,31.6 95.82,31.1 95.95,30.97 DM1.102
M_A_CLK#0: length 55.1
  TOP w0.127: v1(96.03,36.81) 96.34,36.51 v2(96.51,36.51)
  L3 w0.089: 107.82,61.94 107.82,61.96 107.79,61.99 107.79,62.24 108.23,62.67 108.23,69.44 104.86,72.81 104.86,75.13 104.95,75.22 v2(105.19,75.22)
  L3 w0.114: v2(96.51,36.51) 96.39,36.51 96.29,36.61 96.29,38.17 97.38,39.26 97.38,40.06 97.03,40.41 97.03,40.82 97.15,40.94 97.58,40.94 97.81,41.16 97.81,41.61 97.55,41.86 97.12,41.86 97.02,41.97 97.02,42.21 97.15,42.33 97.56,42.33 97.81,42.58 97.81,43.02 97.56,43.26 97.14,43.26 97.04,43.37 97.04,43.63 97.14,43.73 97.61,43.73 97.87,43.99 97.87,44.4 97.61,44.66 97.3,44.66 97.21,44.74 97.21,45.1 106.32,54.21 106.32,60.06 107.82,61.56 107.82,61.94
  BOTTOM w0.127: CPU1.AU53 105.72,75.48 105.72,75.24 105.57,75.09 105.33,75.09 v2(105.19,75.22) ; DM1.103 96.25,37.1 96.19,37.04 95.91,37.04 95.79,36.93 95.79,36.36 96.17,35.98 96.9,35.98 97.02,36.1 97.02,36.35 96.85,36.51 v2(96.51,36.51)
M_A_CLK#1: length 54.9
  TOP w0.127: v1(96.55,31.11) 96.55,31.11 v2(96.55,31.67)
  L3 w0.114: v2(104.29,75.25) 104.12,75.25 103.98,75.11 103.98,72.27 107.16,69.1 107.16,61.77 105.61,60.22 105.61,54.49 96.27,45.15 96.27,39.24 95.59,38.56 95.59,34.94 97.37,33.16 97.37,32.49 v2(96.55,31.67)
  BOTTOM w0.127: CPU1.AU55 104.71,75.3 104.58,75.17 104.36,75.17 v2(104.29,75.25) ; v2(96.55,31.67) 96.47,31.75 96.31,31.75 96.06,31.5 96.06,31.2 96.17,31.09 96.47,31.09 96.55,31.01 DM1.104
M_A_CS#0: length 57.9
  TOP w0.216: v1(101.25,34.96) 100.88,35.33 v2(100.82,35.33)
  L3 w0.203: v2(100.82,35.33) 100.94,35.22 101.23,35.22 101.34,35.33 101.34,36.46 101.36,36.48 101.36,36.96 103.51,39.11 103.51,40.4 106.33,43.22 106.33,43.51 106.04,43.8 105.75,43.8 105.25,43.3 104.97,43.3 104.68,43.58 104.68,43.87 107.8,46.99 110.97,50.17 110.97,50.93 110.59,51.31 110.59,51.99 110.97,52.37 110.97,63.16 111.37,63.55 111.37,70.4 110.67,71.1 110.67,72.67 111.09,73.1 111.09,74.3 110.69,74.7 v2(110.69,75.24)
  BOTTOM w0.216: CPU1.AU45 110.53,75.24 v2(110.69,75.24) ; DM1.114 99.55,32.76 99.66,32.87 100.26,32.87 100.54,33.16 101.34,33.16 101.46,33.27 101.46,33.91 101.34,34.02 100.46,34.02 100.36,34.12 100.36,34.43 100.35,34.43 100.35,35.19 100.49,35.33 v2(100.82,35.33)
M_A_CS#1: length 59.8
  TOP w0.216: v1(102.89,35.62) 102.6,35.34 v2(102.38,35.34)
  L3 w0.089: v2(110.64,75.88) 110.95,75.88 111.18,75.65 111.18,74.98 111.53,74.63 111.53,72.42 111.04,71.92 111.04,71.16 111.67,70.52 111.67,69.79 112.22,69.24 112.22,63.66 111.96,63.4
  L3 w0.203: v2(102.38,35.34) 102.38,35.27 102.27,35.16 102.01,35.16 101.9,35.27 101.9,36.23 101.92,36.25 101.92,36.73 104.07,38.88 104.07,40.17 108.84,44.94 108.84,45.23 108.55,45.52 108.26,45.52 106.84,44.09 106.55,44.09 106.26,44.38 106.26,44.67 111.53,49.93 111.53,62.97 111.96,63.4
  BOTTOM w0.216: CPU1.AU43 110.8,75.88 v2(110.64,75.88) ; v2(102.38,35.34) 102.47,35.34 102.87,34.95 102.87,34.34 102.71,34.19 102.05,34.19 101.41,34.83 101.41,35.89 101.65,36.13 DM1.121
M_A_DIMA_ODT0: length 57.9
  TOP w0.14: v2(102.87,33.41) 102.87,33.97 v1(102.87,33.97)
  L3 w0.089: v2(110.65,76.55) 110.82,76.55 111.96,75.4 111.96,74.22 111.91,74.17 111.91,69.81 112.49,69.23 112.49,63.25 112.24,63
  L3 w0.127: v2(102.87,33.41) 101.65,32.2 101.37,32.2 101.15,32.42 101.15,32.71 102.98,34.54 102.98,37.05 104.59,38.66 104.59,39.96 109.36,44.73 109.36,47.03 112.05,49.72 112.05,62.81 112.24,63
  BOTTOM w0.14: v2(110.65,76.55) 110.33,76.22 CPU1.AT45 ; v2(102.87,33.41) 102.72,33.41 100.15,30.84 DM1.116
M_A_DIMA_ODT1: length 59
  TOP w0.14: v2(102.87,32.09) 103.08,32.09 v1(103.37,31.8)
  L3 w0.089: v2(111.54,76.48) 111.54,76.24 112.18,75.6 112.18,69.81 112.75,69.25 112.75,62.89 112.69,62.84
  L3 w0.127: 112.69,62.84 112.44,62.59 112.44,49.55 109.75,46.86 109.75,44.56 105.03,39.84 105.03,38.55 103.42,36.94 103.42,30.44 103.25,30.27 101.82,30.27 101.53,30.56 101.53,31.11 102.51,32.09 v2(102.87,32.09)
  BOTTOM w0.14: v2(102.87,32.09) 102.39,32.09 101.35,31.06 DM1.120 ; v2(111.54,76.48) 111.28,76.22 CPU1.AT43
M_A_DQ0: length 76.8
  TOP w0.14: v1(66.81,34.2) 66.81,34.21 v2(66.81,34.77)
  L3 w0.127: v2(66.81,34.77) 67.64,35.61 67.64,38.62 68.37,39.34 68.37,59.06 72.45,63.15 72.45,63.37 72.3,63.52 72.08,63.52 69.16,60.61 68.94,60.61 68.79,60.77 68.79,60.99 76.44,68.64 76.44,69.52 77.06,70.15 77.95,70.15 85.87,78.07 87.65,78.07 v2(88.1,78.52)
  BOTTOM w0.14: DM1.16 67.75,30.95 68,31.2 68,32.26 67.47,32.8 67.47,34.11 v2(66.81,34.77) ; v2(88.1,78.52) 88.79,79.22 92.69,79.22 93.12,79.65 94.72,79.65 CPU1.AL71
M_A_DQ1: length 77.1
  TOP w0.14: v1(64.89,36.36) 65.23,36.03 v2(65.35,36.03)
  L3 w0.127: v2(65.35,36.03) 64.91,36.47 64.91,37.35 65.23,37.67 65.23,38.79 65.23,38.79 65.23,41.89 65.23,41.89 65.23,42.63 65.36,42.75 66.56,42.75 66.69,42.88 66.69,43.16 66.56,43.29 65.41,43.29 65.25,43.44 65.25,43.67 65.41,43.82 66.56,43.82 66.69,43.95 66.69,44.23 66.56,44.36 65.41,44.36 65.26,44.51 65.26,44.73 65.41,44.89 66.56,44.89 66.69,45.02 66.69,45.3 66.56,45.42 65.44,45.42 65.29,45.58 65.29,45.8 65.44,45.96 66.56,45.96 66.69,46.08 66.69,62.13 84.39,79.83 90.69,79.83 v2(92,78.52)
  BOTTOM w0.089: 94.48,79.06 94.73,78.81 95.17,78.81 95.32,78.88 95.49,78.88 95.63,78.83 95.83,78.83 96.04,78.9 96.38,78.9 96.89,79.28 CPU1.AL68
  BOTTOM w0.14: DM1.7 65.05,37.27 64.86,37.08 64.86,36.52 v2(65.35,36.03) ; v2(92,78.52) 92.15,78.67 92.8,78.67 93.31,79.19 94.34,79.19 94.48,79.06
M_A_DQ2: length 77.7
  TOP w0.14: v2(64.35,32.86) 64.24,32.86 v1(63.75,32.36)
  L3 w0.127: v2(97.9,78.57) 96.56,78.57 93.55,81.58 84.47,81.58 65.39,62.5 65.39,50.4 64.02,49.03 64.02,38.13 63.54,37.65 63.54,35.28 63.89,34.92 63.89,33.33 v2(64.35,32.86)
  BOTTOM w0.14: CPU1.AN68 97.27,78.29 97.62,78.29 v2(97.9,78.57) ; DM1.4 64.15,31.2 63.68,31.67 63.68,32.19 v2(64.35,32.86)
M_A_DQ3: length 77
  TOP w0.14: v1(63.51,35.85) 63.79,36.14 v2(64,36.14)
  L3 w0.127: v2(92.5,76.97) 92.92,77.38 92.92,79.8 91.53,81.18 84.63,81.18 65.84,62.39 65.84,49.35 65.71,49.23 64.84,49.23 64.71,49.09 64.71,48.81 64.83,48.69 65.71,48.69 65.84,48.57 65.84,48.29 65.71,48.16 64.84,48.16 64.71,48.03 64.71,47.75 64.83,47.63 65.71,47.63 65.84,47.5 65.84,47.22 65.71,47.09 65.07,47.09 64.41,46.43 64.41,37.97 64.12,37.68 64.12,36.24 64.02,36.14 v2(64,36.14)
  BOTTOM w0.14: v2(64,36.14) 64.45,36.59 DM1.5 ; CPU1.AN69 96.32,78.05 95.69,77.43 94.62,77.43 94.56,77.48 93.73,77.48 93.21,76.97 v2(92.5,76.97)
M_A_DQ4: length 77.5
  TOP w0.14: v2(66.81,36.04) 66.97,36.04 v1(67.28,35.73)
  L3 w0.127: v2(86.8,78.52) 85.72,78.52 84.55,77.35 84.37,77.35 84.28,77.44 84.06,77.44 83.9,77.29 83.9,77.06 84,76.97 84,76.79 83.8,76.6 83.62,76.6 83.52,76.69 83.3,76.69 83.14,76.54 83.14,76.32 83.24,76.22 83.24,76.04 83.04,75.84 82.86,75.84 82.75,75.96 82.57,75.96 82.37,75.76 82.37,75.58 82.49,75.46 82.49,75.28 82.29,75.09 82.11,75.09 81.99,75.2 81.81,75.2 81.61,75.01 81.61,74.83 81.73,74.71 81.73,74.53 81.53,74.33 81.35,74.33 81.24,74.45 81.06,74.45 80.86,74.25 80.86,74.07 80.98,73.95 80.98,73.77 80.78,73.58 80.6,73.58 80.48,73.69 80.3,73.69 80.1,73.5 80.1,73.32 80.22,73.2 80.22,73.02 80.02,72.82 79.84,72.82 79.73,72.94 79.55,72.94 79.35,72.74 79.35,72.56 79.47,72.44 79.47,72.26 79.27,72.07 79.09,72.07 78.97,72.18 78.79,72.18 78.59,71.99 78.59,71.81 78.71,71.69 78.71,71.51 78.51,71.31 78.33,71.31 78.22,71.43 78.04,71.43 77.84,71.23 77.84,71.05 77.96,70.93 77.96,70.75 77.74,70.54 76.9,70.54 76.04,69.69 76.04,68.84 75.66,68.46 75.48,68.46 75.27,68.67 75.1,68.67 74.9,68.47 74.9,68.29 75.1,68.08 75.1,67.9 74.91,67.71 74.73,67.71 74.52,67.91 74.34,67.91 74.14,67.71 74.14,67.54 74.35,67.33 74.35,67.15 74.15,66.95 73.97,66.95 73.77,67.16 73.59,67.16 73.39,66.96 73.39,66.78 73.59,66.57 73.59,66.39 73.4,66.2 73.22,66.2 73.01,66.4 72.83,66.4 72.63,66.21 72.63,66.03 72.84,65.82 72.84,65.64 72.64,65.44 72.46,65.44 72.26,65.65 72.08,65.65 71.88,65.45 71.88,65.27 72.09,65.06 72.09,64.88 71.89,64.69 71.71,64.69 71.5,64.89 71.32,64.89 71.12,64.7 71.12,64.52 71.33,64.31 71.33,64.13 71.13,63.93 70.95,63.93 70.75,64.14 70.57,64.14 70.37,63.94 70.37,63.76 70.58,63.55 70.58,63.37 70.38,63.18 70.2,63.18 69.99,63.38 69.81,63.38 69.61,63.19 69.61,63.01 69.82,62.8 69.82,62.62 69.62,62.42 69.44,62.42 69.24,62.63 69.06,62.63 68.86,62.43 68.86,62.25 69.07,62.04 69.07,61.86 68.87,61.67 68.69,61.67 68.48,61.87 68.3,61.87 68.1,61.68 68.1,61.5 68.31,61.29 68.31,61.11 67.97,60.77 67.97,39.51 67.25,38.79 67.25,36.49 67.05,36.29 67.05,36.28 v2(66.81,36.04)
  BOTTOM w0.14: v2(86.8,78.52) 87.42,79.15 88.31,79.15 88.63,79.46 92.62,79.46 93.03,79.88 95.03,79.88 95.25,79.66 95.36,79.66 CPU1.AL70 ; v2(66.81,36.04) 66.93,36.04 67.45,36.56 DM1.15
