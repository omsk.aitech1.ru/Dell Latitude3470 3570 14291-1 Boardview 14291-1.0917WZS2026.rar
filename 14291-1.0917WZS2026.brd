# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
5V_HDD_S0:
  vias: v3(180.4,31.39) v3(183.27,31.49) v3(184.13,31.76)
5V_HDMI_R_S0:
  vias: v1(21.89,71.47)
5V_HDMI_S0:
  vias: v1(16.44,72.37) v3(18.4,71.44)
5V_PWR_2: length 4.2
  TOP w0.203: PU4503.13 39.14,52.51 39.53,52.12
  TOP w0.508: v1(41.31,51.28) PC4524.1 39.59,52.06 39.53,52.12
5V_S0: length 390
  TOP w0.305: 197.68,77.21 197.68,77.01 196.18,75.52 VGABD1.1
  TOP w0.508: R6512.2 50.6,73.46 50.27,73.13 v3(49.85,73.13) ; 197.68,77.21 198.49,78.02 198.49,79.55 199.65,80.7 v2(199.65,83.47) ; R9202.2 179.11,123.82 179.11,122.5 v2(178.93,122.32)
  TOP w0.762: v3(198.57,99.65) 198.57,100.2 197.33,101.44 197.33,107.37 196.93,107.78 v3(196.5,107.78) 196.29,107.56 R6504.1 ; v3(19.81,27.7) 19.81,27.45 R2703.2
  L3 w1.016: v3(49.61,29.68) 50.38,29.68 50.99,30.28 57.89,30.28 v3(58.44,30.83) ; v3(83.62,144.69) 86.07,142.24 86.07,136.33 88.41,133.99 88.41,127.36 91.16,124.61 91.16,120.24 92.05,119.35 v3(93.02,119.35)
  L4 w0.508: v2(175.75,93.14) 175.75,93.41 175.76,93.41 175.76,95.01 175.85,95.1 175.85,95.15 176.22,95.52 176.27,95.52 176.5,95.76 176.96,95.76 178.09,96.88 178.09,102.45 178.72,103.08 178.72,108.75 177.49,109.98 177.49,117.38 175.87,119 v2(175.87,123.21)
  L4 w1.016: v3(58.44,30.83) 58.52,30.76 61.89,30.76 63.31,29.33 64.51,29.33 71.31,22.53 71.31,19.26 72.31,18.27 72.31,18.27 72.44,18.14 73.55,18.14 74.49,17.2 77.19,17.2 78.66,15.73 87.73,15.73 89,14.46 v3(89,13.9)
  L4 w1.27: v3(19.81,27.7) 18.39,29.12 18.39,31.09 17.04,32.44 17.04,46.26 14.7,48.59 14.7,54.51 13.58,55.63 13.58,66.65 12.86,67.37 12.86,74.06 12.95,74.15
  BOTTOM w0.203: U8301.4 v3(171.31,135.15)
  BOTTOM w0.508: v2(175.75,93.14) 175.25,93.14 R6705.1 ; PR8223.1 207.1,103.56 206.56,103.02 206.56,102.4 204.85,100.69 202.7,100.69 201.66,99.65 v3(198.57,99.65)
  BOTTOM w0.635: C2611.1 96.97,139.9 C2605.1 96.91,138.89 FAN261.2
  BOTTOM w0.762: v3(93.02,119.35) 93.02,119.26 88.08,114.32 88.08,109.81 86.01,107.74 86.01,105.85 84.82,104.66 84.82,102.69 80.72,98.58 80.72,94.68 69.6,83.56 65.12,83.56 62.64,81.08 59.6,81.08 53.42,74.9 53.42,74.62 52.54,73.74 50.46,73.74 v3(49.85,73.13)
  BOTTOM w1.016: v3(196.5,107.78) v1(196.5,105.9) 196.5,101.23 196.46,101.19 196.07,100.8 196.07,97.5 198.39,95.18 198.39,90.36 199.65,89.11 v2(199.65,83.47) 200.43,82.69 200.43,70.16 199.66,69.4 199.66,64.33 193.21,57.88 193.21,47.82 199.26,41.77 v3(199.26,34.57) ; R5527.1 75.31,155.83 76.08,155.06 78.3,155.06 79.55,153.82 79.55,150.39 81.53,148.41 81.53,146.79 v3(83.62,144.69) 95.09,144.69 v1(96,143.78) 96.08,143.7 96.08,140.79 C2611.1
  vias: v1(23.82,77.9) v1(25.87,72.75) v1(37.52,11) v1(42.93,27.72) v1(47.48,73.37) v1(89.2,11.46) v3(12.47,75.44) v3(13.51,75.42) v3(24.25,72.78) v3(29.08,28.36) v3(29.92,28.36) v3(33.56,24.82) v3(34.4,24.82) v3(37.78,14.35) v3(37.75,13.51) v3(38.61,14.35) v3(38.59,13.51) v3(39.87,27.08) v3(39.87,26.19) v3(41.27,27.08) v3(41.27,26.19) v3(74.49,2.57) v3(75.33,2.57) v3(178.52,35.29) v3(179.29,35.63) v3(179.85,34.99) v3(199.24,32.6) v3(199.26,33.53)
5V_S5: length 266.9
  TOP w0.203: PU5101.12 50.03,21.85 50.4,21.48 ; U4001.4 v3(37.84,33.3)
  TOP w0.305: PC5001.1 133.27,138.86 133.4,138.73 PU5001.4
  TOP w0.508: v2(125.98,126.24) 126.43,126.69 PC4707.1 PR4702.2 127.1,127.73 v1(127.1,129.04) 127.1,129.54 127.55,130 v2(127.55,130.61) ; v2(114.25,130.68) 114.25,129.75 114.78,129.22 v2(114.78,129.01) v1(114.14,128.37) 113.67,127.9 PR4803.2 PC4807.1 113.13,126.05 v2(112.93,125.85) ; R9201.1 180.64,124.49 180.64,123.1 180.38,122.84 v2(180.36,122.84) 180.38,122.82 180.38,122.1 179.68,121.39 179.66,121.39 179.22,120.96 179.22,115.89 v2(178.89,115.55) ; v3(130.86,135.74) 130.88,135.74 131.31,136.17 131.31,138.21 131.96,138.86 PC5001.1 ; v2(49.6,18.68) 49.61,18.7 PC5101.1 50.49,19.29 50.95,19.75 50.95,20.93 50.4,21.48 ; PR4303.1 110.78,175.84 v2(110.21,175.27) ; PR4657.1 109.32,137.27 108.54,138.05 107.07,138.05 v2(105.51,139.61) v1(105.51,140.46) 105.51,141.42 106.33,142.24 PR4603.1
  TOP w1.016: v3(155.72,125.19) 155.58,125.05 v1(153.69,125.05) 150.51,125.05 v3(149.48,124.03)
  L3 w1.016: 116.9,137.48 129.12,137.48 v3(130.86,135.74) 131.14,136.02 131.14,140.04 132.75,141.66 143.5,141.66 146.17,138.99 149.03,138.99 150.98,137.03 150.98,130.13 152.03,129.09 152.03,127.53 151.49,126.99 151.49,125.1 150.42,124.03 v3(149.48,124.03)
  L4 w0.508: v2(95.7,135.59) 95.7,135.82 94.18,137.34 94.18,139.65 93.57,140.26 93.57,143.97 94.18,144.58 94.18,147.25 92.91,148.51 92.91,149.25 89.81,152.35 89.81,158.22 92.18,160.6 92.18,168.63 98.83,175.27 v2(110.21,175.27) ; v2(54.06,34.9) 54.06,34.42 51.39,31.76 49.91,31.76 48.25,30.1 43.62,30.1
  BOTTOM w0.203: PU4801.36 113.34,130.68 v2(114.25,130.68) ; PU4801.3 114.52,128.75 v2(114.78,129.01) ; v2(112.93,125.85) 113.07,125.99 PU4801.7 ; 127.55,130.63 126.97,130.63 126.69,130.91 PU4701.36 ; v2(125.98,126.24) 126.4,126.66 PU4701.7
  BOTTOM w0.381: C4032.1 164.94,120.66 164.21,120.66 163.94,120.93 U4002.4
  BOTTOM w0.406: PU5203.3 147.82,122.19 147.53,122.47 147.53,123.05 148.51,124.03 v3(149.48,124.03) ; 160.45,116.81 160.47,116.79 U4006.4
  BOTTOM w0.508: v2(179.95,111.12) 180.02,111.12 180.03,111.12 Q6403.E 180.91,110.57 181.92,109.57 181.92,107.97 181.52,107.57 Q6404.E ; 38.35,31.32 37.94,30.92 EC9732.1 ; v2(187.29,106.25) 187.83,106.79 187.83,112.84 192.98,117.99 Q6502.E ; DB2.1 150.29,7.44 149.92,7.08 EC9734.1 v2(148.56,6.37) ; v3(130.86,135.74) 130.57,135.74 128.05,133.23 128.04,133.23 127.55,132.74 v1(127.55,132.69) v2(127.55,130.61) ; 160.11,118.32 C4031.1 ; 160.11,118.32 160.11,117.15 160.45,116.81 ; 160.11,118.32 160.11,118.62 v2(159.71,119.02) ; v2(178.89,115.55) 180.94,117.6 Q6405.E ; v2(54.06,34.9) 56.4,32.56 56.4,30.85 55.03,29.48 51.1,29.48 50.01,28.4 50.01,27.19 48.32,25.49 45.5,25.49 44.03,24.02 44.03,22.55 44.32,22.25 45.29,22.25 48.13,19.41 48.13,18.94 48.5,18.57 49.48,18.57 v2(49.6,18.68) ; v2(57.27,9.68) 56.84,10.11 EC9733.1 ; v2(180.36,122.84) 180.03,122.5 Q6401.E ; C4032.1 165.01,119.65 v2(165.13,119.53) ; PU5401.6 171.57,111.23 v2(171.39,111.41) 171.19,111.61 PC5401.1
  vias: v1(39.54,38.56) v1(189.89,39.84) v1(193.1,39.81) v3(38.98,33.56) v3(39.75,34.07) v3(39.75,33.18) v3(40.63,34.07) v3(40.63,33.18) v3(41.52,34.07) v3(41.52,33.18) v3(42.41,34.07) v3(42.41,33.18) v3(43.3,33.68) v3(192.8,38.84) v3(192.8,37.95) v3(193.69,38.84) v3(193.69,37.95)
+3V_1D5V_AVDD: length 4.5
  TOP w0.203: HDA27.40 26.35,12.08 26.31,12.04
  TOP w0.254: 26.31,12.04 25.9,11.63 25.9,10.95
  BOTTOM w0.254: v2(25.62,10.43) 24.31,9.12 R2713.2
  vias: v1(25.93,10.93)
+3V_AVDD: length 26.5
  TOP w0.203: HDA27.9 31.29,16.87 32.57,18.16 C2719.1
  TOP w0.508: C2719.1 32.55,19.31 v2(31.92,18.67) ; R2722.1 30.74,24.45 30.74,26.92 C2716.1 30.84,28.03 31.1,28.29 v1(31.4,28.29) 31.76,28.29 32.02,28.02 R2731.2 32.02,26.19 31.54,25.71 v2(31.54,24.95)
  L4 w0.508: v2(31.54,24.95) 31.3,24.72 31.3,19.29 v2(31.92,18.67) 31.92,15.98 30.63,14.69 30.63,13.25 30.76,13.11 v2(30.78,13.11)
+3VLP: length 4.6
  TOP w0.102: v2(185.56,67.81) 184.82,67.81 184.48,67.47 KBC24.120
  BOTTOM w0.102: R2454.1 186.35,66.3 R2467.2 185.52,67.77 v2(185.56,67.81) 185.24,67.81 v1(185.04,68.01)
+5V_AVDD: length 11.6
  TOP w0.203: HDA27.26 23.78,17.67 23.39,18.06 23.39,19.21 23.21,19.38
  TOP w0.508: v2(20.01,24.46) 20.55,25 R2703.1 ; 23.21,19.38 22.73,19.87 C2711.1 22.09,19.87 21.53,20.43 21.51,20.43 21.37,20.57 C2710.1 20.38,20.57 v2(20.37,20.55)
  BOTTOM w0.508: v2(20.37,20.55) 21.05,21.24 v1(21.05,22.64) 21.05,23.42 v2(20.01,24.46)
+5V_KB_BL: length 14.8
  TOP w0.508: 195.08,93.84 195.59,94.34 195.59,100.58 194.11,102.05 AFTP6248.1 194.29,103.33 195.6,103.33 C6501.1 195.64,106.07 R6504.2
+5V_PVDD: length 2.1
  TOP w0.203: HDA27.41 26.75,12.01 26.7,11.95 26.7,11.85 26.39,11.54 ; 28.75,12.19 HDA27.46
  vias: v1(31.08,8.06) v1(33.4,8.16)
+V1.00A_SIP: length 33.5
  TOP w0.508: R1122.1 136,104.03 v2(136,103.31)
  L4 w0.508: v3(152.38,112.61) 152.65,112.34 154.13,112.34 156.16,110.31 156.16,105.7 158.19,103.68 158.19,101.89 v2(158.2,101.88) ; v2(165.15,93.22) 165.15,94.31 165.16,94.32 165.16,96.36 165.15,96.37 165.15,100.49 v2(163.83,101.81)
  BOTTOM w0.254: v2(124.01,84.2) 124.01,84.2 125.22,84.2 CPU1.Y18 125.89,84.37 125.89,84.18 CPU1.AB17
  BOTTOM w0.508: v2(163.83,101.81) 163.02,102.62 158.89,102.62 158.2,101.94 v2(158.2,101.88)
  vias: v1(141.27,106.07) v3(145.2,105.81) v3(146.05,105.84) v3(153.02,113.24)
+V1.00U_CPU: length 185
  TOP w0.152: 125.75,91.01 125.75,90.33 125.67,90.25
  TOP w0.381: v2(160.23,107.54) 159.01,106.31 157.22,106.31 154.94,104.03 151.35,104.03 150.51,104.87 v2(149.18,104.87) ; v2(141.69,107.72) 140.03,106.07 134.77,106.07 133.35,104.64 133.35,103.14 125.54,95.33 v1(125.54,94.85) 125.54,92.88 ; R2492.1 170.96,64.99 170.71,64.74 169.58,64.74 168.61,65.71 166.09,65.71 v2(165.37,66.42)
  L3 w0.254: v2(175.24,102.16) 177.15,102.16 178.93,100.37 182.41,100.37 184.53,98.25 185.92,98.25 186.79,97.38 186.79,95.25 190.8,91.23 192.48,91.23 194.36,89.34 194.36,88.52 194.91,87.98 194.91,85.67 193.47,84.23 v2(190.6,84.23)
  L3 w0.381: v2(149.18,104.87) 149.42,104.87 149.5,104.95 149.63,104.95 149.68,104.99 153.55,104.99 155.14,106.58 155.14,112.59 v2(154.73,112.99) ; v2(187.64,60.84) 184.04,60.84 180.97,63.9 180.23,63.9 179.21,64.93 178.26,64.93 177.51,65.68 173.94,65.68 173.36,65.1 169.31,65.1 168.59,65.82 165.97,65.82 v2(165.37,66.42) ; v2(174.95,109.32) 174.41,109.32 173.48,108.39 166.66,108.39 166.35,108.7 162.63,108.7 161.47,107.54 v2(160.23,107.54)
  L4 w0.381: v2(175.24,102.16) 173.9,103.5 173.9,108.53 174.68,109.32 v2(174.95,109.32) ; v2(149.18,104.87) 148.18,104.87 147.64,105.41 147.64,105.92 146.25,107.31 142.1,107.31 v2(141.69,107.72)
  BOTTOM w0.254: CPU1.K20 124.28,89.7 123.74,89.7 CPU1.K21 123.4,89.36 v2(123.26,89.36)
  BOTTOM w0.381: v2(160.23,107.54) 161.84,107.54 165.3,111.01 165.31,111.01 165.57,111.26 R4025.2 ; v2(190.6,84.23) 190.6,83.15 189.55,82.1 189.55,79.99 189.22,79.65 189.22,73.23 188.9,72.91 188.9,68.01 188.49,67.59 188.49,66.79 188.75,66.52 188.75,62.1 188.42,61.76 188.39,61.76 187.64,61.01 v2(187.64,60.84) ; R4036.1 154.73,112.99 v2(154.73,112.99)
+V1.00U_CPU_LS:
  vias: v1(166.18,116)
+V1.8A: length 15
  L3 w0.508: v2(157.57,91.72) 157.95,91.72 158.82,92.58 164.69,92.58 166.52,92.58 166.78,92.85 v2(166.9,92.85)
  BOTTOM w0.508: v2(157.57,91.72) 157.57,89.9 R1139.2 ; v2(166.9,92.85) 166.89,92.86 166.89,94.17 v1(166.77,94.29) 166,95.06 C4020.1
+V1.8A_SIP: length 37.8
  TOP w0.508: v2(167.6,83.35) v1(166.01,84.94) 164.93,86.02 163.52,86.02 162.34,87.2 160.32,87.2 158.6,85.48 157.09,85.48 v2(156.59,84.99)
  L3 w0.508: v2(139.05,84.16) 143.27,84.16 143.63,84.52 150.72,84.52 151.18,84.06 155.67,84.06 v2(156.59,84.99)
  BOTTOM w0.127: v2(139.05,84.16) 138.89,84.16 138.62,84.43 137.05,84.43 136.83,84.22 136.56,84.22 136.01,84.22 135.95,84.28 CPU1.AA1
  BOTTOM w0.508: v2(139.05,84.16) 139.5,83.71 C2108.1 ; v2(167.6,83.35) 167.11,82.87 R1111.1
+V3.3A_SIP:
  vias: v1(163.04,82.53)
+VCC19P2_1P0: length 14.9
  TOP w0.254: v1(127.27,96.21) 127.27,96.28 127.7,96.72 v2(128.14,96.72)
  L3 w0.254: v2(128.14,96.72) 128.14,97.04 129.89,98.8 131.05,98.8 132.2,99.95 132.2,101.44 133.47,102.71 134.2,102.71 134.62,103.13 v2(134.62,103.19)
  BOTTOM w0.127: v2(128.14,96.72) 128.31,96.55 128.31,96.03 127.91,95.63 CPU1.A14
  BOTTOM w0.254: R1131.2 134.3,103.65 134.62,103.33 v2(134.62,103.19)
+VCC24TBT_1P0: length 13.1
  TOP w0.254: v2(133.97,103.21) 133.97,103.92 R1122.2
  BOTTOM w0.254: v2(133.97,103.21) 134.07,103.12 v1(134.07,101.85) 134.07,101.47 133.42,100.82 132.19,100.82 131.79,100.42 131.1,100.42 130.38,99.71 130.38,98.52 130.72,98.18 C2116.1 130.77,97.97 130.77,96.63 130.39,96.25 CPU1.A10
+VCCAMPHYPLL_1P0: length 24.5
  TOP w0.254: v2(140.06,100.21) 140.06,100.51 v1(140.29,100.75)
  L3 w0.254: v2(128,90.04) 128.42,90.46 128.42,92.82 129.08,93.48 129.47,93.48 132.11,96.11 132.58,96.11 133.92,97.45 133.92,98.39 134.66,99.14 135.65,99.14 136.34,99.83 v2(136.34,100.1)
  L4 w0.254: v2(140.06,100.21) 139.91,100.35 136.58,100.35 v2(136.34,100.1)
  BOTTOM w0.254: R1119.2 142.27,99 C1184.1 141.66,100.28 141.5,100.13 140.13,100.13 v2(140.06,100.21) ; CPU1.L15 CPU1.K15 127.6,89.65 v2(128,90.04)
+VCCAMPHYPLL_1P0_L:
  vias: v1(145.16,98.76)
+VCCAPLL_1P0: length 36.3
  TOP w0.152: 134.05,87.78 133.46,87.19 129.35,87.19 v2(128.74,86.58)
  TOP w0.254: v2(152.4,92.59) 152.28,92.59 151.69,92 150.6,92 149.47,90.88 146.54,90.88 v1(146.25,90.58) 145.59,89.92 138.4,89.92 138.1,90.22 136.49,90.22 134.05,87.78
  BOTTOM w0.127: v2(128.74,86.58) 128.47,86.58 128.08,86.18 128.08,86.07 127.59,85.58 CPU1.V15
  BOTTOM w0.254: R1120.2 159.22,94.25 155.92,94.25 154.51,92.84 152.65,92.84 v2(152.4,92.59)
+VCCAPLLEBB_1P0: length 41.9
  TOP w0.254: C1180.1 121.9,86.55 123.21,86.55 v2(123.25,86.59)
  TOP w0.356: v2(145.25,104.73) 145.25,104.44 v1(144.98,104.17)
  L3 w0.203: v2(123.25,86.59) 125.76,89.1 125.76,89.54 126.65,90.43 126.65,93.1 126.85,93.31
  L3 w0.254: 126.85,93.31 127.34,93.79 127.34,96.78 131.82,101.26 131.82,101.78 133.87,103.83 136.25,103.83 136.48,103.61 137.42,103.61 138.43,104.62 145.14,104.62 v2(145.25,104.73)
  BOTTOM w0.127: CPU1.N18 125.5,87.97 125.08,87.54 124.22,87.54 124.11,87.44 123.56,87.44 123.38,87.26 123.38,86.72 v2(123.25,86.59)
  BOTTOM w0.508: R1101.2 145.58,103.48 C1173.1 145.35,103.71 145.35,104.64 v2(145.25,104.73)
+VCCDSW_1P0: length 3.8
  BOTTOM w0.254: C2103.1 v1(137.92,77.99) 136.84,77.99 136.17,78.66 135.71,78.66 CPU1.AL1
+VCCDTS_1P0: length 33.8
  TOP w0.254: v1(164.79,90.29) 164.56,90.53 v2(164.28,90.53)
  L3 w0.254: v2(164.28,90.53) 164.28,90.41 162.83,88.95 160.24,88.95 159.69,89.5 158.97,89.5 157.34,89.5 157.08,89.5 156.16,88.58 153.78,88.58 153.63,88.72 152.32,88.72 151.19,87.59 148.66,87.59 147.59,88.67 145.47,88.67 145.33,88.81 144.37,88.81 142.98,87.42 138.04,87.42 v2(137.61,86.99)
  BOTTOM w0.203: CPU1.T1 135.43,86.89 136.06,86.89 136.2,86.75 137.37,86.75 v2(137.61,86.99)
  BOTTOM w0.254: v2(164.28,90.53) 164.28,90.54 164.26,90.57 164.26,91.17 R1130.2
+VCCF24NS_1P0_L: length 36.1
  TOP w0.254: R1803.2 122.73,87.59 v2(123.18,88.03) ; v1(140.79,104.67) 141.21,105.09 v2(141.21,105.18)
  L3 w0.203: v2(123.18,88.03) 123.52,88.03 124.81,89.33 124.81,92.77 125.28,93.23
  L3 w0.254: 125.28,93.23 126.58,94.54 126.58,97.1 131.06,101.58 131.06,102.1 134.13,105.17 141.14,105.17 141.21,105.23 v2(141.21,105.18)
  BOTTOM w0.127: CPU1.L19 124.68,88.5 124.13,88.5 123.9,88.28 123.42,88.28 v2(123.18,88.03)
  BOTTOM w0.254: v2(141.21,105.18) 140.87,104.84 R1125.2 141.6,104.29 142.36,103.53 C2115.1
+VCCF100_1P0_L: length 36.4
  L3 w0.203: 124.57,93.08 123.92,92.43 123.92,90.41 123.66,90.15 123.06,90.15 v2(122.66,89.75)
  L3 w0.254: 124.57,93.08 126.2,94.71 126.2,97.26 130.68,101.74 130.68,102.26 133.97,105.55 140.74,105.55 140.9,105.71 141.82,105.71 142.16,105.36 v2(143.01,105.36)
  BOTTOM w0.178: CPU1.K19 124.81,89.65 124.45,90.01 123.34,90.01 123.13,89.8 122.71,89.8 v2(122.66,89.75)
  BOTTOM w0.254: C2113.1 144.19,104.42 R1114.2 143.39,104.68 143.01,105.06 v2(143.01,105.36) 142.57,105.36 v1(142.22,105.02)
+VCCF100OC_1P0_L: length 31
  TOP w0.254: v1(136.8,105.01) 137.1,104.71 v2(137.1,104.12)
  L3 w0.203: 126.07,93.33 125.73,93 125.73,90.34 125.28,89.88 125.28,89.25 123.29,87.26 123.02,87.26 v2(122.79,87.03)
  L3 w0.254: v2(137.1,104.12) 137,104.21 133.71,104.21 131.44,101.94 131.44,101.42 126.96,96.94 126.96,94.22 126.07,93.33
  BOTTOM w0.127: CPU1.N20 124.03,87.67 123.42,87.67 v2(122.79,87.03)
  BOTTOM w0.254: C2114.1 138.48,103.92 R1132.2 137.1,104.12 v2(137.1,104.12)
+VCCF135_1P0: length 3.4
  TOP w0.254: v2(147.02,105.71) 146.95,105.71 v1(146.49,105.25)
  BOTTOM w0.178: v2(122.5,89.12) 122.89,89.12 123.2,88.81 CPU1.L21
  BOTTOM w0.254: R1121.2 147.67,105.37 147.34,105.71 v2(147.02,105.71)
+VCCFHV: length 61.8
  L3 w0.254: v2(166.71,79.18) 166.3,78.76 166,78.76 163.82,76.59 161.67,76.59 161.39,76.31 157.83,76.31 157.57,76.05 147.33,76.05 145.83,77.55 141.49,77.55 141.41,77.47 140.47,77.47 139.92,78.01 134.48,78.01 132.73,79.75 127.92,79.75 127.52,80.15 124.18,80.15 v2(124.04,80.01)
  L4 w0.254: v2(162.98,90.54) 162.98,89.48 163.67,88.8 164.98,88.8 165.43,88.34 165.43,87.48 165.43,85.94 166.09,85.28 166.09,85.08 166.23,84.95 166.23,83.85 166.38,83.7 166.38,82.02 167.09,81.31 167.09,79.56 v2(166.71,79.18)
  BOTTOM w0.254: v1(166.71,78.56) v2(166.71,79.18) ; v2(162.98,90.54) 162.98,91.15 R1133.2 ; CPU1.AK20 124.34,79.71 v2(124.04,80.01)
+VCCGT: length 6.7
  L4 w0.508: v2(96.71,87.57) 96.71,88.13 ; v2(99.96,87.57) 99.96,88.18 ; v2(98.66,87.57) v2(98.66,88.48)
  BOTTOM w0.203: CPU1.A62 v2(100.65,95.77) ; CPU1.A53 105.51,94.86 105.51,95.61 v2(105.57,95.67) ; CPU1.A58 v2(103.13,95.77) ; v2(108.28,95.28) 108.09,95.09 CPU1.A48 ; CPU1.A66 v2(98.17,95.77)
  vias: v1(87.96,81.72) v1(88.16,92.6) v1(90.26,85.39) v1(101.7,119.46) v1(106.97,107.43) v1(110.91,113.79) v1(110.96,107.62) v1(113.38,107.43) v2(88.77,87.77) v2(95.41,83.91) v2(96.06,88.48) v2(96.71,83.91) v2(97.36,88.48) v2(97.36,85.74) v2(98.01,83.91) v2(99.31,88.48) v2(99.31,85.74) v2(99.31,83.91) v2(99.97,89.39) v2(101.04,88.93) v2(101.23,87.11) v2(101.29,85.81) v2(101.29,83.9) v2(102.19,86.96) v2(102.3,85.81) v2(102.43,89.84) v2(102.42,83.74) v2(102.95,86.96) v2(103.06,85.81) v2(103.09,83.19) v2(103.23,82.52) v2(103.33,89.84) v2(103.83,85.81) v2(103.85,84.37) v2(104.26,89.84) v2(104.48,86.96) v2(104.53,85.41) v2(104.8,83.43) v2(105.17,89.84) v2(105.27,82.96) v2(105.52,86.18) v2(105.6,84.33) v2(107.91,89.85) v2(108.81,89.85) v3(87.23,88.72) v3(87.21,84.33) v3(87.2,83) v3(88.04,83) v3(88.89,83) v3(89.15,84.31) v3(90,84.31) v3(90.55,86.65) v3(91.51,86.65) v3(91.7,84.26) v3(92.38,86.65) v3(92.55,84.26) v3(93.46,87.09) v3(93.65,85.81) v3(94.35,87.1) v3(94.33,84.26) v3(94.51,85.83) v3(101.79,88.91) v3(102.23,114.47) v3(102.23,113.53) v3(102.23,112.59) v3(102.23,111.65) v3(102.23,110.71) v3(102.46,88.21) v3(102.73,89.09) v3(103.68,89.07) v3(104.14,88.21) v3(105.18,111.33) v3(105.29,109.93) v3(105.61,115.94) v3(105.62,89.09) v3(105.81,88.21) v3(106.17,111.41) v3(106.24,109.31) v3(106.34,114.71) v3(106.32,110.27) v3(106.57,113.62) v3(106.57,89.11) v3(106.73,112.45) v3(107.07,110.93) v3(107.18,109.76) v3(107.31,115.6) v3(107.41,116.77) v3(107.69,119.28) v3(107.82,114.46) v3(108.07,113.09) v3(108.07,111.41) v3(108.12,110.44) v3(108.23,109.36) v3(108.72,115.22) v3(108.96,112.81) v3(109.22,114.3) v3(109.22,109.87) v3(109.49,111.49) v3(109.6,115.85) v3(110.19,113.17) v3(110.31,114.44) v3(110.35,111.01) v3(110.9,115.78) v3(110.9,112.09) v3(111.31,111.24) v3(111.6,113.24) v3(111.92,115.62) v3(111.92,114.46) v3(112.04,112.09) v3(112.38,111.01) v3(112.8,113.26) v3(113.05,114.4) v3(113.12,115.71) v3(113.15,112.22) v3(113.2,117.48) v3(113.32,118.63) v3(113.25,111.27)
+VCCIO: length 4.1
  TOP w0.508: v2(110.62,89.78) 110.6,89.78 109.57,90.81 R801.1
  BOTTOM w0.254: v2(112.64,80.77) 112.4,80.53 112.4,79.61 112.48,79.53 CPU1.AL42 112.48,79.28 CPU1.AM42
  vias: v1(118.08,79.3) v1(157.59,120.68) v1(159.35,125.38) v2(117.97,80.01) v2(118.89,80.01) v2(118.88,78.5) v2(119.6,87.35) v3(152.58,121.46) v3(152.62,120.6) v3(153.51,120.98)
+VCCMPHYAON_1P0: length 56.9
  TOP w0.381: v2(124.04,89.22) 123.81,88.99 C2104.1 124.87,88.47 125.76,89.36 133.01,89.36 134.91,91.26 135.69,91.26 v2(137.35,92.93) ; v2(143.59,94) 144.48,94 v1(146.08,92.41) 146.4,92.08 148.62,92.08 149.34,92.79 149.34,92.79 149.34,92.79 151.38,94.83 151.39,94.83 152.36,94.83 152.61,95.09 156.43,95.09 156.69,94.83 161.57,94.83 162.34,95.6 163.72,95.6 163.73,95.58 163.84,95.58 163.87,95.56 v2(163.98,95.56)
  L4 w0.381: v2(137.73,89.73) 136.68,90.78 136.68,92.25 v2(137.35,92.93) 140.26,92.93 140.74,92.44 141.81,92.44 143.38,94 v2(143.59,94)
  BOTTOM w0.127: v2(137.73,89.73) 137.51,89.94 136.92,89.94 136.58,89.61 135.41,89.61 CPU1.L1
  BOTTOM w0.203: CPU1.K17 125.86,89.22 v2(124.04,89.22)
  BOTTOM w0.381: v2(163.98,95.56) 164.04,95.5 164.04,95.29 164.08,95.24 164.08,93.97 164.08,93.96 R1134.2
+VCCMPHYGTAON_1P0_LS_SIP: length 53.3
  L3 w0.508: 129.62,90.06 129.62,92.47 130.12,92.97 130.12,93.4 132.04,95.32 132.51,95.32 134.42,97.24 134.42,97.66 135.4,98.64 135.86,98.64 137.39,100.16 137.89,100.16 139.47,101.74 146.52,101.74 146.9,101.36 150.64,101.36 151.64,102.36 v3(152.92,102.36)
  BOTTOM w0.508: 157.59,106.7 158.26,106.04 160.61,106.04 164.61,102.04 164.61,95.84 164.61,95.84 164.61,95.73 164.61,95.73 164.61,95.52 164.63,95.51 164.69,95.44 166.25,93.89 166.25,89.92 166.22,89.9 166.22,89.03 R1106.1
  vias: v1(153.41,103.89) v1(154.55,106.44) v2(128.08,87.66)
+VCCPAZIO: length 43.3
  TOP w0.254: v2(158.24,86.12) 158.13,86 154.09,86 153.63,85.54 149.06,85.54 147.26,83.75 147.26,82.38 146.84,81.96 146.71,81.96 146.7,81.95 145.47,81.95 145.26,81.74 140.79,81.74 138.91,79.86 134.61,79.86 v1(134.38,80.09) 133.74,80.73 123.25,80.73 v2(123.17,80.8)
  BOTTOM w0.089: v2(123.17,80.8) 123.27,80.71 124.7,80.71 CPU1.AJ19
  BOTTOM w0.254: R1135.2 158.43,86.12 v2(158.24,86.12) 157.31,87.04 R1118.2
+VCCPDSW_3P3: length 94.8
  TOP w0.254: v2(155.05,66.4) 155.05,66.73 154.79,66.99 R1703.1 154.27,67.83 R1723.1 ; v2(164.28,86.7) 163.26,87.72 156.89,87.72 155.55,86.38 153.93,86.38 153.47,85.92 148.9,85.92 145.1,82.12 140.63,82.12 138.72,80.2 136.41,80.2 v1(135.55,81.07) 134.86,81.75 127.57,81.75 127.02,81.2 123.77,81.2 v2(123.12,81.86) ; R1707.1 151.72,66.51 v2(151.72,65.64)
  L3 w0.254: v2(165.57,68.92) 165.45,68.8 162.41,68.8 161.34,67.73 161.34,66.9 160.39,65.95 158.78,65.95 158.33,66.4 v2(155.05,66.4)
  L4 w0.254: v2(165.57,68.92) 165.69,69.04 165.69,70.42 165.92,70.65 165.92,72.65 165.74,72.83 165.74,72.83 165.69,72.88 165.69,75.63 165.15,76.17 165.15,80.61 164.96,80.81 164.96,83.11 164.81,83.26 164.81,83.32 163.85,84.29 163.85,86.27 v2(164.28,86.7)
  BOTTOM w0.089: 123.23,81.31 123.65,80.89 125.82,80.89 CPU1.AJ17
  BOTTOM w0.127: CPU1.AD18 125.25,83.33 124.27,83.33 124.2,83.25 123.43,83.25 123.32,83.14
  BOTTOM w0.254: 123.23,81.31 123.14,81.4 123.14,81.84 v2(123.12,81.86) 122.89,82.08 122.89,82.72 123.32,83.14 ; v2(155.05,66.4) 154.27,66.4 153.51,65.64 v2(151.72,65.64) ; v2(164.28,86.7) 164.15,86.83 R1711.2 163.4,86.79 R1712.2 ; CPU1.AD17 CPU1.AD18
+VCCPGPPA: length 50
  L3 w0.254: v2(152.1,75.3) 152.47,75.67 157.73,75.67 157.97,75.9 161.57,75.9 161.82,76.15 163.95,76.15 165.45,77.65 v2(166.05,77.65)
  L4 w0.254: v2(152.1,75.3) 152.1,74.87 151.73,74.5 149.06,74.5 148.29,75.27 146.78,75.27 146.5,75 145.61,75 145.32,75.29 145.32,77.15 143.9,78.56 140.29,78.56 140.06,78.33 134.69,78.33 132.93,80.1 131.27,80.1 130.66,80.7 128.56,80.7 128.11,80.25 v2(128.11,80.22)
  BOTTOM w0.254: R1109.2 166.87,81.48 R1111.2 167.11,80.53 166.85,80.27 166.85,80.08 v1(166.8,80.03) 166.19,79.42 166.19,78.37 166.05,78.23 v2(166.05,77.65) ; CPU1.AK15 127.96,79.96 127.96,80.07 v2(128.11,80.22)
+VCCPGPPB: length 41.9
  TOP w0.254: v2(164.38,78.32) 164.73,78.32 v1(165.21,78.8)
  L3 w0.254: v2(164.38,78.32) 163.95,78.32 163.7,78.57 163.55,78.57 162.84,79.27 158.8,79.27 158.3,79.77 150.79,79.77 150.27,79.25 146.75,79.25 146.63,79.37 145.01,79.37 144.82,79.18 137.15,79.18 134.53,81.79 128.49,81.79 128.16,82.12 v2(128.16,82.28)
  BOTTOM w0.127: CPU1.AG15 128.01,81.69 128.01,82.13 v2(128.16,82.28)
  BOTTOM w0.254: R1116.2 164.73,78.32 v2(164.38,78.32)
+VCCPGPPC: length 37.5
  TOP w0.254: v2(128.16,84.41) 127.49,84.41 v1(127.13,84.05) 126.74,83.66 C2106.1
  L3 w0.254: v2(128.16,84.41) 128.16,84.4 128.63,83.93 134.11,83.93 135.15,82.89 138.09,82.89 138.33,83.12 141.45,83.12 141.77,82.8 143.89,82.8 144.02,82.94 145.7,82.94 146.13,83.36 148.45,83.36 148.91,82.9 150.52,82.9 150.95,83.33 156.23,83.33 157.58,84.67 157.8,84.67 157.97,84.85 v2(158.34,84.85)
  BOTTOM w0.203: v2(128.16,84.41) 127.95,84.2 127.36,84.2 CPU1.Y16
  BOTTOM w0.254: R1123.2 159.01,85.52 v2(158.34,84.85)
+VCCPGPPD: length 36
  TOP w0.254: v2(158.25,86.86) v1(157.68,86.86)
  L3 w0.254: v2(128.2,85.48) 128.66,85.02 133.8,85.02 134.54,84.28 136.44,84.28 137.07,84.9 140.97,84.9 141.55,85.47 142.08,85.47 142.73,84.82 143.21,84.82 143.42,85.03 150.93,85.03 151.36,84.61 155.37,84.61 156.5,85.74 157.13,85.74 v2(158.25,86.86)
  BOTTOM w0.254: R1113.2 158.61,88 158.25,87.64 v2(158.25,86.86) ; CPU1.Y15 127.59,84.74 128.2,85.36 v2(128.2,85.48)
+VCCPGPPD_TCH: length 6.5
  BOTTOM w0.254: R1129.2 158.29,89.32 R1113.1 160.43,89.32 R1108.2 160.44,89.95 160.32,90.07 C1183.1 160.32,92.12 160.32,92.13 v1(160.32,92.2)
+VCCPGPPE: length 44.9
  TOP w0.254: v2(128,86.68) v1(126.99,86.68) 126.08,86.68 125.26,85.85 C2107.1
  L3 w0.254: v2(128,86.68) 128.46,87.14 134.73,87.14 135.39,87.8 142.82,87.8 144.21,89.19 145.49,89.19 145.63,89.05 147.78,89.05 148.85,87.98 151.03,87.98 152.16,89.1 153.79,89.1 153.93,88.96 156,88.96 156.92,89.88 157.5,89.88 159.13,89.88 159.13,89.88 159.85,89.88 160.4,89.33 162.62,89.33 163.62,90.33 v2(163.62,90.54)
  BOTTOM w0.203: CPU1.T16 127.34,86.7 127.97,86.7 v2(128,86.68)
  BOTTOM w0.254: v2(163.62,90.54) 163.62,89.73 R1124.2
+VCCPGPPF: length 39.7
  TOP w0.254: v2(123.99,81.67) 126.89,81.67 128.06,82.85 132.92,82.85 133.11,82.65 134.57,82.65 135.16,82.07 138.24,82.07 138.54,81.76 139.73,81.76 140.48,82.5 144.94,82.5 148.74,86.3 153.09,86.3 153.77,86.98 v1(154.25,86.98) v2(155.14,86.98)
  BOTTOM w0.152: v2(123.99,81.67) 126.51,81.67 CPU1.AF16
  BOTTOM w0.254: v2(155.14,86.98) 155.08,87.05 154.55,87.05 153.62,87.97 R1138.1
+VCCPGPPG: length 36.4
  TOP w0.254: v2(158.34,84.21) 158,84.21 v1(157.77,84.44)
  L3 w0.254: v2(127.99,83.33) 128.48,82.85 133.09,82.85 133.44,82.51 138.32,82.51 138.55,82.74 141.29,82.74 141.62,82.42 144.04,82.42 144.18,82.55 145.94,82.55 146.36,82.98 148.3,82.98 148.75,82.52 150.68,82.52 151.11,82.95 156.39,82.95 157.7,84.25 158.3,84.25 v2(158.34,84.21)
  BOTTOM w0.254: v2(127.99,83.33) 127.98,83.33 CPU1.AD15 ; R1128.2 159.12,84.21 v2(158.34,84.21) 158.3,84.25 157.83,84.25 157.56,84.52 157.56,85.55 R1136.2
+VCCPRIM_1P0: length 40.5
  TOP w0.508: v2(162.35,90.54) 160.8,88.99 v1(154.96,88.99) 152.4,88.99 151.24,87.84 147.87,87.84 147.07,87.04 142.39,87.04 142.02,87.41 139.4,87.41 139.22,87.59 136.5,87.59 133.78,84.87 133.15,84.87
  L3 w0.254: v2(124.04,86.71) 124.04,86.19 123.53,85.68 123.53,84.88 123.01,84.36 v2(123.01,84)
  BOTTOM w0.127: CPU1.P18 125.28,86.77 124.1,86.77 v2(124.04,86.71) ; CPU1.AB19 CPU1.AB20 124.03,83.47 123.54,83.47 v2(123.01,84)
  BOTTOM w0.508: R1112.2 161.57,91.1 162.12,90.54 v2(162.35,90.54)
+VCCPRIM_3P3: length 106
  TOP w0.254: C2105.1 v2(121.73,82.37) 122.53,81.57 v2(122.53,80.81) ; v2(164.34,89.32) 164.34,88.88 163.56,88.1 v1(155.93,88.1) 154.3,88.1 152.99,86.8 148.56,86.8 146.65,84.89 142.65,84.89 141.57,85.97 135.67,85.97 134.01,84.31 132.6,84.31 132.22,83.93 127.85,83.93 126.96,83.04 125.26,83.04 124.83,83.46 124.83,84.24 v2(124.04,85.03)
  L3 w0.254: v2(121.73,82.37) 122.75,83.38 123.06,83.38 123.51,83.83 123.51,84.36 124.04,84.89 v2(124.04,85.03) ; v2(163.5,107.87) 162.62,106.99 156.87,106.99 153.99,104.11 151.09,104.11 150.65,103.68 147.78,103.68 147.44,104.02 138.51,104.02 137.37,102.88 v2(137.22,102.88)
  L4 w0.254: v2(163.5,107.87) 163.37,107.74 163.37,102.88 162.8,102.32 162.8,100.34 162.38,99.92 162.38,94.65 162.43,94.6 162.43,94.18 162.43,94.18 162.43,93.21 164.79,90.84 164.79,90.12 164.34,89.67 v2(164.34,89.32)
  BOTTOM w0.127: v2(124.04,85.03) 124.56,85.03 CPU1.V19
  BOTTOM w0.254: v2(137.22,102.88) 136.72,102.88 136.36,102.52 R1701.1 ; R1127.2 163.73,88.15 164.34,88.76 v2(164.34,89.32) ; v2(122.53,80.81) 122.53,80.68 122.88,80.33 123.6,80.33 CPU1.AJ21
+VCCPRIM_CORE: length 44.3
  L3 w1.016: 125.12,95.23 125.12,97.25 129.92,102.05 129.92,102.7 130.7,103.48 130.7,105.01 133.39,107.7 138.12,107.7 139.64,109.22 144.81,109.22 151.73,116.15 151.73,118.02 v3(152.65,118.94)
  BOTTOM w0.305: v2(122.99,85.03) 123.41,85.46 CPU1.V21 123.76,85.53 124.27,85.53 CPU1.V20 ; v2(124.01,82.5) 124.59,82.5 CPU1.AF19 CPU1.AF18
  vias: v1(148.48,119.23) v2(121.63,84.33) v3(153.18,119.79) v3(153.72,119.12)
+VCCPRTC_3P3: length 23.1
  TOP w0.203: 126.65,74.84 126.65,78.67 126.35,78.98 124.85,78.98 v2(124.37,78.5)
  TOP w0.254: R2106.2 129.94,67.92 v1(129.44,68.41) v2(128.2,69.65) 128.2,70.98 128.35,71.13 128.35,72.61 126.65,74.31 126.65,74.84
  BOTTOM w0.127: v2(128.2,69.65) 127.78,70.07 127.78,71.26 127.44,71.61 127.44,71.95 127.65,72.16 127.65,72.7 CPU1.BB14
  BOTTOM w0.254: v2(124.37,78.5) 124.37,78.97 CPU1.AK19
+VCCPRTCPRIM_3P3: length 47.9
  TOP w0.254: v2(164.64,84.64) 163.52,84.64 161.48,86.69 161.06,86.69 161.03,86.67 160.72,86.67 159.5,85.45 159.5,84.46 158.59,83.56 158.03,83.56 157.74,83.86 156.32,83.86 155.02,85.16 149.22,85.16 147.64,83.59 147.64,82.22 147,81.58 146.89,81.58 145.29,79.98 C2111.1 C2110.1 C2109.1 143.12,79.97 141.62,79.97 141.02,80.58 140.29,80.58 139.12,79.4 v1(135.63,79.4) 133.56,79.4 132.66,80.3 131.94,80.3 131.91,80.27 130.76,80.27 130.21,79.72 128.72,79.72 128.18,79.18 v2(128.01,79.18)
  BOTTOM w0.127: v2(128.01,79.18) 127.95,79.23 126.79,79.23 126.59,79.43 126.44,79.43 CPU1.AK17
  BOTTOM w0.254: R1115.2 163.81,84.64 v2(164.64,84.64)
+VCCPSPI: length 41.2
  TOP w0.254: v1(163.52,78.66) 162.89,78.66 v2(162.58,78.35)
  L3 w0.254: v2(162.58,78.35) 161.47,77.24 157.6,77.24 155.68,79.16 151.05,79.16 150.53,78.64 147.08,78.64 146.41,77.97 143.22,77.97 142.4,78.79 135.98,78.79 134.04,80.73 128.66,80.73 v2(128.16,81.24)
  BOTTOM w0.127: CPU1.AJ16 127.41,80.9 127.73,80.9 128.07,81.24 v2(128.16,81.24)
  BOTTOM w0.254: R1126.2 162.83,78.6 v2(162.58,78.35)
+VCCSA: length 2.5
  BOTTOM w0.508: R735.1 123.32,97.26 123.7,96.88 123.7,96.11 v2(123.52,95.94)
  vias: v1(119.62,89.48) v1(129.2,100.86) v1(136.95,112.57) v1(137,113.62) v2(118.89,89.79) v2(118.89,89.16) v2(119.8,91.39) v2(120.38,80.65) v2(120.74,89.8) v2(120.74,89.17) v2(120.73,80.02) v3(136.01,115.09) v3(136.04,114) v3(136.77,114.46) v3(137.66,115.09) v3(137.66,114.2)
+VCCSRAM_1P0: length 11.5
  TOP w0.356: v3(164.7,88.11) v1(165.41,88.11)
  L3 w0.381: v2(123.37,82.5) 122.66,82.5 122,81.84 121.51,81.84 121.16,82.19 121.16,82.71 122.38,83.93 122.38,85.28 122.86,85.75 v2(122.86,86.08)
  BOTTOM w0.127: CPU1.AF21 123.71,82.08 124.31,82.08 CPU1.AF20
  BOTTOM w0.254: v2(123.37,82.5) 123.37,82.42 CPU1.AF21 ; CPU1.T19 CPU1.T20 123.95,85.91 123.03,85.91 v2(122.86,86.08)
+VCCST_CPU: length 205.1
  TOP w0.254: v2(123.92,146.08) 123.92,146.08 PR4623.1 123.25,147.59 123.52,147.86 PC4610.1
  L3 w0.254: v2(148.6,104.29) 150.5,104.29 150.69,104.49 150.93,104.49 150.93,104.49 153.68,104.49 156.25,107.07 v2(156.25,114.35) 156.25,115.51 156.79,116.05 156.79,122.16 154.51,124.43 154.51,127.8 154.31,128 154.31,134.57 154.56,134.81 154.56,137.1 152.36,139.3 152.36,139.92 151.13,141.15 151.13,142.09 149.48,143.73 148.51,143.73 147.96,144.29 145.49,144.29 144.72,143.52 128.23,143.52 126.43,145.32 125.45,145.32 124.69,146.08 v2(123.92,146.08) 122.18,144.34 118.46,144.34 116.45,146.35 111.59,146.35 110.83,147.11 110.23,147.11 109.27,146.16 108.4,146.16 104.27,142.03 100.88,142.03 99.26,140.4 95.64,140.4 94.92,139.68 94.92,135.56 98.67,131.81 98.67,123.98 97.05,122.36 97.05,118.14 92.45,113.54 92.45,109.58 97.02,105.02 v2(97.02,101.32)
  L4 w0.254: v2(128.59,104.18) 129.01,104.18 130.98,106.16 138.85,106.16 139.14,105.87 143.25,105.87 145.07,104.06 148.32,104.06 v2(148.6,104.29) ; v2(97.02,101.32) 97.16,101.46 v2(99.63,101.46) 100.56,101.46 v2(100.67,101.57)
  BOTTOM w0.152: CPU1.A18 125.43,95.77
  BOTTOM w0.254: v2(128.59,104.18) 128.82,103.96 128.82,101 C716.1 125.87,98.05 125.87,96.45 125.43,96.02 125.43,95.77 ; v2(100.67,101.57) 100.67,101.76 R419.1 ; v2(156.25,114.35) 156.07,114.53 R4036.2 153.92,114.53 R4045.2 ; R726.1 97.99,99.31 R603.2 97.32,99.97 97.32,100.74 97.33,100.74 v1(97.33,100.82) 97.32,100.82 97.32,101.01 v2(97.02,101.32) ; R727.1 v2(99.63,101.46) 99.43,101.46 98.67,102.22 R723.1 ; v2(123.92,146.08) 123.92,146.08 PR4623.1 PR4622.1 PR4621.1
+VCCSTG: length 280.8
  TOP w0.254: v2(153.94,112.99) 154.83,112.1 v1(155.27,112.1) 155.73,112.1 157.09,113.46 158.3,113.46 162.03,117.19 162.03,120.11 163.49,121.57 163.49,124.35 v2(164.17,125.04) ; v2(160.8,108.18) 160.07,108.18 158.67,106.78 156.97,106.78 154.73,104.54 151.69,104.54 150.85,105.38 148.82,105.38 v2(148.73,105.47) ; v2(167.93,87.4) 168.07,87.26 168.07,85.36 168.6,84.83 168.6,82.17 166.2,79.78 166.2,78.5 v2(167.99,76.72) ; R2440.1 169.63,65.32 168.8,66.15 166.99,66.15 166.75,66.39 166.75,66.6 166.4,66.95 164.2,66.95 163.84,67.31 163.83,67.31 163.47,67.68 163.47,68.75 163.65,68.93 163.65,71.69 163.11,72.22 v2(163.11,72.67)
  L3 w0.254: v2(93.85,99.3) 93.79,99.36 v2(93.79,105.37) ; v2(159.5,91.77) 159.8,92.07 161.45,92.07 161.46,92.06 164.89,92.06 164.9,92.07 166,92.07 166.92,92.07 167.26,92.41 167.37,92.41 v2(167.39,92.43) ; v2(148.73,105.47) 148.8,105.39 149.45,105.39 149.49,105.44 153.36,105.44 154.59,106.66 154.59,112.35 153.94,112.99 v2(153.94,112.99) 153.94,114.17 156.08,116.3 156.08,122.33 154.13,124.28 154.13,127.65 153.93,127.84 153.93,134.73 154.17,134.97 154.17,136.94 151.98,139.14 151.98,139.76 150.74,140.99 150.74,141.93 149.32,143.35 148.35,143.35 147.8,143.9 145.65,143.9 144.88,143.14 128.07,143.14 127.48,143.73 126.27,144.94 125.12,144.94 v2(124.51,145.55)
  L4 w0.203: v2(124.37,91.38) 123.92,91.83 123.92,92.45
  L4 w0.254: v2(160.8,108.18) 160.8,104.03 160.13,103.36 160.13,101.11 159.53,100.51 159.53,99.65 159.02,99.14 159.02,95.85 158.9,95.73 158.9,95.26 159.2,94.96 159.33,94.96 159.56,94.73 159.56,92.25 159.56,91.83 v2(159.5,91.77) ; v2(148.73,105.47) 148.49,105.47 148.09,105.87 148.09,106.14 145.51,108.72 139.06,108.72 138.91,108.57 129.96,108.57 128.4,107.01 126.67,107.01 126.18,106.53 v2(124.13,106.53) 123.65,107.01 118.15,107.01 117.64,106.5 117.64,104.93 118.12,104.46 118.12,101.21 117.11,100.2 114.34,100.2 112.17,102.37 109.35,102.37 108.84,102.87 108.84,103.71 107.26,105.29 v2(106.41,105.29) 105.75,104.63 v2(105.45,104.63) 104.95,105.13 103.39,105.13 103.24,104.97 v2(102.36,104.97) 102.21,104.97 101.29,105.9 100.11,105.9 99.46,105.25 96.24,105.25 95.7,104.71 94.46,104.71 v2(93.79,105.37) ; 123.92,92.45 123.92,92.87 121.14,95.65 v2(121.14,96.74)
  BOTTOM w0.254: v2(105.45,104.63) 105.84,104.24 R417.2 105.84,103.15 R416.2 105.82,103.11 R408.2 ; R1722.1 93.92,100.06 C717.1 93.91,99.36 v2(93.85,99.3) 92.78,99.3 92.39,98.9 R401.1 ; R4048.2 v2(164.17,125.04) ; CPU1.G20 124.5,91.38 v2(124.37,91.38) ; v2(167.99,76.72) 167.61,76.72 167.43,76.53 167.43,76.1 164,72.67 v2(163.11,72.67) ; R409.2 106.96,105.29 v2(106.41,105.29) ; R422.2 103.32,104.53 R421.2 R423.2 101.98,104.59 v2(102.36,104.97) ; v2(124.51,145.55) 124.48,145.53 123.71,145.53 123.38,145.19 PR4669.1 ; v2(124.13,106.53) 123.18,105.58 123.18,102.93 123.01,102.75 123.01,101.08 121.14,99.21 v2(121.14,96.74) 121.14,96.08 121.74,95.47 122.44,95.47 122.95,94.96 CPU1.A22 ; v2(167.39,92.43) 167.39,92.37 167.31,92.29 167.31,90.55 167.48,90.38 167.48,89.8 167.42,89.74 167.42,87.87 167.9,87.4 v2(167.93,87.4) ; R4045.1 153.92,113.01 v2(153.94,112.99)
+VDDQ_CPU_CLK: length 36.2
  TOP w0.254: C715.1 R705.2 129.8,63.03 127.44,63.03 126.88,62.47 126.12,62.47 124.75,63.84 v1(124.75,68.38) 124.75,69.33 123.72,70.36 v2(123.72,70.84) ; C722.1 112.47,78.54 v2(112.48,78.53)
  L3 w0.203: 122.06,76.37 122.06,76.97 122.07,76.98 122.07,78.68 121.75,79 112.94,79 v2(112.48,78.53)
  L3 w0.254: 122.06,76.37 122.06,75.06 122.46,74.66 122.88,74.66 123.2,74.34 123.2,73.49 124.25,72.44 124.25,71.37 v2(123.72,70.84)
  BOTTOM w0.254: v2(112.48,78.53) 112.77,78.82 CPU1.AM40
DVSS: length 3.7
  TOP w0.102: HDA27.4 32.66,14.87 33.31,15.52 R2732.1
GND: length 1766.8
  TOP w0.089: v2(201.44,140.58) 201.31,140.58 201.04,140.31 200.89,140.31 200.8,140.23 200.22,140.23 199.84,140.6 v2(199.83,140.6)
  TOP w0.203: KBC24.84 175.47,73.01 v2(175.6,73.13) ; v2(175.97,68.03) 176.48,67.52 KBC24.100 ; U4001.11 U4001.15 ; KBC24.64 175.28,80.69 175.29,80.68 175.29,80.32 175.53,80.07 v2(175.53,80.01) ; KBC24.124 186.08,68.01 v2(185.61,68.48) ; v2(47.42,19.14) 47.47,19.19 PU5101.7 ; KBC24.51 180.48,80.93 180.02,80.47 v2(180,80.47) ; KBC24.17 188.25,74.61 188.1,74.76 v2(187.46,74.76) ; Q6001.1 173.68,28.68 173.58,28.78 173.58,29.65 173.25,29.98 Q6001.4 ; PU5101.4 45.44,21.85 v2(45.08,21.49) ; v2(196.4,78.52) 196.4,77.44 195.98,77.02 VGABD1.4 ; v2(49.04,19.97) 49.04,19.99 48.67,20.36 PU5101.10
  TOP w0.254: AFTP6201.1 v2(190.86,118.48)
  TOP w0.305: VRAM3.M9 198.95,165.3 v2(198.56,164.91) ; VRAM3.G9 202.93,165.32 v2(202.54,165.7) 202.95,166.11 VRAM3.G8 ; VRAM4.E8 175.55,171.32 v2(175.53,171.32) 175.15,170.94 VRAM4.D8 ; VRAM3.D8 205.34,166.12 v2(204.94,165.72) 204.55,166.1 VRAM3.E8 ; v2(203.35,171.32) 202.95,171.72 VRAM3.G1 202.68,171.99 202.68,172.4 v2(202.42,172.66) ; v2(177.15,172.3) 177.55,171.9 VRAM4.G9 ; PU5001.6 134.61,136.59 v2(134.19,136.17) ; LCD1.13 77.31,171.32 77.31,171.32 v2(77.23,171.32) ; v2(204.96,171.31) 205.35,171.7 VRAM3.D1 ; v2(204.96,171.31) 204.57,170.92 VRAM3.E2 ; v2(204.96,171.31) VRAM3.E1 ; VGABD1.13 196.11,81.52 v2(196.32,81.32) ; VRAM3.A9 207.75,165.3 v2(207.33,164.88) 206.95,165.26 VRAM3.B9 ; v2(15.44,24.13) 15.22,24.13 AFTP6244.1 ; VRAM4.E2 175.92,166.12 v2(175.53,165.73) ; v2(201.7,170.52) 201.35,170.88 VRAM3.J2 ; VRAM4.G8 177.55,170.95 v2(177.91,171.31) ; LEDBD1.6 190.79,125.62 v2(190.74,125.57) 191.19,125.12 LEDBD1.5 ; v2(175.53,165.73) 175.93,165.32 VRAM4.E1 ; v2(175.53,165.73) 175.15,165.35 VRAM4.D1 ; v2(128.8,84.42) 128.8,84.7 128.56,84.94 127.09,84.94 126.69,84.55 C2106.2 ; U1702.3 155.14,43.24 156,43.24 v2(156.18,43.06) ; VRAM4.J8 179.17,170.92 v2(179.55,170.54) ; v2(176.63,31.34) 176.76,31.47 C6009.2 ; v2(96.74,153.65) 96.74,153.6 96.6,153.46 C5516.2 EC5505.2 ; v2(201.76,166.5) 201.76,166.48 201.4,166.12 VRAM3.J8 ; v2(163.14,73.31) 163.49,73.31 163.75,73.05 163.75,72.57 164.1,72.21 R2417.2 ; KB1.1 190.87,117.45 191.09,117.68 191.09,118.24 v2(190.86,118.48) ; 76.89,159.82 LCD1.36 ; LCD1.16 77.31,169.82 77.31,169.82 v2(77.23,169.82) ; v2(176.51,28.34) 176.37,28.2 R6005.2 175.53,28.2 175.05,28.68 Q6001.1 ; v2(79.37,167.78) 78.83,168.32 LCD1.19 ; VRAM4.B3 173.55,167.33 v2(173.4,167.48) ; LCD1.25 77.53,165.32 v2(77.26,165.59) 77.49,165.82 LCD1.24 ; VRAM4.G1 177.51,165.32 v2(177.11,165.72) ; v2(196.4,80.02) VGABD1.10 ; v2(185.29,165.31) 185.28,165.32 VRAM4.T1 ; v2(77.25,163.33) 77.26,163.32 LCD1.29 ; VGABD1.7 v2(196.4,78.52) ; FPR1.1 175.5,133.74 v2(175.44,133.68)
  TOP w0.356: VRAM4.B1 173.37,165.14 v2(173.37,164.73) ; VRAM3.B1 206.95,171.91 v2(207.3,172.26) ; v2(203.5,164.56) 203.5,164.54 203.75,165 VRAM3.F9 ; v2(181.12,143.84) 180.83,144.14 PQ8301.4 ; v2(208.16,169.29) 207.83,169.62 207.45,169.62 VRAM3.B3 ; VRAM3.T1 195.18,171.72 v2(195.16,171.74) ; VRAM4.J2 179.15,166.15 v2(178.76,166.54) ; v2(173.36,172.29) 173.55,172.1 VRAM4.B9 ; v2(181.29,172.36) 181.29,171.98 VRAM4.M9 ; v2(177.15,172.3) 177.15,172.27 176.75,171.87 VRAM4.F9 ; v2(198.86,172.27) 198.95,172.18 VRAM3.M1 ; v2(185.35,171.79) 184.82,171.79 VRAM4.T9 ; v2(195.16,165.32) 195.75,165.32 VRAM3.T9 ; VRAM4.P9 183.14,171.73 v2(183.14,172.4) ; v2(182.93,164.71) 183.15,164.93 VRAM4.P1 ; v2(181.67,164.77) 181.55,164.89 VRAM4.M1 ; v2(177.41,145.88) 177.85,145.44 PQ8301.1 ; v2(197.42,172.45) 197.42,171.79 VRAM3.P1 ; VRAM3.P9 v2(197.35,164.74)
  TOP w0.381: TPAD1.5 59.28,76.77 v2(59.28,76.76) ; v2(193.05,74.21) 192.62,74.64 C2413.2 ; EC3103.1 34.89,174.79 34.22,174.12 v2(34.15,174.12) 34.13,174.1 U3201.8 ; v2(174.99,53.83) 175.33,54.17 U2401.2 ; PQ4402.1 102.88,166.21 v2(102.22,166.87) ; v2(141.82,153.04) 143.4,154.62 PQ4403.S ; R730.2 121.14,82.01 121.89,81.26 v2(121.89,80.82) ; R7637.2 204.19,131.37 v2(204.21,131.35) ; Q6101.1 156.55,52.3 157.6,52.3 157.81,52.1 R6101.2 ; v2(10.74,70.1) EU5703.8 EU5703.3 ; v2(173.36,172.29) 173.25,172.18 173.21,172.18 VRAM4.A9
  TOP w0.406: PQ4303.4 119.32,175.34 v2(119.37,175.29) ; v2(154.1,54.56) 154.27,54.56 154.66,54.17 Q6101.4 ; v2(124.07,170.46) 124.09,170.48 PQ4405.1 ; v2(122.04,169.57) 122.09,169.52 PQ4405.4 ; v2(105.15,169.19) 105.15,168.3 104.94,168.09 PQ4402.4
  TOP w0.508: HDMI1.5 8.33,64.17 ; C7502.2 188.18,152.19 v2(188.17,152.18) ; v2(114.55,125.33) PC4807.2 114.59,126.01 PC4808.2 ; v2(163.23,77.42) 163.21,77.42 163,77.21 162.45,77.21 Q2408.S 162.04,75.4 161.1,74.45 C2403.2 ; v2(193.25,146.14) 192.94,146.45 C7505.2 ; R2436.2 170.87,70.93 170.24,70.93 v2(170.22,70.95) ; R6505.2 199.11,114.49 198.56,113.94 v2(197.82,113.94) 197.82,113.33 195.37,110.88 R6507.2 195.37,110.34 C6502.2 ; C7310.2 175.19,145.85 v2(174.95,145.85) ; 76.89,159.82 75.66,159.82 v2(74.15,161.33) ; C1211.2 79.36,36.79 v2(79.45,36.7) ; C1311.2 138.54,24.54 C1210.2 ; EC6501.2 52.94,78.07 v2(52.97,78.04) ; KB1.32 186.06,91.91 v2(186.27,91.71) ; v2(169.68,78.8) 170.49,78.8 170.6,78.91 R2449.1 ; v2(32.38,59.08) 32.38,58.31 R4006.2 ; EC5301.2 143,135.26 v3(143,134.4) ; C2417.2 174.1,86.76 174.28,86.94 v2(174.28,87.01) 174.54,87.01 175.19,86.36 C2402.1 175.21,86.13 R2510.2 ; PC4610.2 125.01,147.24 v2(124.96,147.19) ; v2(107.82,172.72) 108.66,171.89 PR4308.2 ; 115.21,89.76 115.2,89.75 PC1022.2 ; 115.21,89.76 C1102.2 ; 115.21,89.76 v2(115.22,89.74) ; v2(126.23,176.43) 126.33,176.34 PD4302.1 ; C1321.2 110.81,18.9 v2(110.74,18.97) ; C1210.2 137.52,24.55 R1301.2 ; C1210.2 137.01,24.54 136.1,23.63 v2(136.1,22.9) ; v2(40.54,169.93) 40.54,169.94 C3115.2 ; C6501.2 195.64,101.76 196.88,100.51 196.88,99.78 ; C1322.2 115.3,23.86 v2(115.3,22.97) ; v2(119.37,177.45) 119.31,177.51 PR4318.2 ; C4003.2 33.51,56.53 v2(33.7,56.72) ; PC1055.2 89.56,60.89 PC1064.2 89.4,58.89 88.85,58.35 88.85,56.08 PC1056.2 ; v2(55.52,44.75) 55.52,44.74 R4214.2 55.59,43.98 R4215.2 ; v2(99.48,168.39) 99.5,168.37 DCIN1.8 ; v2(77.29,31.43) 77.34,31.38 C1220.2 ; C7902.2 177.66,161.54 v2(177.64,161.56) ; EC9704.2 91.52,111.07 v2(91.42,111.17) ; v2(115.1,19.19) 114.44,19.19 C1213.2 ; v2(38.41,61.2) 38.41,61.2 38.41,60.46 37.46,59.52 PR4523.2 ; EC2002.2 149.94,89.37 v2(149.07,88.5) ; D1319.1 86.51,18.55 86.91,18.96 v2(87.65,18.96) ; v2(184.86,146.41) 184.37,146.89 C7317.2 ; v2(197.31,151.34) 197.32,151.33 R7510.2 ; R7518.2 199.68,133.27 v2(199.77,133.18) ; PR4433.2 119.31,169.89 v2(119.25,169.96) 118.61,169.96 118.36,170.21 PR4316.2 ; R2024.2 149.38,74.89 v2(149.5,75) ; EC9739.2 15.83,22.39 v2(15.77,22.33) ; v2(183.03,123.73) 183.03,123.94 C9201.2 C9202.2 ; C1310.2 C1302.2 78.55,25.85 v2(78.18,26.22) ; EC9201.1 178.93,126.56 v2(178.93,128.94) ; v2(15.74,20.55) 15.74,19.75 EC2704.2 ; AFTP2501.1 14.38,21.37 USB2.4 ; PR4413.1 122.23,168.75 122.04,168.94 v2(122.04,169.57) ; C1101.2 117.13,89.83 v2(117.05,89.76) ; C1205.2 60.38,37.53 C1204.2 61.42,37.74 C1206.2 61.94,37.75 v2(62.74,36.94) ; FAN1.3 96.57,140.8 v2(97.53,141.76) 98.19,142.42 C2604.2 98.98,142.42 99.61,141.79 99.61,140.62 99.17,140.17 C2603.2 EC2601.2 ; R7602.2 202.22,140.3 201.94,140.58 v2(201.44,140.58) ; R4207.2 55.69,39.99 R4203.2 55.52,40.92 v2(55.52,40.92) ; v3(15.06,17.35) 15.45,16.96 ED301.2 ; PC1058.2 110.18,64.95 v2(110.19,64.95) ; v3(61.9,71.33) 62.05,71.17 TPAD1.10 ; v2(80.76,174.87) 80.74,174.84 R5528.2 ; C7507.2 203.87,150.17 v2(203.84,150.2) ; PR5108.2 46.24,26.87 PR5102.2 47,27.6 v2(46.96,27.64) ; v2(37.57,173.51) 37.56,173.52 EC3102.1 ; v2(151.47,75.3) 151.47,73.91 150.6,73.04 R2019.2 ; v2(180,88.64) 179.83,88.81 C2423.2 ; v2(99.44,64.62) 99.23,64.62 99.2,64.6 99.2,64.6 98.83,64.22 98.83,64.22 PC1057.2 ; v2(106.85,154.49) 106.85,154.24 107.25,153.85 108.26,153.85 EC9724.2 109.27,153.93 EC9726.2 ; EC9702.2 v2(48.43,55.5) ; C3511.2 22.68,35.71 v2(22.31,36.09) ; R5526.2 80.1,167.78 v2(79.37,167.78) ; v2(57.35,31.27) 57.69,30.92 EC9701.2 ; v2(103.37,23.35) 103.19,23.54 C1312.2 ; v3(13.57,17.34) 13.65,17.26 ED304.2 ; v2(188.18,63.09) 188.09,63.19 C2426.2 ; C1303.2 139.35,19.59 v2(138.58,19.59) ; v2(158.58,52.89) 158.58,52.37 158.3,52.09 R6101.2 ; R502.2 R503.2 ; R502.2 R501.2 ; R502.2 124.29,72.26 v2(123.52,71.48) ; C1307.2 141.23,25.29 v2(141.42,25.1) ; v2(20.62,13.37) 21.06,13.8 C2704.1 ; v2(111.48,23.43) 111.22,23.69 C1315.2 ; v2(48.92,69.38) 48.98,69.44 EC6505.2 ; D4304.1 151.79,167.38 152.2,166.97 EC4306.1 152.25,166.36 v2(152.25,165.7) ; PC5106.2 49.93,26.9 v2(49.38,27.45) ; Q1901.S 141.81,60.28 142.37,60.28 v2(142.77,60.68) ; C718.2 122.55,77.19 v2(122.54,77.2) ; v2(138.65,18.26) 138.89,18.26 C1304.2 ; v2(195.28,146.14) 195.27,146.15 C7702.2 ; EC1803.1 127,63.9 126.98,63.89 R413.2 126.98,63.57 v2(126.58,63.17) 126.52,63.17 R412.2 ; EC9735.2 134.75,153.82 v2(134.76,153.83) ; C1221.2 84.53,31.41 v2(84.55,31.43) ; D502.1 148.26,65.86 v2(148.53,65.6) ; v2(80.16,162.73) 80.16,162.08 EC5502.2 ; R3107.2 53.08,167.06 v2(53.09,167.07) ; PC4531.2 v2(38.5,49.68) ; v2(31.31,13.58) 31.39,13.58 31.81,13.16 C2717.2 ; v2(88.98,32.43) 88.97,32.42 C1212.2 ; EC2501.2 139.22,53.78 139.12,53.88 v2(139.12,53.91) ; v2(112.52,164.24) 111.96,163.69 PC4401.1 ; v2(33.4,23.35) 33.39,23.35 R2717.2 ; D4306.1 159.92,166.43 EC4309.2 159.71,166.16 v2(159.27,166.16) ; R4211.2 R4209.2 v2(55.69,48.57) ; PC8309.2 148.46,36 v2(148.46,36.66) ; PR4302.2 114.17,173.17 ; PR4661.2 108.41,140.1 v2(109.45,140.1) ; v2(47.13,173.7) 47.16,173.72 C3101.2 ; EC9725.2 v2(199.35,45.01) ; v2(46.92,16.72) PC5103.2 PC5102.2 ; C3102.2 51.54,172.89 v2(51.97,172.46) ; EC9721.2 71.94,3.77 v2(71.69,4.02) ; v2(192.76,153.23) 192.79,153.2 R7511.2 193.44,153.23 R7508.2 ; v2(48.92,76.55) 48.93,76.55 EC6504.2 ; C7525.2 190.7,152.15 v2(190.7,152.15) ; v2(63.98,35.46) 63.72,35.19 63,35.19 C1305.2 ; PC4524.2 39.59,49.12 v2(39.59,49.12) ; v2(104.43,18.23) 104.43,18.07 104.51,17.99 C1316.2 ; v2(170.38,73.33) 169.39,73.33 168.81,73.92 168.81,76.63 169.43,77.25 170.06,77.25 170.09,77.27 EC1704.2 ; D1217.1 71.78,30.44 C1217.2 71.73,31.3 v2(71.91,31.48) ; R7912.1 182.08,161.6 C7923.2 183.09,160.92 v2(182.98,160.82) ; v2(48.77,72.1) 49.78,72.1 EC6506.2 ; R1501.2 134.45,93.92 v2(134.47,93.89) ; C2414.2 177.56,60.62 v2(177.88,60.94) 177.88,61.43 C2424.1 ; PC5408.2 41.64,17.95 41.34,17.65 PU5402.2 v3(38.87,17.65) ; ED305.2 17.25,16.7 16.65,17.31 v3(16.26,17.31) ; EC5501.2 83,162.08 v2(82.56,162.53) ; D4305.1 155.86,167.13 156.01,166.97 EC4310.2 v2(155.33,166.4) ; PR4530.2 34.93,59.08 v2(35.02,58.98) 35.02,58.28 PR4517.2 ; PC5407.2 40.86,20.62 v2(40.18,20.62) ; v2(108.38,22.8) 108.91,22.8 108.99,22.88 C1314.2 ; EC9202.1 176.25,126.5 v2(176.25,127.39) ; VGABD1.17 197.47,73.57 197.46,73.58 v2(196.88,73.58) ; PC4707.2 128.56,126.69 PC4708.2 128.6,125.79 v2(128.39,125.58) ; PC4519.2 35.06,50.82 v3(34.81,51.08) ; v2(132.86,65.74) 133.01,65.59 EC1802.2 ; R7506.2 203.54,154.68 R7512.2 203.12,153.8 v2(203.15,153.76) ; C1301.2 85.62,17.97 v2(85.27,18.32) ; v2(33.4,20.35) 33.46,20.29 C2719.2 ; PC1062.2 118.57,64.58 v2(117.92,65.23) ; v2(170.21,75.03) 171.4,75.03 C2410.2 ; v2(48.95,73.81) 49.01,73.88 EC6502.2 ; R2034.2 145.42,63.26 145.43,63.25 145.43,63.05 145.48,63.01 145.48,62.98 v2(145.41,62.98) ; v2(77.82,156.85) 77.82,156.39 80.22,153.99 C5540.2 ; EU3602.2 19.91,29.32 v3(19.71,29.49) ; v2(36.78,17.67) 35.98,17.67 EC2709.2 35.14,17.62 C2718.2 ; IRCCD1.7 90.69,155.07 90.5,154.87 v2(90.44,154.87) ; R2611.2 194.41,69.37 v2(194.79,68.99) ; v2(40.45,61.21) 40.47,61.2 40.47,61.19 40.57,61.08 PR4526.2 ; C2109.2 C2110.2 C2111.2 145.27,80.87 v2(145.54,81.13) ; v2(132.24,136.11) 132.54,136.4 PC5001.2 ; PR4451.2 v2(113.53,169.96) ; PR4531.2 42.29,60.32 v2(42.22,60.39) ; v2(105.38,62.97) 106.3,62.97 C719.2 ; v2(109.61,165.69) 109.66,165.64 PR4432.2 ; v2(41.02,78.12) 41.05,78.09 Q6505.S ; PC1060.2 119.69,72.6 v2(120.71,71.59) ; C7501.2 181.16,152.53 v2(181.12,152.57) ; v2(119.37,175.29) 119.49,175.18 PQ4304.E ; R4003.2 32.08,53.85 31.39,53.85 v2(31.34,53.9) ; C1313.2 105.95,21.82 106.26,21.52 v2(106.7,21.52) ; v2(115.35,93.61) 115.35,93.91 115.74,94.3 R720.2 ; v2(199.01,146.37) 199.13,146.26 C7506.2 ; PR4652.2 v2(117.8,139.55) ; v2(203.2,135.24) 203.17,135.27 203.17,136.33 R7627.2 ; v2(46.57,20.07) 46.32,19.81 PC5118.2 ; C2425.1 v2(178.81,64.26) ; R7507.1 200.79,152 v2(200.65,152.14) ; v2(196.98,115.99) 196.96,115.97 Q6501.S ; v2(182.29,58.38) 182.53,58.63 R2445.1 ; EC2708.2 v2(36.44,18.57) ; HDMI1.11 8.31,67.17
  TOP w0.635: 9,61.81 HDMI1.2 9.85,62.67 ; USB2.11 13,18.47 ; USB2.11 11.32,19.36 ; USB2.11 11.32,17.58 ; 166.46,180.85 BATT1.9 ; USB1.12 2.87,54.25 2.71,54.41 ; 8.25,75.26 HDMI1.21 ; HDMI1.21 8.25,72.65 ; HDMI1.21 9.98,73.92 ; 1.75,77.09 HDMI1.23 3.34,75.82 ; USB1.4 12.07,39.22 USB1.11 11.32,37.09 10.79,36.56 ; USB1.13 2.87,35.56 3.12,35.31 ; 4.36,16.06 3.4,17.02 USB2.13 2.2,17.02 1.39,16.21 ; 3.02,34.29 2.87,34.15 USB2.12 ; 10,65.67 HDMI1.8 ; USB1.7 11.28,44.87 ; USB1.7 10.57,45.58 ; USB1.7 10.57,44.16 ; 11.32,50.38 USB1.10 ; USB1.10 11.32,52.16 ; USB1.10 13,51.27 ; v2(190.98,22.65) 190.95,22.62 IOBD1.19 ; 10.89,33.02 11.32,32.6 USB2.10 ; BATT1.10 146.17,179.77 ; BATT1.10 144.08,179.77 ; BATT1.10 145.12,177.84 ; 10.61,59.42 HDMI1.20 ; HDMI1.20 8.25,60.99 ; HDMI1.20 8.25,57.99 ; 10.57,25.58 USB2.7 10.57,24.16 ; 12.07,20.66 USB2.4 12.07,22.08 ; 1.75,56.29 HDMI1.22 3.47,57.52 3.75,57.23 ; PC1061.2 115.41,73.91 v2(115.53,74.03)
  TOP w0.762: BATT1.7 151,179.02 ; BATT1.7 149.5,180.52 ; BATT1.7 149.5,179.02 ; BATT1.7 151,180.52 ; 219.96,145.95 219.96,145.56 HGPU2.1 218.82,140.96 218.82,138.16 ; BATT1.6 153,180.52 ; BATT1.6 151.5,179.02 ; BATT1.6 153,179.02 ; BATT1.6 151.5,180.52 ; BATT1.8 149,180.52 ; BATT1.8 147.5,179.02 ; BATT1.8 149,179.02 ; BATT1.8 147.5,180.52
  L3 w0.089: v2(199.83,140.6) 199.84,140.6 200.22,140.23 201.09,140.23 v2(201.44,140.58)
  L3 w0.127: v2(192.4,149.75) 192.4,149.72 192.79,149.33 195.19,149.33 v2(195.65,149.79)
  L3 w0.508: 8.16,69.94 7.93,70.17 HDMI1.17 ; HDMI1.5 8.27,64.17 ; 8.55,75.62 8.25,75.32 HDMI1.21 9.55,73.92 10.41,74.78 ; HDMI1.11 8.27,67.17 ; 1.6,77.27 1.75,77.12 HDMI1.23 3.42,75.82 3.63,76.03 ; 9.14,61.73 9,61.87 HDMI1.2 10.08,62.67 10.1,62.64 ; 10,65.69 9.98,65.67 HDMI1.8
  L3 w0.635: 4.26,16.16 3.4,17.02 USB2.13 2.2,17.02 1.42,16.24 ; 164.34,180.8 BATT1.9 166.38,180.78 ; USB1.10 11.32,52.16 ; USB1.10 11.32,50.38 ; USB1.10 13,51.27 ; USB1.11 13,38.47 ; USB1.11 11.32,37.58 ; USB1.11 11.32,39.36 ; 8.28,61.07 8.25,61.04 HDMI1.20 ; 11.32,30.38 USB2.10 ; USB2.10 11.32,32.16 ; USB2.10 13,31.27 ; 3.17,35.39 2.87,35.69 USB1.13 ; 3.14,34.35 2.87,34.07 USB2.12 ; HDMI1.20 8.25,57.87 8.38,57.74 ; HDMI1.20 10.33,59.42 10.36,59.39 ; USB1.12 2.87,54.15 2.59,54.44 ; 12.07,40.66 USB1.4 ; USB1.4 12.07,42.08 ; USB1.4 12.78,41.37 ; USB1.7 10.57,45.58 ; USB1.7 10.57,44.16 ; USB1.7 11.28,44.87 ; 11.32,17.58 USB2.11 ; USB2.11 11.32,19.36 ; USB2.11 13,18.47 ; 1.93,56.01 1.75,56.19 HDMI1.22 3.67,57.52 4.03,57.15 ; USB2.4 12.78,21.37 ; USB2.4 12.07,20.66 ; USB2.4 12.07,22.08 ; 10.57,24.16 USB2.7 ; USB2.7 11.28,24.87 ; USB2.7 10.57,25.58 ; 146.21,180.85 BATT1.10 144.02,180.88
  L3 w0.762: 147.5,180.52 BATT1.8 149,180.52 ; 151,180.52 BATT1.7 149.5,180.52 ; 151.5,180.52 BATT1.6 153,180.52
  L4 w0.089: v2(201.44,140.58) 201.35,140.58 201,140.23 200.26,140.23 199.88,140.6 v2(199.83,140.6)
  L4 w0.508: 9,61.84 HDMI1.2 10,62.67 ; HDMI1.17 8.26,70.17 ; HDMI1.11 8.22,67.17 ; HDMI1.5 8.27,64.17
  L4 w0.635: 11.32,52.33 USB1.10 ; 9.88,73.92 HDMI1.21 8.25,75.29 8.4,75.44 ; USB2.11 11.32,19.36 ; USB2.11 11.32,17.58 ; USB2.11 13,18.47 ; USB2.7 11.28,24.87 ; USB2.7 10.57,24.16 ; USB2.7 10.57,25.58 ; 9.95,65.67 HDMI1.8 8.27,65.67 ; 166.42,179.77 BATT1.9 164.33,179.77 ; 146.17,179.77 BATT1.10 144.08,179.77 ; 1.21,16.03 2.2,17.02 USB2.13 3.4,17.02 4.24,16.18 ; 3.86,75.93 3.75,75.82 HDMI1.23 1.75,77.2 1.77,77.22 ; USB2.12 2.87,34.07 3.14,34.35 ; 12.07,20.66 USB2.4 ; USB2.4 12.07,22.08 ; USB2.4 12.78,21.37 ; 10.36,59.08 10.02,59.42 HDMI1.20 8.25,57.66 8.33,57.59 ; 11.32,30.38 USB2.10 ; USB2.10 11.32,32.16 ; USB2.10 13,31.27 ; 3.14,35.41 2.87,35.69 USB1.13 ; 2.87,54.25 USB1.12 ; USB1.4 12.07,39.22 USB1.11 11.32,37.19 10.79,36.66 ; 10.57,44.16 USB1.7 10.57,45.58 ; 3.7,57.36 3.54,57.52 HDMI1.22 1.75,56.11 2,55.86
  L4 w0.762: BATT1.7 151,179.02 ; BATT1.7 149.5,180.52 ; BATT1.7 151,180.52 ; BATT1.7 149.5,179.02 ; 147.5,180.52 BATT1.8 ; BATT1.8 149,179.02 ; BATT1.8 147.5,179.02 ; BATT1.8 149,180.52 ; 151.5,180.52 BATT1.6 ; BATT1.6 151.5,179.02 ; BATT1.6 153,179.02 ; BATT1.6 153,180.52
  L4 w1.016: 219.78,142.57 219.67,142.69 HGPU2.1
  BOTTOM w0.089: CPU1.L2 134.96,89.36 135.21,89.36 135.28,89.32 135.48,89.32 135.6,89.37 135.65,89.39 136.94,89.39 v2(137.09,89.54)
  BOTTOM w0.102: CPU1.G5 133.41,91.41 133.41,91.88 CPU1.F4 ; CPU1.T21 123.65,86.33 123.65,87.09 CPU1.P21
  BOTTOM w0.127: v2(93.9,77.07) 93.92,77.07 94.06,77.21 95.91,77.21 CPU1.AP70 ; CPU1.BB26 121.56,72.12 121.66,72.02 121.66,70.39 122.22,69.83 122.22,68.39 v2(121.24,67.4) ; v2(122.79,88.55) 123.51,88.55 123.56,88.5 123.81,88.5 124.12,88.81 CPU1.L20 ; v2(120.71,71.59) 120.61,71.68 120.61,73.29 CPU1.BA28 ; v2(114.17,70.52) 114.23,70.58 CPU1.BB38 ; v2(125.28,77.85) 124.96,78.17 CPU1.AN20 ; v2(119.56,70.29) 119.21,70.64 CPU1.BB30 ; CPU1.AM71 95.4,78.6 93.84,78.6 v2(93.67,78.78) ; GPU1.AF8 181.02,137.71 v2(180.97,137.76) ; CPU1.BB67 97.5,72.21 97.01,71.73 96.68,71.73 v2(96.53,71.59) ; CPU1.AG71 94.6,81.27 94.24,81.64 92.83,81.64 92.4,81.2 91.16,81.2 v2(90.7,80.74) ; CPU1.AW26 121.18,74.73 121.15,74.76 120.85,74.76 120.82,74.73 CPU1.AW28 ; CPU1.AT68 97.36,76.65 97.39,76.68 97.39,76.97 97.36,77 CPU1.AP68 ; CPU1.AW62 101.12,74.73 101.15,74.76 101.44,74.76 101.47,74.73 CPU1.AW60 ; CPU1.Y20 CPU1.Y21 123.53,84.46 123.53,83.94 CPU1.AB21 ; v2(114.31,92.03) 114.32,92.04 114.32,92.58 114.44,92.7 115.03,92.7 115.42,93.09 CPU1.D34 ; CPU1.AW32 117.91,74.76 118.68,74.76 118.71,74.73 CPU1.AW30 ; v2(93.86,75.78) 94.08,75.78 94.56,76.26 CPU1.AT71 ; CPU1.B34 115.89,94.48 115.89,95.31 117.25,96.67 117.25,97.16 117.39,97.3 117.39,97.5 118.2,98.31 118.2,99.91 118.77,100.48 v2(118.77,102.74) 118.39,102.74 118.27,102.87 118.27,106.59 118.39,106.71 122.61,106.71 122.74,106.59 122.74,103.37 C1802.1 ; v2(102.72,68.38) 102.81,68.47 102.81,69.09 104.46,70.74 CPU1.BB55 ; v2(101.63,71.51) 101.69,71.57 101.69,72.61 CPU1.BB60 ; CPU1.BB64 99.51,71.84 v2(99.54,71.81) ; CPU1.BB34 116.58,71.12 117.01,70.69 117.01,69.19 116.8,68.98 116.8,67.6 116.65,67.45 116.65,67.09 ; R734.2 119.58,99.08 119.39,98.89 119.39,97.29 118.11,96.01 v2(118.11,95.93) ; v2(111.48,71.51) 111.63,71.66 CPU1.BB43 ; CPU1.N19 124.79,87.97 124.47,88.29 124.22,88.29 123.91,87.97 CPU1.N21 ; v2(122.11,101.96) 122.11,101.94 v2(119.91,99.75)
  BOTTOM w0.152: v2(105.17,91.3) 105.17,91.06 105.49,90.74 105.76,90.74 105.97,90.95 106.43,90.95 CPU1.G52 ; CPU1.AN20 CPU1.AP20 ; CPU1.AW34 117.02,74.73 117.07,74.79 117.42,74.79 117.48,74.73 CPU1.AW32 ; CPU1.AW26 121.97,74.73 122.08,74.84 122.32,74.84 122.42,74.73 CPU1.AW23 123.19,74.41 123.19,73.83 CPU1.BA23
  BOTTOM w0.178: CPU1.G66 98.05,91.03 97.87,90.85 97.87,90.83 97.67,90.63 97.67,90.61 97.66,90.59 97.66,90.31 97.67,90.3 CPU1.K67 ; CPU1.AM61 101.18,78.95 101.84,78.95 CPU1.AM60 ; CPU1.N6 133.38,88.57 133.38,89.2 CPU1.L4 ; CPU1.P21 123.73,87.18 124.29,87.18 CPU1.P20 CPU1.P19 125.08,87.13 125.5,87.55 125.86,87.55 125.89,87.53
  BOTTOM w0.203: CPU1.AR52 106.22,77.19 v2(106.03,77.19) ; CPU1.AW49 108.04,74.26 v2(107.89,74.11) ; CPU1.AW49 108.42,74.73 108.46,74.77 109.2,74.77 CPU1.AW47 ; CPU1.AW49 107.74,74.73 CPU1.AW50 ; CPU1.AT42 CPU1.AR42 CPU1.AP42 ; U6701.6 171.69,95.53 171.37,95.86 v2(171.11,95.86) ; CPU1.AK27 120.25,79.97 120.16,80.07 v2(119.84,80.07) ; v2(136.11,76.66) 136.11,76.65 135.06,76.65 134.74,76.33 CPU1.AT2 ; CPU1.F2 CPU1.F1 135.62,92.47 135.86,92.47 136.14,92.75 136.14,92.98 v2(136.19,93.03) ; CPU1.AR43 111.04,76.87 110.66,77.25 110.64,77.23 110.64,77.23 v2(110.63,77.22) 110.29,76.87 CPU1.AR45 ; CPU1.L18 CPU1.L17 ; CPU1.AR58 102.88,76.3 ; CPU1.AV68 97.37,75.46 97.4,75.49 97.4,75.75 97.36,75.79 CPU1.AT68 ; v2(105.8,74.04) 105.64,74.2 CPU1.AW53 105.18,74.73 105.17,74.75 104.88,74.75 104.86,74.73 CPU1.AW55 ; v2(127.88,128.48) 127.87,128.46 PU4701.5 ; CPU1.G43 110.98,91.06 110.86,90.94 110.45,90.94 110.33,91.06 CPU1.G45 ; CPU1.AW18 CPU1.BA18 CPU1.BB18 ; 114.11,74.75 112.95,74.75 CPU1.AW41 ; CPU1.AW12 128.96,75.87 v2(128.94,75.9) ; U6701.7 172.25,95 172.77,95.52 v2(173,95.52) ; CPU1.AW41 112.93,74.61 113.22,74.31 113.22,74.26 113.26,74.22 113.26,73.95 113.25,73.93 113.25,73.84 113.19,73.78 ; CPU1.AW41 112.56,75.1 112.21,75.1 111.84,74.73 CPU1.AW43 111.69,74.77 110.92,74.77 110.88,74.73 CPU1.AW45 110.45,74.14 v2(110.45,74.13) ; v2(127.85,96.15) 127.66,95.95 127.66,95.2 127.59,95.14 127.59,94.52 127.91,94.2 CPU1.B14 ; CPU1.AW62 v2(100.68,74.13) ; CPU1.AK11 129.27,79.3 129.03,79.3 v2(128.91,79.18) ; CPU1.AN63 99.64,78.67 CPU1.AL64 100.29,79.58 CPU1.AK63 100.41,79.91 100.41,80.44 100.29,80.56 CPU1.AH63 ; CPU1.AN63 CPU1.AP63 CPU1.AR63 ; CPU1.AN63 100.79,78.82 CPU1.AM61 ; CPU1.AR46 109.02,76.62 108.62,76.62 CPU1.AR48 108.37,76.91 108.03,77.24 v2(107.92,77.24) 107.79,77.24 107.45,76.9 CPU1.AR50 ; CPU1.D45 109.59,93.13 109.26,92.8 109.26,92.38 CPU1.E46 ; CPU1.AH13 127.89,80.7 127.62,80.43 CPU1.AJ15 ; CPU1.AP20 CPU1.AR20 ; CPU1.AM21 123.91,79.36 CPU1.AK21 123.47,79.8 123.04,79.8 CPU1.AK22 122.95,79.76 v2(121.89,80.82) ; v2(173.01,94.88) 173.01,94.22 172.79,94.01 U6701.8 ; v2(94.61,89.28) 94.79,89.46 95.36,89.46 CPU1.K71 CPU1.K70 ; CPU1.AW38 114.6,74.73 114.64,74.77 114.95,74.77 114.99,74.73 CPU1.AW36 115.41,74.15 v2(115.53,74.03) ; 125.89,87.53 CPU1.P17 ; CPU1.AM27 120.32,78.82 120.44,78.95 120.9,78.95 121.02,78.82 CPU1.AM25 ; v2(171.11,95.14) 171.19,95.05 U6701.5 ; CPU1.K16 126.88,89.65 126.49,90.04 126.25,90.04 125.88,90.41 CPU1.H18 125.64,90.31 CPU1.K18 ; 108.61,162.38 PU4401.22 ; CPU1.G6 132.04,91.06 131.68,91.43 131.51,91.43 CPU1.F8 131.09,91.71 v2(130.77,91.39) ; CPU1.E18 125.86,92.36 126.28,92.78 126.87,92.78 127.16,92.49 127.44,92.49 CPU1.E15
  BOTTOM w0.229: 127.76,82.53 128.06,82.84 CPU1.AD13
  BOTTOM w0.254: CPU1.L18 125.64,88.62 CPU1.N19 ; v2(104.31,92.77) 103.9,92.36 CPU1.E56 103.13,93.02 CPU1.D58 CPU1.B58 ; CPU1.V18 124.99,84.81 CPU1.Y19 CPU1.Y20 ; v2(106.03,77.19) 105.93,77.19 CPU1.AR53 105.54,76.79 104.79,76.79 CPU1.AR55 104.64,76.87 104.49,76.73 104.49,76.73 v2(104.3,76.54) 104.17,76.54 103.85,76.22 CPU1.AT56 103.66,76.22 v2(103.34,75.9) 103.01,76.22 CPU1.AT58 102.88,76.3 ; v2(185.71,144.72) 186.09,145.1 GPU1.AB17 ; v2(122.65,21.41) 122.52,21.27 122.15,21.27 121.72,21.7 121.72,23.55 121.55,23.73 DM2.139 ; CPU1.AR20 124.74,76.79 124.74,76.31 CPU1.AT20 ; CPU1.U63 100.29,86.06 v2(99.96,85.74) 99.96,85.75 99.64,86.08 CPU1.U64 ; v2(99.31,87.57) 99.31,87.7 CPU1.N65 ; GPU1.B11 202.47,140.19 202.05,140.61 201.68,140.61 201.65,140.58 v2(201.44,140.58) ; VRAM1.E1 204.73,165.5 204.73,165.51 v2(204.94,165.72) ; VRAM3.E8 204.55,166.1 v2(204.94,165.72) ; CPU1.AM55 104.71,78.84 CPU1.AL55 ; DM1.25 70.45,35.39 71.3,34.54 v2(71.87,34.54) ; v2(107.9,92.61) 107.9,91.44 v2(107.85,91.39) ; v2(107.9,92.61) 107.7,92.61 CPU1.E50 107.44,92.36 v2(107.07,92.73) 107.07,92.73 105.97,92.73 CPU1.D53 105.86,93.35 105.86,93.77 105.61,94.02 CPU1.B53 ; v2(107.9,92.61) 108.09,92.79 CPU1.D48 108.09,93.39 v2(108.29,93.59) ; v2(115.53,74.03) 115.53,73.89 115.41,73.77 CPU1.BA36 ; v2(204.94,165.72) 205.33,165.32 VRAM1.D1 ; CPU1.AG21 123.77,81.18 124.25,81.18 CPU1.AG20 CPU1.AG19 CPU1.AG18 CPU1.AG17 CPU1.AG16 127.59,81.91 CPU1.AF15 ; CPU1.F35 115.38,92.01 115.06,92.01 CPU1.F37 ; CPU1.F32 117.38,91.71 117.21,91.54 116.82,91.54 116.65,91.71 CPU1.F33 ; CPU1.F32 117.83,92.04 v2(117.97,92.04) 118,92.07 CPU1.D30 CPU1.B30 117.67,94.44 117.67,94.62 117.66,94.63 117.66,94.89 117.67,94.9 117.67,95.48 v2(118.11,95.93) ; CPU1.F32 117.83,91.39 v2(117.97,91.39) ; CPU1.AN35 115.36,77.85 v2(115.22,77.85) 115.09,77.85 CPU1.AN37 ; v2(131.37,88.63) 131.37,88.73 131.68,89.05 CPU1.L8 ; CPU1.AR46 CPU1.AR45 ; CPU1.AJ20 124.76,80.01 125.22,80.01 CPU1.AK18 CPU1.AJ18 126.06,80.01 126.52,80.01 CPU1.AK16 127.47,80.12 127.47,80.31 CPU1.AJ15 ; CPU1.D47 108.74,93.13 v2(108.29,93.59) ; CPU1.AW8 131.21,74.73 v2(130.85,75.1) 130.37,75.57 CPU1.AU10 130.15,75.41 CPU1.AW10 v2(130.15,74.1) CPU1.BA10 ; v2(98.01,85.74) 98.01,85.87 CPU1.U67 ; CPU1.L17 126.42,88.81 126.46,88.84 126.85,88.84 126.88,88.81 CPU1.L16 CPU1.K16 127.18,89.89 127.18,90.02 CPU1.H15 ; v2(110.45,74.13) 110.45,74.13 CPU1.BA45 ; v2(94.63,90.76) 94.74,90.87 CPU1.H71 ; 113.19,73.78 113.19,73.77 CPU1.BA41 ; CPU1.AM60 102.1,78.82 v2(102.42,78.5) 102.55,78.5 CPU1.AN58 ; CPU1.K61 100.93,90.13 100.62,90.44 v2(100.62,90.67) 100.54,90.67 CPU1.G63 ; CPU1.D10 130.35,93.13 CPU1.D11 129.71,92.68 CPU1.E11 ; v2(132.81,18.23) 132.81,18.13 133.25,17.69 DM2.178 ; CPU1.BA62 v2(100.68,74.13) ; CPU1.D69 97.3,92.74 97.33,92.71 97.75,92.71 97.88,92.84 97.93,92.84 CPU1.D66 CPU1.B66 ; CPU1.D69 96.36,92.74 v2(96.26,92.64) ; CPU1.D69 CPU1.F68 ; CPU1.AN30 118.75,77.85 v2(118.88,77.85) ; v2(98.66,85.74) 98.66,85.87 CPU1.U66 ; CPU1.AH63 100.29,80.86 v2(99.98,81.17) ; CPU1.U10 130.16,85.81 v2(130.16,85.5) 129.53,85.5 v2(129.52,85.51) ; DM1.162 113.95,30.75 113.92,30.79 113.92,31.66 113.94,31.68 113.94,33.13 113.64,33.43 v2(113.24,33.43) ; CPU1.AA4 CPU1.AA2 ; CPU1.AF10 130.75,81.41 130.75,81.28 v2(130.75,81.28) ; v2(130.02,83.39) 130,83.4 v2(129.37,83.4) v2(128.69,83.4) 128.69,83.1 CPU1.AD13 128.43,82.67 v2(128.81,82.3) 129.41,82.3 v2(129.44,82.33) ; CPU1.AN58 103.34,78.63 CPU1.AL58 ; CPU1.AN58 102.96,78.09 102.96,77.6 CPU1.AP58 102.94,77.46 102.94,77.05 102.88,76.99 CPU1.AR58 ; CPU1.F28 118.88,91.25 CPU1.J28 ; CPU1.F28 119.21,91.71 v2(118.88,92.04) ; CPU1.F28 119.4,91.71 119.73,92.04 v2(119.79,92.04) 119.88,92.04 120.2,91.71 CPU1.F27 ; v2(97.36,83.91) 97.36,84.04 CPU1.AA68 ; v2(113.5,89.76) 113.5,89.78 113.39,89.89 CPU1.J38 ; CPU1.R6 133.59,87.1 CPU1.T4 CPU1.T2 ; CPU1.R6 CPU1.N6 ; CPU1.R6 132.99,86.77 v2(132.78,86.57) ; CPU1.AP42 111.93,77.52 v2(111.61,77.84) 111.94,78.17 CPU1.AN42 111.69,78.51 v2(111.55,78.51) ; CPU1.F22 122.86,91.71 122.54,91.39 ; v2(130.77,77.2) 130.77,77.19 130.9,77.19 CPU1.AR8 ; CPU1.AD62 100.12,82.99 99.67,82.54 CPU1.AE64 99.53,82.64 99.09,82.64 CPU1.AE65 98.87,82.66 98.46,82.66 CPU1.AE66 98.23,82.64 97.79,82.64 CPU1.AE67 CPU1.AE68 CPU1.AE69 ; CPU1.AP32 117.33,77.52 v2(117.03,77.82) 117.16,77.82 CPU1.AN32 ; CPU1.F13 128.39,91.71 127.74,92.36 CPU1.E15 127.57,92.6 127.91,92.94 CPU1.D14 127.78,93.22 127.78,93.98 CPU1.B14 ; CPU1.AM68 97.75,79.11 ; 97.75,79.11 97.75,79.13 97.27,79.62 97.27,79.71 CPU1.AK68 ; 97.75,79.11 98.16,79.11 CPU1.AL66 CPU1.AL65 99,78.91 99.11,78.91 99.17,78.85 99.56,78.85 99.61,78.91 99.62,78.91 CPU1.AL64 ; CPU1.AD21 123.72,82.97 124.3,82.97 CPU1.AD20 124.43,83.03 124.9,83.03 CPU1.AD19 125.41,82.52 125.87,82.52 CPU1.AF17 ; v2(31.46,176.18) 31.46,176.18 U3202.3 U3202.8 ; v2(108.29,93.59) 108.09,93.79 CPU1.B48 ; CPU1.BA49 108.04,73.94 107.93,74.05 107.93,74.07 v2(107.89,74.11) ; v2(118.88,77.85) 119.21,77.52 CPU1.AP28 119.28,77.46 119.28,76.93 CPU1.AR28 CPU1.AT28 ; v2(118.88,77.85) 119.01,77.85 CPU1.AN28 ; 122.41,77.2 CPU1.AR23 122.02,76.81 122.02,76.28 CPU1.AT23 121.6,75.74 121.6,75.17 121.66,75.11 CPU1.AW26 ; 122.41,77.2 v2(122.54,77.2) ; 122.41,77.2 122.4,77.2 CPU1.AP23 121.99,77.61 121.99,78.09 CPU1.AN23 ; CPU1.BA57 103.16,73.94 v2(103.01,74.09) 103.16,74.24 CPU1.AW57 ; CPU1.AV1 136.38,74.94 v2(136.68,74.63) ; v2(99.98,81.17) 100.29,81.48 CPU1.AF63 ; v2(99.98,81.17) 99.93,81.13 99.93,81.01 CPU1.AH64 ; v2(130.77,77.85) 130.64,77.85 CPU1.AP10 ; CPU1.AR11 129.72,77.2 v2(129.85,77.2) ; CPU1.AM8 131.55,79.15 v2(131.68,79.15) CPU1.AK8 ; v2(91.35,21.12) 91.61,21.12 92.29,21.8 92.29,23.82 92.15,23.95 DM2.49 ; CPU1.F42 112.16,91.71 v2(112.49,91.39) 112.56,91.39 112.89,91.71 CPU1.F40 ; CPU1.K70 96.16,89.62 CPU1.K68 97.46,89.62 CPU1.K67 CPU1.K66 CPU1.K65 99.06,89.92 99.52,89.92 CPU1.K64 99.69,89.89 100.2,89.89 CPU1.K63 ; CPU1.AW16 126.54,74.9 v2(126.19,75.25) 126.09,75.25 125.57,74.73 CPU1.AW18 125.31,75.09 CPU1.AU20 124.12,74.87 CPU1.AW21 ; v2(121.18,21.57) 120.55,21.57 119.79,22.34 119.79,23.92 119.75,23.97 DM2.133 ; CPU1.AK69 CPU1.AK68 ; CPU1.AK68 97.04,80.06 CPU1.AH67 97.69,80.82 v2(97.33,81.17) ; v2(111.56,91.37) 111.38,91.37 111.11,91.09 CPU1.G43 111.11,91.05 CPU1.J42 ; GPU1.AF5 181.63,135.22 181.32,134.91 181.03,134.91 v2(181.02,134.9) ; CPU1.AW53 106.06,74.73 106.1,74.77 106.4,74.77 106.45,74.73 CPU1.AW51 107.18,74.41 CPU1.AW50 ; v2(117.4,33.54) 117.29,33.54 116.71,32.97 116.71,31.88 116.89,31.7 116.89,31.33 116.95,31.27 DM1.172 ; CPU1.W9 130.69,84.63 130.69,84.4 130.69,84.4 v2(130.71,84.4) ; CPU1.E18 125.74,92.84 125.48,93.09 CPU1.D18 CPU1.B18 ; CPU1.AP38 113.72,77.52 v2(113.39,77.85) ; CPU1.AW34 116.67,74.73 116.43,74.97 116.43,75.21 116.22,75.42 116.22,75.68 CPU1.AT35 115.5,76.4 115.5,76.7 CPU1.AR35 115.36,77.2 115.33,77.2 ; CPU1.BA14 v2(127.73,74.1) CPU1.AW14 ; CPU1.AW64 99.8,74.73 99.9,74.83 100.59,74.83 CPU1.AW62 100.68,75.35 100.63,75.4 100.63,75.73 CPU1.AT63 100.21,76.3 100.21,76.8 CPU1.AR63 ; v2(128.8,84.42) 128.8,84.52 128.43,84.89 CPU1.W13 ; GPU1.E17 200.31,145.15 200.73,144.73 v2(201.4,144.73) 202.04,144.73 202.46,145.15 GPU1.B17 ; CPU1.F27 120.71,91.25 CPU1.J25 ; CPU1.F27 120.67,92.13 120.67,92.63 120.48,92.82 CPU1.D26 120.52,93.13 CPU1.D25 ; 115.33,77.2 115.66,77.52 CPU1.AP35 ; 115.33,77.2 v2(115.22,77.2) ; v2(113.19,95.61) 113.38,95.43 113.38,94.96 113.39,94.95 113.39,94.63 113.38,94.62 113.38,94.44 CPU1.B39 113.04,93.75 v2(112.88,93.59) 113.04,93.42 CPU1.D39 ; CPU1.AW6 132.53,74.1 v2(132.51,74.07) 132.53,74.07 132.57,74.03 CPU1.BA6 CPU1.BB6 132.57,72.39 v2(132.72,72.24) ; v2(117.97,78.5) 117.97,78.5 CPU1.AL32 ; v2(94.5,92.78) 94.61,92.67 CPU1.E71 ; 122.54,91.39 122.54,91.39 ; 122.54,91.39 122.4,91.39 CPU1.F23 121.63,92.16 v2(121.63,92.75) 121.24,93.13 CPU1.D25 ; CPU1.A67 97.5,95.25 97.18,95.57 v2(97.18,95.74) ; CPU1.K22 122.95,90.18 122.95,91.02 CPU1.G22 ; v2(131.09,20.85) 131.45,20.48 DM2.172 ; CPU1.G58 102.75,91.06 v2(102.42,91.39) 102.29,91.39 CPU1.G60 ; v2(115.35,93.61) 115.35,93.94 CPU1.B34 ; v2(130.05,87.65) 130.38,87.98 CPU1.N10 ; CPU1.AF4 CPU1.AF2 CPU1.AF1 135.8,81.63 v2(136,81.43) ; CPU1.AN38 113.53,78.5 v2(113.39,78.5) 113.26,78.5 CPU1.AN40 ; v2(93.26,73.97) 93.4,74.1 94.2,74.1 94.96,74.87 CPU1.AV71 CPU1.AV70 CPU1.AV69 ; CPU1.AT2 CPU1.AT4 133.6,76.33 CPU1.AR5 ; CPU1.D6 132.84,93.25 133.37,93.78 CPU1.C5 ; DM2.25 84.95,24.09 84.54,23.68 84.54,22.31 v2(85.26,21.59) ; CPU1.AH6 133.21,80.47 133.21,80.43 133.38,80.26 133.52,80.26 v2(133.53,80.25) 133.56,80.22 133.56,80.08 133.76,79.88 CPU1.AJ4 CPU1.AL4 ; CPU1.D25 CPU1.C25 ; CPU1.J35 v2(115.22,89.74) ; CPU1.AW47 109.64,74.73 109.69,74.77 109.99,74.77 110.03,74.73 CPU1.AW45 ; CPU1.AV68 98.12,75.06 CPU1.AW66 98.31,74.21 CPU1.AY66 CPU1.BA66 ; CPU1.BA53 105.64,73.88 v2(105.8,74.04) ; CPU1.BA32 117.9,73.53 117.9,74.11 v2(117.95,74.15) 117.93,74.17 117.93,74.69 CPU1.AW32 117.88,75.2 CPU1.AU32 ; CPU1.N68 97.36,87.7 v2(97.36,87.57) ; CPU1.AM27 120.25,78.84 CPU1.AL28 119.8,79.3 CPU1.AK27 ; CPU1.R13 128.43,87.32 v2(128.74,87.62) 128.74,87.87 CPU1.N13 ; CPU1.AW38 114.11,74.75 114.11,75.31 CPU1.AU38 ; CPU1.B44 110.56,94.1 v2(110.56,93.6) 110.56,93.1 CPU1.D44 109.93,93.09 CPU1.D45 ; CPU1.AL38 v2(114.31,79.99) ; CPU1.L4 CPU1.L2 ; CPU1.AL35 v2(116.14,79.99) ; CPU1.J32 v2(117.05,89.76) ; DM2.31 86.75,24.97 86.75,24.96 86.75,23.82 86.75,23.81 86.75,23.75 86.52,23.53 86.52,22.38 87.6,21.31 v2(87.68,21.31) ; CPU1.B62 CPU1.D62 ; DM2.43 90.35,23.89 90.09,23.63 90.09,22.31 89.33,21.56 v2(89.15,21.56) ; CPU1.J13 128.54,89.76 128.76,89.54 129.17,89.54 CPU1.J11 ; CPU1.B22 CPU1.D22 ; CPU1.AD8 131.68,82.52 v2(131.47,82.31)
  BOTTOM w0.279: GPU1.U2 189.98,132.48 189.95,132.48 v2(189.84,132.37) ; v2(200.62,137.3) 200.62,137.34 GPU1.E8 ; VRAM4.B9 173.55,172.1 v2(173.36,172.29) ; GPU1.L2 195.25,132.77 v2(195.65,133.17) ; GPU1.B14 v2(203.46,142.67) ; v2(189.89,135.56) 189.89,135.55 190.27,135.17 GPU1.U5 ; GPU1.L23 195.27,150.17 195.65,149.79 v2(195.65,149.79) ; v2(192.76,153.23) 192.76,153.15 192.75,153.14 GPU1.P26 ; v2(204.21,131.35) 204.13,131.27 203.86,131.27 203.5,131.63 203.5,132.7 203.44,132.76 ; GPU1.B1 203.44,132.76 ; 203.44,132.76 GPU1.A2 ; v2(182.19,150.12) 182.85,150.12 GPU1.AF23 ; v2(198.13,134.77) 197.73,135.17 GPU1.H5 ; v2(183.14,172.4) 183.15,172.38 VRAM4.P9 ; v2(200.62,134.8) 200.2,135.22 GPU1.E5 ; GPU1.B8 202.83,137.53 v2(203.49,137.53) ; v2(200.64,148.88) 200.64,148.88 200.25,149.27 GPU1.E22 ; GPU1.B5 203.18,135.22 v2(203.2,135.24) ; GPU1.P2 192.75,132.74 192.35,132.35 v2(192.35,132.33) ; GPU1.P5 192.68,135.17 192.32,134.82 v2(192.32,134.8) ; v2(187.37,134.77) 187.77,135.17 GPU1.Y5 ; GPU1.B20 202.67,147.63 202.69,147.66 202.95,147.66 203.04,147.57 203.78,147.57 203.83,147.53 203.83,147.5 v2(203.83,147.5) ; GPU1.AG2 181.82,132.54 181.82,131.9 v2(181.9,131.82) 181.9,131.82 182.7,131.82 GPU1.AF1 ; GPU1.AE17 GPU1.AF17 182.85,145.1 v2(182.44,144.7) ; GPU1.E20 200.62,147.26 200.62,147.25 v2(200.63,147.24) ; VRAM4.P1 183.15,164.93 v2(182.93,164.71) ; VRAM4.B1 173.55,164.91 v2(173.37,164.73) ; GPU1.U26 190.29,152.57 190.7,152.17 v2(190.7,152.15) ; GPU1.B27 202.69,153.37 203.09,153.76 v2(203.15,153.76) 203.45,153.47 203.45,153.47 203.65,153.26 203.65,152.82 203.45,152.62 GPU1.A26 ; GPU1.Y23 187.79,150.17 v2(187.38,149.76) ; v2(184.86,135.64) 185.29,135.22 GPU1.AC5 ; v2(192.4,149.75) 192.41,149.76 192.41,149.84 192.74,150.17 GPU1.P23 ; GPU1.AC8 v2(185.67,137.29) GPU1.AB7 186.25,136.71 186.79,136.71 GPU1.AA7 ; v2(181.12,152.57) 181.17,152.57 181.17,152.57 GPU1.AG26 ; v2(173.13,169.71) 173.13,169.77 173.48,170.12 VRAM2.B3 ; v2(197.31,151.34) 197.31,151.35 197.71,151.75 GPU1.H25 ; GPU1.AB24 186.09,150.97 v2(185.72,150.6) ; VRAM3.T9 195.16,165.32 v2(195.16,165.32) ; GPU1.B23 202.67,150.1 203.73,150.1 v2(203.84,150.2) ; VRAM3.T1 195.73,171.74 v2(195.16,171.74) ; v2(181.29,172.36) 181.55,172.1 VRAM4.M9 ; GPU1.U23 190.27,150.15 189.89,149.77 189.89,149.72 v2(189.89,149.72) ; VRAM4.T9 185.28,171.72 v2(185.35,171.79) ; VRAM3.M1 198.95,172.18 v2(198.86,172.27) ; GPU1.AC26 185.3,152.67 v2(184.93,153.04) ; v2(197.42,172.45) 197.35,172.38 VRAM3.P1 ; VRAM3.B1 206.95,171.97 207.23,172.26 v2(207.3,172.26) 207.3,172.17 VRAM1.A9 ; v2(185.68,140.61) 186.09,140.2 GPU1.AB11 ; VRAM4.M1 181.55,164.89 v2(181.67,164.77) ; v2(195.61,152.17) 195.59,152.15 195.57,152.15 195.23,151.81 GPU1.L25 ; v2(188.19,132.37) GPU1.Y2 ; v2(185.29,165.31) 185.28,165.32 VRAM4.T1 ; GPU1.AE14 183.65,142.69 v2(183.25,143.09) 182.85,142.69 GPU1.AF14 ; GPU1.AC22 GPU1.AD22 v2(184.05,148.87) GPU1.AD21 ; v2(184.9,132.33) 184.9,132.33 185.3,132.73 GPU1.AC2 ; v2(195.65,134.77) 195.25,135.17 GPU1.L5 ; v2(188.17,152.18) 187.79,152.56 GPU1.Y26 ; v2(198.06,149.75) 198.04,149.77 198.04,149.81 197.71,150.13 GPU1.H23 ; VRAM3.P9 v2(197.35,164.74)
  BOTTOM w0.305: v2(198.56,164.91) 198.95,165.3 VRAM3.M9 ; v2(124.13,36.69) 123.85,36.97 DM1.195 ; 161.26,69.22 161.26,68.33 160.85,67.92 Q1702.4 ; 161.26,69.22 161.26,69.32 160.75,69.83 v2(160.01,69.83) ; 161.26,69.22 Q1702.1 ; v2(79.49,22.78) 79.49,23.29 80.15,23.95 DM2.9 ; CPU1.F22 123.32,92.04 v2(123.45,92.04) 123.58,92.04 CPU1.E21 123.62,92.65 123.39,92.65 CPU1.D22 ; DM1.13 66.85,36.72 v2(66.81,36.67) ; CPU1.F35 115.74,91.71 115.9,91.87 116.44,91.87 CPU1.F33 ; VRAM1.G8 202.96,170.92 v2(203.35,171.32) ; DM1.179 119.05,36.83 v2(119.18,36.71) ; EC5504.2 89.76,148.65 v2(90.39,148.01) ; v2(157.69,61.69) 157.94,61.43 159.49,61.43 159.57,61.52 WLAN1.7 161.72,61.52 162.13,61.94 162.13,62.98 ; CPU1.U70 95.74,86.06 v2(96.06,85.74) ; CPU1.F37 114.46,92.02 114.32,92.02 v2(114.31,92.03) 114.17,92.03 CPU1.F38 CPU1.F40 ; v2(202.54,165.7) 202.93,165.32 VRAM3.G9 ; DM1.170 116.35,31.35 116.1,31.61 116.1,32.4 115.79,32.71 v2(115.51,32.71) ; DM1.138 106.75,31.32 v2(106.58,31.49) 106.15,31.06 DM1.136 ; v2(201.76,166.5) 201.38,166.12 VRAM3.J8 ; v2(188.47,23.48) 188.65,23.66 HDD1.1 ; v2(123.65,18.89) 123.4,18.89 123.05,18.54 DM2.144 ; v2(70.64,32.76) 70.91,32.76 71.29,32.38 71.29,31.09 71.35,31.02 DM1.28 ; DM1.196 124.15,31.14 124.32,31.31 124.32,33.02 123.98,33.36 v2(123.5,33.36) ; WLAN1.39 162.32,53.52 v2(162.56,53.76) ; DM1.48 77.35,31.37 v2(77.29,31.43) ; WLAN1.23 159.36,57.52 v2(159.17,57.33) ; CPU1.AE69 96.06,82.86 v2(95.85,82.86) ; DM1.150 110.35,31.27 v2(110.08,31.54) ; v2(100.57,92.06) 100.57,92.69 100.65,92.77 CPU1.D62 ; v2(117.5,147.69) 116.79,146.98 PG4601.2 ; 118.35,19.57 118.32,19.55 118.32,18.05 118.25,17.98 DM2.128 ; DM1.37 74.05,35.48 73.02,34.45 v2(72.9,34.45) ; v2(179.55,170.54) 179.17,170.92 VRAM4.J8 ; DM1.134 v2(105.55,31.44) ; DM1.71 84.25,36.07 83.8,35.62 v2(83.64,35.62) ; VRAM2.A9 172.58,165.32 v2(172.16,164.89) ; DM2.196 v2(138.65,18.26) ; DM2.153 125.75,23.85 125.41,23.5 v2(125.21,23.5) 125.15,23.56 DM2.151 ; DM1.49 77.65,37.29 78.06,36.88 78.06,35 77.16,34.1 v2(76.68,34.1) ; VRAM2.E1 v2(175.53,171.32) ; v2(175.53,171.32) VRAM4.E8 ; v2(175.53,171.32) VRAM2.D1 ; DM1.153 111.25,36.69 111.49,36.45 ; v2(128.8,81.27) 128.8,81.15 128.43,80.78 CPU1.AH13 ; v2(136.85,18.23) 136.85,17.99 136.85,17.39 136.85,17.39 136.85,16.77 DM2.190 ; v2(158.58,52.89) 159.45,52.02 WLAN1.45 ; DM1.2 63.55,31.03 63.17,31.41 63.17,32.61 64.08,33.52 v2(64.35,33.52) ; U9101.32 163.19,27.18 162.99,27.39 v2(162.99,27.74) ; R1715.2 154.4,73.91 154.8,73.51 Q1701.4 155.4,72.94 155.55,73.08 EC1703.2 C1701.2 ; DM1.189 122.05,35.81 121.6,35.36 v2(121.39,35.36) ; WLAN1.57 161.98,49.02 v2(162.23,48.77) ; v2(125.28,77.85) 125.61,77.52 CPU1.AP18 ; DM1.19 68.65,37.02 v2(69,36.67) ; v2(130.77,90.08) 131.09,89.76 CPU1.J8 131.68,89.3 CPU1.L8 ; DM2.13 81.35,23.55 81.03,23.23 81.03,22.17 v2(81.29,21.91) ; GPU1.E25 200.28,151.77 v2(200.65,152.14) ; CPU1.U69 96.71,85.87 v2(96.71,85.74) ; VRAM4.G9 v2(177.91,171.31) ; U9101.9 168.66,28.07 v2(169.08,28.49) ; v2(107.85,91.39) 108.18,91.06 CPU1.G48 ; v2(153.98,95.66) 153.68,95.36 THM26.5 ; DM1.145 108.85,36.91 v2(108.62,36.68) ; v2(80.88,34.73) 81.14,34.73 81.67,35.26 81.67,36.78 ; v2(106.85,154.49) 106.83,154.49 106.59,154.73 PR4409.2 PC4413.2 ; 81.67,36.78 81.25,37.19 DM1.61 ; 81.67,36.78 81.85,36.96 DM1.63 ; 95.75,23.37 v2(96.15,22.98) 96.35,23.18 DM2.63 ; DM1.11 66.25,37.16 66.21,37.12 66.21,35.75 65.83,35.37 v2(65.35,35.37) ; DM1.151 110.65,36.4 110.28,36.03 v2(110.07,36.03) ; v2(112.11,31.56) 112.16,31.51 112.16,30.64 112.15,30.63 112.15,29.97 DM1.156 ; v2(162.24,47.53) 162.19,47.52 WLAN1.63 ; DM1.155 111.85,37.28 111.75,37.18 111.75,36.71 111.49,36.45 ; v2(71.88,36.71) 71.88,36.71 72.01,36.71 72.25,36.94 DM1.31 ; v2(119.93,33.48) 119.45,33.48 118.75,32.78 DM1.178 ; v2(123.65,20.21) 123.88,20.21 124.84,19.25 124.84,17.4 124.85,17.39 124.85,16.77 DM2.150 ; DM1.133 105.25,38.17 105.25,37.52 105.24,37.51 105.24,37.24 105.15,37.15 105.15,36.19 104.94,35.98 v2(104.47,35.98) ; DM1.187 121.45,36.74 v2(121.39,36.68) 121.37,36.68 120.85,37.2 DM1.185 ; v2(198.09,132.34) 198.09,132.39 GPU1.H2 ; v2(98.66,83.91) 98.66,84.04 CPU1.AA65 ; GPU1.E14 200.25,142.64 200.63,142.26 v2(200.63,142.26) ; DM2.161 128.15,24.13 128.39,23.89 128.39,22.01 127.91,21.53 v2(127.43,21.53) ; VRAM4.E2 175.92,166.12 v2(175.53,165.73) 175.15,166.1 VRAM2.D8 ; VRAM1.D8 205.16,171.11 205.16,171.11 204.96,171.33 v2(204.96,171.31) 204.73,171.08 204.71,171.08 VRAM3.E2 ; DM1.167 115.45,37.28 115.41,37.25 115.41,36.56 v2(115.54,36.43) ; 111.49,36.45 111.49,35.68 110.52,34.71 v2(110.07,34.71) ; CPU1.AP68 97.36,77.45 v2(97.77,77.86) ; VRAM3.J2 201.35,170.88 v2(201.7,170.52) ; v2(81.35,18.24) 81.65,17.94 DM2.14 ; v2(113.24,36.56) 113.65,36.97 DM1.161 ; v2(70.64,31.49) 70.73,31.41 70.73,30.85 70.75,30.83 DM1.26 ; WLAN1.36 167.18,54.27 166.98,54.48 166.98,55.49 167.26,55.77 WLAN1.30 169.56,55.77 v2(169.82,56.03) ; v2(162.17,44.51) 162.15,44.52 WLAN1.75 ; WLAN1.51 159.51,50.52 159.28,50.29 v2(159.23,50.29) ; CPU1.AR16 126.98,76.55 v2(127.11,76.55) 127.24,76.55 CPU1.AR15 ; DM2.38 88.85,19.8 88.24,20.41 v2(87.61,20.41) ; v2(169.6,57.64) 169.23,57.27 WLAN1.24 ; VRAM4.J2 179.15,166.15 v2(178.76,166.54) ; v2(207.33,164.88) 206.95,165.26 VRAM3.B9 ; v2(67.45,31.49) 67.15,31.18 DM1.14 ; v2(83.64,34.33) 83.34,34.33 82.45,35.22 DM1.65 ; v2(199.83,140.6) 199.84,140.6 GPU1.E11 ; DM2.156 126.65,17.63 126.66,17.65 126.66,18.04 v2(126.46,18.24) ; v2(162.2,46.02) 162.17,46.02 WLAN1.69 ; DM1.44 76.15,32.86 75.59,33.42 74.97,33.42 v2(74.97,33.42) ; v2(62.74,36.94) 63.65,36.94 63.85,37.14 DM1.3 ; v2(115.35,93.61) 115.35,93.27 CPU1.D34 ; DM2.65 96.95,23.81 97.18,23.58 97.18,22.61 96.27,21.7 v2(96.12,21.7) ; DM1.168 115.75,31.16 115.54,31.38 115.54,31.4 v2(115.51,31.43) ; v2(131.47,23.07) 131.75,23.34 DM2.173 ; v2(203.35,171.32) 202.95,171.72 VRAM3.G1 ; v2(203.35,171.32) 203.75,171.71 VRAM1.F9 ; C4032.2 164.89,121.36 v2(164.32,121.36) 164.13,121.36 163.9,121.58 U4002.3 ; v2(128.91,79.18) 128.84,79.18 CPU1.AM13 ; DM1.190 122.35,30.82 122.41,30.88 122.41,33.23 122.26,33.38 121.92,33.38 v2(121.83,33.3) ; WLAN1.29 161.6,56.02 161.85,55.77 161.85,55.21 161.66,55.02 WLAN1.33 159.36,55.02 158.64,54.3 v2(158.64,53.81) ; DM1.66 82.75,30.63 82.76,30.64 82.76,32.19 81.44,33.5 v2(80.88,33.5) ; DM2.66 97.25,17.94 v2(96.96,18.23) ; v2(207.34,166.51) 206.95,166.9 VRAM1.B3 ; DM1.9 65.65,37.49 65.65,37.49 65.65,36.98 v2(65.35,36.69) ; v2(73.58,32.1) 73.67,32.1 74.35,31.42 ; DM2.138 121.25,18.59 121.55,18.89 v2(121.85,18.89) ; v2(186.07,24.29) 187.3,25.52 HDD1.4 ; DM1.144 108.55,31.39 v2(108.6,31.44) ; DB3.4 157.34,13.46 ; v2(106.6,36.6) 107.05,37.06 DM1.139 ; DM1.43 75.84,38.16 75.84,36.82 75.95,36.71 75.95,36.27 75.51,35.83 v2(75.38,35.83) ; DM2.168 130.25,18.32 v2(130.25,18.32) ; VRAM4.G1 177.51,165.32 v2(177.11,165.72) ; DM1.55 v2(79.45,36.7) ; 101.2,80.71 CPU1.AH63 ; v2(117.03,77.82) 116.94,77.82 CPU1.AN33 ; v2(83.55,22.16) 83.18,22.16 83.04,22.3 83.04,23.83 83.14,23.93 83.14,24.28 83.15,24.29 DM2.19 ; U9101.23 164.86,22.3 v2(164.59,22.03) ; CPU1.G22 122.86,91.06 122.54,91.39 ; v2(129.8,23.39) 129.8,23.54 129.95,23.69 DM2.167 ; DM1.46 76.75,32.62 76.92,32.79 77.25,32.79 v2(77.29,32.76) ; v2(78.18,26.22) 78.35,26.05 DM2.3 78.35,24.18 78.05,23.88 ; v2(81.74,20.71) 81.05,20.71 80.47,21.29 80.47,23.47 80.75,23.76 DM2.11 ; R9118.2 164.56,29.22 164.56,29.21 v2(164.56,29.16) ; VRAM2.F9 176.75,165.36 v2(177.11,165.72) ; v2(66.02,32) 65.35,31.33 DM1.8 ; v2(104.48,34.66) 104,34.66 103.45,35.21 DM1.127 ; v2(173.48,21.89) 173.48,21.88 173.48,20.43 172.66,19.6 C9102.2 ; v2(111.56,91.37) 111.63,91.37 111.97,91.71 CPU1.F42 ; v2(119.93,32.21) 120.01,32.29 120.34,32.29 120.55,32.08 DM1.184 ; v2(106.98,91.33) 106.72,91.06 CPU1.G52 ; CPU1.E53 105.62,92.39 105.97,92.73 ; DM2.162 128.45,17.97 v2(128.15,18.27) ; DM2.195 138.35,23.9 138.81,23.44 v2(138.81,23.29) ; v2(177.11,165.72) 177.51,166.12 VRAM2.G8 ; CPU1.AU15 127.24,75.9 v2(127.11,75.9) ; v2(159.56,115.82) 159.62,115.82 159.92,115.53 U4006.3 ; v2(169.56,58.92) 169.41,58.77 WLAN1.18 ; v2(105.17,91.3) 104.95,91.3 CPU1.G55 ; DM1.54 79.15,31.07 78.91,31.31 78.91,31.83 79.33,32.25 v2(79.45,32.25) ; v2(99.5,92.8) 99.13,92.42 CPU1.E65 98.82,92.68 98.59,92.68 CPU1.D66 ; DM1.173 117.25,37.52 117.26,37.51 117.26,36.83 v2(117.4,36.69) ; C9103.2 163.13,19.09 v2(163.13,19.09) ; v2(94.96,105.36) 95.19,105.36 95.61,104.94 U1701.3 ; CPU1.F13 128.01,91.24 128.01,90.86 CPU1.H15 ; DM1.128 103.75,32.3 103.3,32.75 v2(102.87,32.75)
  BOTTOM w0.33: DM2.20 83.45,18.31 v2(83.44,18.32) ; 95.75,23.37 DM2.61 ; v2(94.67,20.27) 94.47,20.27 93.6,19.4 93.6,17.88 93.65,17.83 DM2.54 ; DM2.32 87.05,18.54 87.46,18.96 v2(87.65,18.96) ; v2(132.95,22.85) 133.31,22.85 133.55,23.09 DM2.179 ; DM2.28 85.85,17.71 85.93,17.79 85.93,19.07 85.41,19.59 v2(85.27,19.59) ; v2(99.33,18.27) 99.05,17.98 DM2.72 ; DM2.55 93.95,23.03 v2(93.85,22.93) ; v2(89.15,22.83) 88.94,22.83 88.55,23.22 DM2.37 ; DM2.189 136.55,23.5 137.04,23.01 137.04,22.71 137.55,22.2 v2(137.84,22.2) ; v2(130.25,19.6) 130.43,19.6 130.85,19.18 DM2.170 ; v2(71.91,31.48) 72.07,31.48 72.55,31 DM1.32 ; 78.05,23.88 78.05,22.23 v2(78.13,22.15) ; DM2.184 135.05,17.38 135.05,17.38 135.05,18.51 134.6,18.96 v2(134.01,18.96) ; v2(90.25,19.61) 90.93,19.61 91.25,19.29 DM2.46 ; v2(121.85,20.21) 121.84,20.2 121.23,20.2 120.65,19.62 DM2.136 ; DM1.60 80.95,31.37 v2(80.88,31.44) ; v2(92.45,18.96) 92.26,18.96 91.85,18.55 DM2.48 ; v2(119.5,18.96) 120.05,18.41 DM2.134 ; v2(127.43,22.85) 126.54,22.85 126.35,23.03 DM2.155 ; v2(99.22,22.72) 98.75,23.19 DM2.71 ; DM2.2 78.05,18.58 78.43,18.96 v2(78.65,18.96) ; DM2.44 90.65,17.94 v2(90.25,18.34) ; v2(118.85,22.2) 118.7,22.2 118.3,22.6 118.3,23.44 117.95,23.79 DM2.127 ; DM2.26 85.25,17.94 85.27,17.96 v2(85.27,18.32) ; DM1.38 74.35,31.42 ; DM2.8 79.85,16.77 79.85,17.94 79.75,18.04 79.75,19.18 v2(80.53,19.95) ; v2(122.68,22.7) 122.89,22.7 123.35,23.16 DM2.145 ; DM2.187 135.95,23.05 v2(136.1,22.9) 136.05,22.9 135.35,23.6 DM2.185 ; v2(94.67,19) 94.92,19 95.45,18.47 DM2.60 ; 118.35,19.57 119.04,20.26 v2(119.49,20.26) ; DM1.20 68.95,31.41 68.95,31.41 v2(68.95,31.43) ; DM1.72 v2(84.55,31.43)
  BOTTOM w0.356: U7301.3 178.71,123.6 178.46,123.36 v2(178.46,123.26) ; C4102.2 156.76,83.22 U4101.1 ; U4003.3 153.01,127.13 v2(152.54,126.66) ; GPU1.AD12 184.45,141.06 v2(184.06,141.45) 184.43,141.83 GPU1.AD13 ; v2(172.6,89.24) 174.48,89.24 174.75,89.5 Q6701.4
  BOTTOM w0.381: Q4001.4 54.21,32.05 v2(54.22,32.06) ; v2(168.86,31.2) 168.81,31.15 C9104.2 ; EU5702.3 v2(10.74,65.87) ; v2(15.01,32.92) U3602.3 U3602.8 ; Q4001.1 50.47,30.75 50.31,30.59 v2(49.97,30.59) ; v2(15.26,43.24) 15.29,43.21 U3601.3 ; v2(18.11,43.24) 18.08,43.21 U3601.8 ; v2(89.81,160.34) 89.39,159.93 PQ4306.1 ; 116.65,67.09 116.65,66.39 117.81,65.23 v2(117.92,65.23) ; v2(169.3,143.11) 169.54,143.35 PQ8306.4 ; PQ8307.1 167.58,138.87 v2(167.33,138.62) ; GPU1.E2 200.17,132.77 v2(199.77,133.18) ; EU5701.3 v2(10.56,61.71)
  BOTTOM w0.406: v2(219.6,98.6) PQ8305.4 217.79,98.6 217.39,98.2 217.39,97.49 217.2,97.3 PQ8305.1 ; v2(176.5,93.67) 176.81,93.36 176.81,93.36 176.92,93.26 176.92,91.83 176.63,91.54 Q6701.1 ; Q1701.1 153.08,71.63 v2(153.63,71.08) ; PQ4306.1 88.73,159.55 88.5,159.32 88.5,158.61 88.14,158.25 PQ4306.4 ; U6001.8 182.9,24.16 v2(182.91,24.15) ; v2(156.33,126.65) 156.19,126.79 U4005.3 ; v2(167.4,141.12) 167.94,141.12 168.37,141.54 PQ8306.1 ; CPU1.AL2 CPU1.AL4
  BOTTOM w0.508: v2(205.86,127.71) 205.76,127.82 R7622.2 R7647.2 ; R7621.2 207.42,128.68 207.65,128.9 R7632.2 207.62,129.24 R7654.2 206.27,129.24 v2(205.91,129.6) ; R7650.2 201.83,127.56 v2(202.33,127.06) 202.72,127.44 R7609.2 ; v2(163.48,66.34) 163.15,66.01 EC6103.2 ; v2(128.11,129.52) 128.95,129.52 PR4653.1 ; v2(183.74,39.97) 183.89,39.82 U3503.2 ; v2(138.21,47.43) 138.09,47.55 137.4,47.55 EC1902.2 ; R722.2 87.99,85.18 v2(87.99,84.34) ; v2(151.89,131.98) 152.4,132.5 PR5307.2 ; v2(151.89,131.98) 151.65,131.75 R4019.2 ; v2(151.89,131.98) 151.51,132.36 PC5311.2 ; v2(161.79,24.19) 161.39,24.19 160.44,25.13 R9102.2 ; PR4313.2 v2(91.55,160.92) ; v2(158.49,161.36) 158.38,161.25 C7326.2 ; v3(36.07,31.05) 36.21,30.92 EC9732.2 ; v2(114.55,125.33) 115.47,126.24 PR4656.1 ; R2727.2 13.65,17.25 v3(13.57,17.34) ; R7610.2 208.24,132.88 v2(208.8,132.32) ; EC6102.2 166,65.66 166.23,65.9 166.23,66.39 v2(166.24,66.39) ; Q4009.S 50.2,12.64 v2(50.2,13.17) ; PC5104.2 47.87,23.81 v2(47.87,22.89) ; v2(163.75,99.61) 163.75,99.18 C2610.2 ; R5531.2 77.27,165.58 v2(77.26,165.59) ; EC9743.2 15.81,23.77 v2(15.44,24.13) ; v2(157.5,63.36) 158.16,64.02 EC1707.2 ; v2(141.2,77.98) 139.72,77.98 C2103.2 ; v2(175.24,111.45) 174.94,111.75 PC5406.2 PR5401.2 ; R5412.2 20,79.57 v2(19.96,79.61) ; v2(90.01,95.58) 90.06,95.53 R405.2 ; v2(126.53,99.94) 126.05,99.46 C716.2 ; R7306.2 181.19,126.11 v2(181.22,126.14) ; PR5308.1 151.75,134.95 v2(151.89,134.81) ; C4102.2 157.29,83.11 v2(157.53,83.35) ; v2(163.02,109.87) 163.68,110.53 C4013.2 ; DM2.205 74.47,8.87 v3(73.99,9.35) ; C4014.2 157.85,132.11 157.85,134.24 v2(157.47,134.62) ; RTC1.2 68.4,8.67 68.66,8.93 70.7,8.93 v2(73.52,6.1) ; EC6403.2 v2(185.92,106.58) ; EC6402.2 v2(185.92,110.14) ; PR8213.2 202.74,92.89 v2(203.19,92.44) 203.63,92.88 PC8217.2 ; v2(54.72,9.66) 54.4,9.99 C2503.2 R2504.2 ; v2(172.6,89.24) 172.59,89.25 R6707.2 ; C4006.2 164.95,123.79 v2(164.34,124.4) ; v2(170.73,119.43) 170.73,119.43 170.73,119.61 170.98,119.86 Q4004.S ; v2(86.89,67.03) 87.47,66.45 R602.2 ; C7323.2 v2(174.8,146.92) ; EC6507.2 196.98,116.49 196.98,115.99 v2(196.98,115.99) ; v2(149.35,136.68) 149.46,136.79 PR5305.2 ; C2502.2 136.91,59.73 v2(136.9,59.72) ; v2(163.9,120.05) 163.58,119.72 163.58,119.02 C4016.2 ; EC9733.2 58.2,11.35 59.01,12.16 v2(59.28,12.16) 61.47,9.97 RTC1.4 ; v2(148.8,54.33) 148.76,54.37 147.98,54.37 EC2502.2 ; C5505.2 84.75,154.92 v2(84.26,155.41) ; v2(74.15,161.33) 74.22,161.4 C5539.2 ; v2(65.28,5.9) 64.81,6.37 RTC1.3 ; C6701.2 C6702.2 168.38,94.68 v2(167.57,95.49) C4020.2 ; v2(138.24,45.04) 138.24,45.08 137.65,45.67 EC1901.1 ; C2602.2 159.23,99.71 C2601.2 158.37,99.73 158.37,100.1 v2(158.07,100.4) ; X7601.4 209.49,136.52 v2(209.07,136.11) 208.68,136.5 C7608.1 ; v3(108.85,163.55) 108.85,162.62 108.61,162.38 ; C4009.2 31.67,54.24 v2(31.34,53.9) ; EC9745.2 14.73,17.02 v3(15.06,17.35) ; C1803.2 146.09,78.43 v2(145.91,78.61) ; C1801.1 v2(118.77,102.74) ; v2(145.9,75.53) 146.19,75.82 C1804.2 ; EC1712.2 151.47,74.73 v2(151.47,75.3) ; U5501.2 78.87,156.85 R5506.1 77.84,156.87 v2(77.82,156.85) ; v2(87.14,91.42) 86.66,90.95 R601.2 ; SKT25.4 141.75,53.09 141.19,53.65 139.37,53.65 v2(139.12,53.91) ; v2(176.5,93.67) 176.04,94.14 C6703.2 ; v2(150.42,139.09) 150.58,138.94 PC5309.2 151.1,138.23 PC5304.2 ; v2(97.9,147.53) 97.86,147.57 C5535.1 ; C2112.2 137.59,63.58 138.07,63.1 v2(138.17,63.1) 138.45,63.37 R2016.2 ; v2(96.55,99.72) EC1708.2 R1719.2 ; v2(187.46,74.76) 187.12,74.76 186.41,75.47 C2429.2 ; v2(153.06,73.91) 153.42,74.27 154.36,74.27 R1715.2 ; EC9705.2 141.64,149.42 142.95,148.11 144.13,148.11 v2(144.19,148.05) ; v2(143.96,45.39) 144.17,45.6 EC2505.2 ; v2(142.6,65.45) 142.15,65.9 R1825.2 ; C7609.2 188.14,125.16 187.09,126.21 v2(187.09,126.63) ; v2(185.61,68.48) 186.5,68.48 187.25,67.73 C2428.2 187.22,67.12 R2454.2 ; R7628.1 207.01,137.46 R7601.2 205.93,137.46 v2(205.8,137.59) ; v3(16.26,17.31) 16.56,17.01 16.56,16.04 EC9744.2 ; EC9706.2 v2(104.39,121.18) ; R734.2 120.12,99.54 v2(119.91,99.75) ; EC4001.2 155.77,132.6 v2(156.23,133.06) ; PC4526.2 38.41,59.77 38.41,60.36 38.42,60.37 38.42,60.89 38.41,60.9 38.41,61.2 v2(38.41,61.2) ; v2(141.94,62.37) 141.94,62.53 141.94,62.53 R2026.2 141.09,63.06 R2018.2 ; v2(175.15,103.27) 175.09,103.27 174.72,102.9 PR5404.2 ; v2(134.76,153.83) 135.06,154.13 PR4430.2 ; PR8259.2 PC8226.1 213.61,94.22 PC8203.1 214.04,94.16 v2(214.34,93.86) ; EC6407.2 182.87,120.47 182.87,120.14 v2(182.87,120.14) ; v2(103.53,99.74) 103.42,99.63 R402.2 ; v2(97.89,138.16) 97.86,138.18 C2605.2 98.18,139.27 C2611.2 ; C9105.2 160.88,28.22 161.63,28.22 C9106.2 162.82,27.9 v2(162.99,27.74) ; C4030.2 40.68,10.44 v2(40.67,10.44) ; EC6406.2 183.3,119.31 v2(182.91,119.31) ; EC2504.2 v2(156.46,55.27) ; v2(213.42,98.26) 213.32,98.16 213.02,98.16 212.72,97.85 PC8225.1 ; EC1711.2 148.89,72.08 148.43,72.54 v2(148.14,72.54) ; EC3107.1 35.73,175.35 36.42,176.04 EC3106.1 37.6,176.04 v2(37.62,176.02) ; v2(158.2,114.19) 158.02,114.37 C4008.2 ; v2(37.57,173.51) 37.52,173.46 EC3105.1 ; EC1706.2 135.3,103.24 v2(135.3,103.24) ; v2(100.83,104.4) 100.91,104.32 R406.2 ; R1502.2 139.45,76.51 139.45,76.24 R1836.2 138.37,75.94 v2(138.13,76.18) ; C1702.2 93,103.16 EC1709.2 92.43,103.95 v2(92.27,103.8) ; PC8207.2 209.16,104.5 v3(209.27,104.6) 209.75,104.6 210.31,104.04 PR8224.2 ; DB2.4 v2(151.34,10.6) ; C4101.2 153.46,86.9 153.06,87.31 v2(152.69,87.31) ; v2(17.39,73.89) 17.38,73.88 C5401.2 ; v2(138.07,48.9) 138.06,48.91 R1725.1 ; PC8301.2 141.54,153.32 v2(141.82,153.04) 141.73,153.04 141.27,152.58 EC9715.2 ; v2(135.02,100.1) 135.02,100.1 135.02,100.02 134.63,99.63 R1904.1 135.45,99.15 EC1903.2 ; v2(168.09,84.54) 168.02,84.46 C1176.2 166.21,85.12 C1175.2 ; DB2.6 v2(150.35,11.9) ; v2(147.82,149.25) 147.82,150.18 PC8302.2 ; v2(176.51,28.34) 176.77,28.6 EU3404.2 ; EC2506.2 v2(144.11,43.9) ; C717.2 92.43,100.06 v2(92.22,100.28) ; EC5503.2 75.44,163.19 v2(75.48,163.23) ; R5410.2 18.85,76.05 v2(19,76.05) ; R7302.2 141.95,151.97 142.31,152.33 v2(142.31,152.41) ; C4012.2 v2(168.69,113.73) ; EC9738.2 v2(67.51,87.01) ; C2116.2 131.16,99.26 v2(131.16,99.71) ; PQ8307.4 v2(170.25,140.77) ; v2(178.58,152.67) 177.91,153.34 R7301.2 ; C7610.2 190.99,125.32 v2(190.74,125.57) ; v2(89.15,93.55) R605.2 ; EC9722.2 v2(197.04,17.55) ; C1802.1 v2(122.11,101.96) ; EU3601.2 v2(15.99,38.95) ; EC9737.2 v2(33.17,77.09)
  BOTTOM w0.559: R9804.2 178.54,12.98 v2(178.55,12.98)
  BOTTOM w0.584: v2(156.18,43.06) 156.03,43.21 156.03,43.5 155.75,43.78 SKT26.4
  BOTTOM w0.635: USB2.11 13,18.47 ; USB2.11 11.32,17.58 ; USB2.11 11.32,19.36 ; 7.92,57.56 8.25,57.89 HDMI1.20 10.48,59.42 10.59,59.31 ; 10.57,25.58 USB2.7 10.57,24.16 ; 12.78,21.37 USB2.4 12.07,20.66 ; v2(175.04,105.19) 174.77,104.92 PU5401.1 ; USB1.11 13,38.47 ; USB1.11 11.32,37.58 ; USB1.11 11.32,39.36 ; 11.32,32.16 USB2.10 11.32,30.38 ; USB1.10 13,51.27 ; USB1.10 11.32,50.38 ; USB1.10 11.32,52.16 ; 8.3,75.7 8.25,75.65 HDMI1.21 10.28,73.92 10.31,73.94 ; 165.37,177.84 BATT1.9 166.42,179.77 ; USB1.13 2.87,35.41 3.07,35.21 ; 1.75,56.26 HDMI1.22 3.77,57.52 4.08,57.21 ; 144.08,179.77 BATT1.10 146.17,179.77 ; USB2.12 2.87,34.05 3.17,34.35 ; 4.34,16.08 3.4,17.02 USB2.13 2.18,17.02 1.21,16.06 ; 3.27,54.69 2.87,54.29 USB1.12 ; 10.57,45.58 USB1.7 10.57,44.16 ; 1.75,77.04 HDMI1.23 3.52,75.82 3.78,76.08 ; HDD1.22 192.55,23.34 v2(192.56,23.33) ; HDD1.21 190.6,22.27 v2(190.98,22.65)
  BOTTOM w0.762: DB1.12 156.79,36.48 v2(157.17,36.86) ; v2(161.84,35.32) 161.84,35.78 161.84,35.78 DB1.8 ; 219.79,139.99 HGPU2.1 ; HGPU2.1 219.62,145.22 ; HGPU2.1 214.42,140.02 ; HGPU2.1 214.64,145.14 ; 147.5,180.52 BATT1.8 ; BATT1.8 149,180.52 ; BATT1.8 147.5,179.02 ; BATT1.8 149,179.02 ; 149.5,180.52 BATT1.7 ; BATT1.7 151,180.52 ; BATT1.7 149.5,179.02 ; BATT1.7 151,179.02 ; 13.64,55.33 H3.1 18.2,56.58 ; 151.5,180.52 BATT1.6 ; BATT1.6 151.5,179.02 ; BATT1.6 153,180.52 ; BATT1.6 153,179.02 ; DB1.10 159.34,35.9 v2(159.83,35.41)
  vias: v1(15.02,60.35) v1(18,73.31) v1(24.58,78.22) v1(25.24,69.56) v1(43.58,76.94) v1(57.95,168.23) v1(58.34,70.28) v1(62.83,168.36) v1(64.11,168.39) v1(80.51,84.99) v1(86.83,141.03) v1(88.37,167.46) v1(98.29,167.88) v1(103.29,72.67) v1(104.59,126.17) v1(105.25,132.39) v1(110.58,30.27) v1(111.61,10.51) v1(116.96,168) v1(116.96,111.21) v1(117.67,123.8) v1(118.73,85.83) v1(119.34,135.85) v1(127.16,88.01) v1(128.13,168.74) v1(133.09,133.18) v1(146.9,95.99) v1(157.71,93.48) v1(158.95,119.34) v1(163.04,24.47) v1(167.64,57.64) v1(174.17,98.52) v1(177.93,23.93) v1(181.49,176.52) v1(184.89,17.9) v1(189.19,8.81) v1(192.37,133.37) v1(195.57,17.51) v1(201.89,161.5) v1(206.57,104.2) v1(213.24,102.26) v2(1.15,1.65) v2(6.38,180.86) v2(6.37,161.14) v2(6.4,78.96) v2(7.16,34.9) v2(8.92,180.86) v2(8.91,161.14) v2(9.34,55.77) v2(11.45,161.14) v2(11.46,180.86) v2(12.47,77.27) v2(12.62,79.8) v2(13.94,19.71) v2(14,180.86) v2(13.99,161.14) v2(14.12,40.16) v2(14.12,37.79) v2(14.22,6.31) v2(14.5,7.82) v2(15.16,22.84) v2(15.51,18.9) v2(16.17,6.31) v2(16.54,180.86) v2(16.53,161.14) v2(17.02,67.95) v2(17.11,65.89) v2(17.06,63.78) v2(17.08,61.63) v2(17.08,59.48) v2(17.75,6.29) v2(18.11,7.62) v2(18.16,44.73) v2(18.28,80.18) v2(18.54,45.29) v2(19.04,57.28) v2(19.08,180.86) v2(19.07,161.14) v2(19.07,6.26) v2(19.33,33.44) v2(19.46,39.6) v2(19.46,38.85) v2(20.04,33.44) v2(20.11,39.59) v2(20.12,38.89) v2(20.19,70.51) v2(20.16,59.79) v2(20.28,57.52) v2(20.62,6.26) v2(21.31,63.86) v2(21.35,61.59) v2(21.48,67.77) v2(21.62,180.86) v2(21.61,161.14) v2(21.66,66.58) v2(21.74,65.41) v2(22.4,70.67) v2(22.74,54.71) v2(22.75,56.85) v2(23.73,38.43) v2(23.75,36.25) v2(24.15,161.14) v2(24.16,180.86) v2(24.68,42.84) v2(24.69,42.07) v2(24.9,46.99) v2(24.86,44.62) v2(25.06,38.39) v2(25.32,15.87) v2(25.69,37.39) v2(26.47,15.87) v2(26.7,180.86) v2(26.69,161.14) v2(27.35,17.78) v2(27.35,16.76) v2(27.35,15.87) v2(27.35,15.11) v2(27.35,14.09) v2(28.06,163.41) v2(28.06,162.39) v2(28.14,33.64) v2(28.24,15.87) v2(28.79,176.97) v2(29.04,167.64) v2(29.02,166.82) v2(29.24,179.33) v2(29.23,161.14) v2(29.39,15.87) v2(29.53,6.84) v2(30.42,6.84) v2(31.3,6.84) v2(31.39,177.69) v2(31.78,179.33) v2(31.77,161.14) v2(31.99,170.65) v2(31.99,169.83) v2(32.19,6.84) v2(33.08,6.84) v2(33.89,171.94) v2(33.97,6.84) v2(34.23,12.68) v2(34.32,179.33) v2(35.07,16.21) v2(36.01,15.4) v2(36.19,171.17) v2(36.31,178.04) v2(36.86,179.33) v2(37.69,81.05) v2(38.5,55.14) v2(38.63,169.91) v2(39.04,7.07) v2(39.14,55.78) v2(39.14,55.14) v2(39.14,54.51) v2(39.33,15.37) v2(39.39,161.14) v2(39.77,55.14) v2(39.87,174.02) v2(40.82,177.99) v2(40.84,162.64) v2(41.13,173.76) v2(41.14,172.92) v2(41.12,161.24) v2(41.35,166.69) v2(42.19,176.77) v2(42.22,161.25) v2(43.08,161.24) v2(43.33,166.24) v2(43.72,174.46) v2(45.01,6.96) v2(45.52,168.97) v2(46.53,169.98) v2(46.53,168.97) v2(46.53,167.95) v2(46.86,164.18) v2(47.24,22.25) v2(47.55,168.97) v2(47.87,22.25) v2(47.87,21.62) v2(48.51,22.25) v2(49.63,165.09) v2(51.75,161.15) v2(51.94,161.91) v2(53.09,80.86) v2(53.78,164.71) v2(56.11,177.58) v2(56.51,70.4) v2(57.38,70.35) v2(58.09,164.27) v2(60.73,177.5) v2(61.44,169.61) v2(61.58,167.51) v2(63.02,161.78) v2(64.52,32.25) v2(64.87,167.42) v2(66.04,34.06) v2(66.81,35.4) v2(67.65,167.45) v2(67.65,166.56) v2(69.01,35.37) v2(68.95,32.7) v2(72.9,35.8) v2(73.05,22.07) v2(73.06,21.44) v2(73.06,20.52) v2(73.06,19.89) v2(73.43,156.91) v2(73.42,156.04) v2(74.39,178) v2(74.97,32.1) v2(75.27,178) v2(75.37,34.51) v2(76.65,36.37) v2(77.06,74.91) v2(77.27,178.12) v2(77.7,77.22) v2(78.46,77.73) v2(78.65,20.23) v2(79.09,178.12) v2(79.31,77.72) v2(79.26,21.41) v2(79.45,35.4) v2(80.88,36.05) v2(81.64,81.41) v2(82.31,169.94) v2(82.85,174.16) v2(82.92,172.79) v2(82.93,89.56) v2(82.93,88.29) v2(82.9,87.15) v2(82.88,82.83) v2(83.4,170.07) v2(83.44,19.59) v2(83.48,169.13) v2(83.54,87.15) v2(83.46,84.33) v2(83.54,82.96) v2(83.55,20.89) v2(83.62,172.1) v2(83.56,89.56) v2(83.56,88.29) v2(84.08,158.45) v2(84.09,90.52) v2(84.09,84.33) v2(84.18,157.69) v2(84.2,89.56) v2(84.2,88.29) v2(84.17,87.15) v2(84.17,82.96) v2(84.55,32.76) v2(85.21,159.87) v2(86,97.03) v2(86.8,97.61) v2(87.12,32.04) v2(87.45,78.52) v2(87.4,36.03) v2(87.4,34.71) v2(87.4,33.39) v2(87.54,140.16) v2(87.54,138.91) v2(87.56,137.69) v2(87.58,136.39) v2(87.57,54.41) v2(87.62,53.67) v2(87.62,52.99) v2(87.68,22.58) v2(87.99,80.71) v2(88.18,168.41) v2(88.7,74.21) v2(88.98,33.75) v2(89.32,75.34) v2(89.4,78.52) v2(89.73,35.9) v2(89.86,77.02) v2(90.05,74.21) v2(90.13,32.1) v2(91,35.76) v2(91.02,34.31) v2(91.35,78.52) v2(91.85,76.97) v2(91.97,73.97) v2(92.12,75.6) v2(92.45,20.23) v2(93.62,148.85) v2(93.64,80.54) v2(93.64,69.05) v2(93.64,67.1) v2(93.64,35.8) v2(93.69,34.33) v2(93.97,21.58) v2(94.31,148.85) v2(94.99,32.24) v2(95.49,68.39) v2(95.49,66.44) v2(96.07,20.44) v2(96.52,34.88) v2(96.55,32.99) v2(96.78,20.23) v2(97.62,67.8) v2(97.62,65.82) v2(97.65,36.05) v2(97.65,34.72) v2(98.97,32.7) v2(98.97,31.43) v2(99.21,35.9) v2(99.23,21.45) v2(99.19,19.52) v2(99.29,34.62) v2(99.4,68.52) v2(99.4,66.57) v2(100,21.39) v2(100.01,20.33) v2(100.83,36.02) v2(100.84,34.57) v2(101.08,82.58) v2(101.46,79.82) v2(101.56,81.07) v2(101.61,64.1) v2(101.67,80.44) v2(101.74,20.36) v2(102.04,18.93) v2(102.39,36.03) v2(102.38,34.67) v2(102.5,80.83) v2(102.49,80.09) v2(102.72,67.06) v2(102.72,65.1) v2(102.87,31.43) v2(103.34,80.74) v2(103.34,80.09) v2(103.37,22.08) v2(103.37,20.81) v2(104.31,67.75) v2(104.31,65.8) v2(104.3,63.84) v2(104.43,19.55) v2(105.14,80.76) v2(105.15,80.09) v2(105.53,66.44) v2(105.55,32.75) v2(106.22,20.28) v2(106.22,18.96) v2(106.66,34.4) v2(106.7,22.84) v2(106.89,80.79) v2(106.99,80.05) v2(107.12,103.51) v2(107.59,68.61) v2(107.62,66.71) v2(107.62,64.8) v2(107.98,19.55) v2(107.98,18.23) v2(108.37,105.83) v2(108.38,21.53) v2(108.62,35.36) v2(108.61,32.73) v2(108.74,129.48) v2(108.74,128.84) v2(108.73,127.5) v2(108.78,128.15) v2(108.8,80.8) v2(108.87,80.12) v2(109.25,18.93) v2(109.44,129.49) v2(109.43,127.52) v2(109.45,104.59) v2(109.48,128.86) v2(109.45,128.21) v2(109.5,99.59) v2(109.73,80.72) v2(109.89,97.56) v2(110.13,127.51) v2(110.08,32.86) v2(110.16,129.49) v2(110.17,128.85) v2(110.16,128.2) v2(110.21,105.65) v2(110.24,68.29) v2(110.24,66.34) v2(110.67,20.98) v2(110.84,127.52) v2(110.87,129.48) v2(110.85,128.84) v2(110.85,128.19) v2(110.97,102.97) v2(111.46,21.37) v2(111.64,129.51) v2(111.62,128.87) v2(111.64,128.22) v2(111.75,97.86) v2(111.82,68.43) v2(111.82,67.13) v2(111.82,65.82) v2(111.82,63.88) v2(112.04,33.64) v2(112.3,129.35) v2(112.3,128.67) v2(112.33,128.03) v2(112.26,104.41) v2(112.45,22.85) v2(112.45,21.53) v2(112.5,99.15) v2(112.93,129.55) v2(112.92,128.9) v2(112.94,128.26) v2(112.89,127.62) v2(112.88,20.25) v2(112.86,18.9) v2(113.24,35.29) v2(113.24,32.13) v2(114.17,68.56) v2(114.17,66.61) v2(114.17,64.55) v2(115.06,173.64) v2(115.3,21.65) v2(115.3,20.32) v2(115.54,35.11) v2(115.9,69.77) v2(115.9,67.82) v2(115.9,65.87) v2(116.58,172.5) v2(117.11,21.9) v2(117.4,34.76) v2(117.4,32.22) v2(117.92,67.18) v2(118.85,20.93) v2(119.13,34.75) v2(119.56,68.34) v2(119.56,66.39) v2(121.95,96.07) v2(122.09,130) v2(122.09,129.36) v2(122.13,128.67) v2(122.08,128.02) v2(122.79,130.01) v2(122.83,129.38) v2(122.8,128.73) v2(122.78,128.04) v2(123.08,96.65) v2(123.5,130.01) v2(123.52,129.37) v2(123.51,128.72) v2(123.48,128.03) v2(123.61,32.1) v2(123.73,67.35) v2(123.73,65.4) v2(123.73,63.44) v2(124.07,103.87) v2(124.13,35.37) v2(124.22,130) v2(124.2,129.36) v2(124.2,128.71) v2(124.19,128.04) v2(124.99,130.03) v2(124.97,129.39) v2(124.99,128.74) v2(125.21,22.18) v2(125.21,20.86) v2(125.64,129.87) v2(125.63,129.19) v2(125.63,128.55) v2(126.27,130.05) v2(126.26,129.39) v2(126.25,128.76) v2(126.27,128.11) v2(126.46,20.15) v2(126.88,49.54) v2(126.88,48.86) v2(127.92,104.2) v2(127.98,48.76) v2(128.01,36.04) v2(128.02,35.24) v2(128.11,20.93) v2(128.12,19.65) v2(129.44,84.41) v2(129.44,81.26) v2(129.42,59.21) v2(129.73,97.88) v2(129.78,95.66) v2(129.8,21.94) v2(130.08,84.44) v2(130.07,81.27) v2(130.77,90.73) v2(131.98,84.42) v2(132.71,19.55) v2(132.95,21.53) v2(133.78,137.75) v2(134.01,20.25) v2(134.12,61.89) v2(134.86,137.82) v2(135.66,62.92) v2(136.01,137.9) v2(136.1,21.58) v2(136.29,63.12) v2(136.4,20.1) v2(137.69,58.87) v2(137.87,20.89) v2(140.41,59.03) v2(141.96,83.34) v2(142.33,95.26) v2(142.59,83.31) v2(142.97,95.27) v2(143.23,83.31) v2(144.52,149.38) v2(145.33,7.97) v2(145.41,149) v2(146.04,154.84) v2(146.04,154.21) v2(146.04,153.57) v2(146.01,93.51) v2(145.97,7.97) v2(147.62,92.78) v2(147.7,7.97) v2(147.87,107.09) v2(147.89,97.42) v2(148.35,92.69) v2(148.66,52.63) v2(149.24,105.9) v2(149.31,53.39) v2(150.61,109.46) v2(151.46,8.02) v2(151.82,108.19) v2(151.94,106.98) v2(152.22,8.02) v2(152.42,124.13) v2(152.42,123.42) v2(152.58,110.17) v2(153.3,106.11) v2(153.52,39.6) v2(153.95,108.91) v2(154.57,90.21) v2(154.55,11.08) v2(154.71,69.23) v2(154.73,39.45) v2(155.19,11.08) v2(155.71,91.2) v2(156.42,92.46) v2(157.83,36.11) v2(158.87,12.73) v2(159.32,39.09) v2(159.51,12.73) v2(159.99,82.24) v2(161.24,81.6) v2(162.06,82.45) v2(162.2,80.57) v2(162.43,52.05) v2(162.91,35.59) v2(163.44,35.16) v2(164.36,61.13) v2(164.77,25.43) v2(165.3,171.47) v2(165.26,59.36) v2(165.32,35.36) v2(165.43,25.46) v2(165.77,172.62) v2(165.98,169.63) v2(166.1,26.74) v2(166.11,26.09) v2(166.11,25.44) v2(166.12,24.79) v2(166.12,24.13) v2(166.54,168) v2(166.54,167.03) v2(166.54,165.94) v2(166.76,25.43) v2(166.9,171.07) v2(167.2,174.92) v2(167.21,174.28) v2(167.4,25.44) v2(169.02,29.62) v2(169.41,126.52) v2(169.41,125.89) v2(169.4,67.58) v2(169.4,23.19) v2(169.84,67.1) v2(170.05,126.52) v2(170.05,125.89) v2(170.11,22.85) v2(170.65,30.59) v2(171.48,25.75) v2(171.52,23.46) v2(172.57,138.98) v2(172.56,137.81) v2(172.59,136.51) v2(172.69,100.75) v2(172.77,23.93) v2(173.32,100.75) v2(173.81,99.18) v2(174.24,9.29) v2(175.43,133.05) v2(176.29,137.54) v2(178.11,138.29) v2(178.68,136.58) v2(180.55,140.67) v2(180.68,136.58) v2(180.94,132.88) v2(181.21,26.34) v2(181.46,140.67) v2(181.99,126.14) v2(182.62,126.14) v2(183.01,25.51) v2(183.26,148.09) v2(183.73,28.55) v2(183.91,86) v2(184.04,148.04) v2(184.04,143.08) v2(184.17,9.35) v2(184.65,125.51) v2(184.85,143.08) v2(185.02,15.66) v2(185.67,147.22) v2(185.66,143.07) v2(185.79,27.71) v2(185.98,32.63) v2(186.07,28.65) v2(186.38,126.6) v2(188.01,18.63) v2(189.31,144.21) v2(189.33,142.22) v2(190.25,147.18) v2(190.22,143.13) v2(190.22,139.15) v2(190.34,76.38) v2(191.22,146.14) v2(191.22,144.11) v2(191.21,142.06) v2(191.22,140.18) v2(191.22,138.27) v2(191.26,128.17) v2(191.65,12.91) v2(192.73,128.15) v2(192.65,72.09) v2(193.2,160.49) v2(193.25,144.24) v2(193.25,142.21) v2(193.26,140.19) v2(193.38,41.17) v2(195.23,144.24) v2(195.23,142.21) v2(195.24,140.15) v2(195.17,136.86) v2(195.22,122.28) v2(195.28,138.27) v2(195.88,117.15) v2(196.99,85.13) v2(197,84.37) v2(197.25,144.05) v2(198.66,2.42) v2(198.89,98.82) v2(201.74,159.95) v2(202.7,159.39) v2(203.1,162.78) v2(204.45,96.2) v2(205.39,94.79) v2(205.99,142.19) v2(207.64,140.11) v2(207.69,142.75) v2(207.84,161.18) v2(208.38,140.11) v2(208.4,98.33) v2(209.04,98.96) v2(209.04,98.33) v2(209.04,97.69) v2(209.27,92) v2(209.67,98.33) v2(213.11,148.96) v2(213.23,139.5) v2(213.64,149.33) v2(218.35,152.83) v2(218.45,153.57) v3(1.13,55.24) v3(1.13,34.92) v3(1.16,80.55) v3(4.87,81.92) v3(5.34,35.87) v3(5.32,33.88) v3(5.51,15.9) v3(6.27,57.19) v3(6.4,76.16) v3(6.5,53.87) v3(9.08,33.85) v3(9.28,53.85) v3(9.33,35.88) v3(9.26,15.9) v3(9.91,81.92) v3(13.7,36.57) v3(13.7,35.57) v3(14.65,81.89) v3(14.64,36.3) v3(15.58,36.32) v3(16.16,30.12) v3(16.18,29.14) v3(17.21,30.09) v3(17.23,29.1) v3(21.85,81.89) v3(25.22,30.74) v3(26.08,30.74) v3(26.11,27.82) v3(26.94,30.74) v3(27.05,27.87) v3(27.57,81.94) v3(27.81,30.74) v3(28.08,27.85) v3(29.23,30.33) v3(32.5,30.6) v3(34.3,31.05) v3(34.56,47.01) v3(34.88,81.92) v3(35.18,31.05) v3(35.33,48.03) v3(35.45,47.01) v3(36.34,48.03) v3(36.34,47.01) v3(36.47,49.17) v3(36.47,46) v3(37.23,47.52) v3(37.36,48.66) v3(39.23,179.33) v3(41.38,25.32) v3(42.18,81.91) v3(42.18,30.59) v3(42.18,29.75) v3(42.32,49.79) v3(42.41,48.86) v3(42.57,48.03) v3(42.57,47.01) v3(43.27,49.8) v3(43.3,48.89) v3(43.45,48.03) v3(43.45,47.01) v3(43.62,25.55) v3(44.31,179.33) v3(44.44,161.2) v3(44.72,46.63) v3(44.72,45.74) v3(44.94,33.03) v3(45.83,33.03) v3(46.72,33.03) v3(47.61,33.03) v3(48.5,33.03) v3(49.39,179.33) v3(49.53,161.21) v3(50.19,81.93) v3(51.76,27.94) v3(52.54,20.73) v3(53.05,19.97) v3(53.43,20.73) v3(53.94,19.97) v3(54.11,160.67) v3(54.23,17.44) v3(54.32,20.73) v3(54.47,179.33) v3(54.82,19.97) v3(55.21,20.73) v3(55.16,17.45) v3(55.74,82.81) v3(55.71,19.97) v3(56,17.45) v3(56.09,20.73) v3(56.28,28.21) v3(56.6,19.97) v3(56.98,20.73) v3(57.38,160.56) v3(57.52,83.36) v3(58.22,22.07) v3(59.42,84.05) v3(59.55,179.33) v3(60.87,84.61) v3(61.19,42.6) v3(61.19,41.33) v3(61.25,161.08) v3(64.11,157.92) v3(64.63,179.33) v3(65.07,14.43) v3(65.16,86.71) v3(65.96,14.43) v3(66.85,14.39) v3(67.74,14.39) v3(68.63,14.39) v3(69.23,2.31) v3(69.52,14.43) v3(69.76,179.33) v3(69.76,89.69) v3(70.17,154.48) v3(70.41,14.43) v3(71.3,14.43) v3(72.19,14.43) v3(73.86,93.24) v3(75.38,150.1) v3(77.74,95.43) v3(78.08,98.3) v3(79.25,148.87) v3(79.86,179.32) v3(79.86,144.28) v3(82.25,139.61) v3(82.17,105.48) v3(83.55,136.05) v3(84.08,110.83) v3(84.64,131.32) v3(84.94,179.32) v3(85.33,116.78) v3(85.96,127.57) v3(90.03,179.31) v3(94.1,164.37) v3(94.1,163.48) v3(94.91,112.96) v3(94.91,112.12) v3(94.91,111.28) v3(94.91,110.44) v3(94.91,109.61) v3(94.94,108.77) v3(94.99,164.37) v3(94.99,163.48) v3(95.11,179.31) v3(96.08,159.62) v3(99.69,163.35) v3(99.69,162.46) v3(100.15,179.32) v3(104.7,132.89) v3(104.7,131.82) v3(104.73,130.66) v3(104.84,134.01) v3(104.79,129.49) v3(104.84,128.33) v3(104.91,135.17) v3(104.94,127.19) v3(105.26,179.33) v3(105.66,126.59) v3(105.84,130.68) v3(105.9,135.15) v3(105.94,134.02) v3(105.9,132.91) v3(105.9,131.84) v3(105.91,129.56) v3(106.03,128.45) v3(105.99,127.38) v3(108.5,86.85) v3(108.64,83.72) v3(108.71,85.81) v3(109.32,86.51) v3(109.5,85.38) v3(110.39,179.33) v3(110.42,85.41) v3(114.68,160.94) v3(115.38,179.32) v3(115.44,161.32) v3(116.33,161.32) v3(116.93,81.48) v3(117.22,161.32) v3(117.19,86.58) v3(117.18,85.04) v3(117.6,162.21) v3(117.67,113.2) v3(117.67,112.31) v3(117.67,111.42) v3(117.76,118.95) v3(117.76,118.06) v3(117.76,117.17) v3(117.76,116.28) v3(117.76,115.39) v3(117.76,114.51) v3(118.03,86.58) v3(118.02,85.04) v3(118.1,161.32) v3(118.49,162.21) v3(118.52,119.36) v3(118.52,118.47) v3(118.52,117.58) v3(118.52,116.69) v3(118.52,115.8) v3(118.52,114.92) v3(118.52,114.03) v3(118.52,113.14) v3(118.52,112.25) v3(118.54,111.41) v3(118.86,86.58) v3(118.86,85.06) v3(118.99,161.32) v3(119.09,134.72) v3(119.09,133.88) v3(119.09,133.04) v3(119.09,132.2) v3(119.09,131.36) v3(119.09,130.52) v3(119.5,162.21) v3(119.65,129.72) v3(119.7,128.88) v3(119.88,161.32) v3(119.96,134.74) v3(119.96,133.9) v3(119.96,133.06) v3(119.96,132.22) v3(119.96,131.38) v3(119.96,130.54) v3(120.31,128.23) v3(120.39,160.3) v3(120.54,179.31) v3(120.57,129.9) v3(120.58,129.06) v3(121.28,160.3) v3(125.59,179.33) v3(127.12,173.54) v3(127.12,172.37) v3(127.15,170.79) v3(128.01,175.29) v3(128.01,173.54) v3(128.01,172.37) v3(128.04,170.79) v3(129.88,180.8) v3(131.68,133.61) v3(131.69,132.74) v3(131.69,131.86) v3(131.95,119.44) v3(131.95,115.78) v3(131.95,114.68) v3(131.93,113.85) v3(131.93,112.94) v3(131.98,118.59) v3(132,117.71) v3(131.97,116.86) v3(132.56,133.61) v3(132.58,132.74) v3(132.58,131.86) v3(132.84,116.86) v3(132.81,115.78) v3(132.81,114.68) v3(132.81,113.85) v3(132.81,112.94) v3(133.87,180.82) v3(137.08,179.12) v3(137.93,180.82) v3(140.44,123.81) v3(140.44,120.25) v3(140.46,122.97) v3(140.46,122.08) v3(140.46,121.19) v3(140.46,119.41) v3(140.46,118.52) v3(140.46,117.63) v3(140.89,114.55) v3(140.91,113.7) v3(141.12,179.18) v3(141.22,134.4) v3(141.8,114.56) v3(141.8,113.67) v3(142.11,134.4) v3(143.06,180.84) v3(143.89,134.4) v3(144.75,100.13) v3(145.59,100.13) v3(146.6,158.25) v3(146.6,156.89) v3(155.95,149.76) v3(157.01,149.79) v3(158.05,117.88) v3(158.06,118.72) v3(158.23,119.56) v3(161.02,1.14) v3(165.45,1.16) v3(165.94,105.57) v3(165.97,103.77) v3(167.8,180.82) v3(169.54,114.52) v3(169.57,115.36) v3(171.33,1.16) v3(171.51,178.44) v3(172.78,178.43) v3(173.99,178.45) v3(174.49,180.83) v3(174.68,34.77) v3(174.68,33.87) v3(174.68,32.97) v3(177.57,1.14) v3(181.16,180.82) v3(182.8,178.35) v3(183.05,36.02) v3(183.32,34.12) v3(183.32,1.16) v3(183.97,178.37) v3(184.32,36.9) v3(185.09,178.4) v3(185.1,44.29) v3(185.59,180.81) v3(185.84,36.73) v3(188.48,43.89) v3(189.59,1.16) v3(191.01,179.35) v3(192.66,35.9) v3(193.77,32.67) v3(195.56,1.17) v3(196.09,179.35) v3(197.71,124.15) v3(197.71,123.26) v3(197.71,122.37) v3(198.25,121.73) v3(198.92,177.72) v3(200.06,177.74) v3(200.65,51.9) v3(200.65,46.82) v3(200.65,41.74) v3(200.65,36.66) v3(200.65,31.58) v3(200.65,26.5) v3(200.65,21.42) v3(200.65,16.34) v3(200.65,11.26) v3(200.65,6.18) v3(200.68,87.81) v3(200.66,67.44) v3(200.66,62.36) v3(200.66,1.55) v3(200.95,89.54) v3(201.17,179.35) v3(201.33,177.74) v3(201.69,124.44) v3(201.69,123.55) v3(201.69,122.66) v3(201.69,121.78) v3(204.34,105.19) v3(204.56,90.61) v3(204.91,177.75) v3(205.08,104.55) v3(205.08,103.66) v3(205.71,102.9) v3(205.82,177.76) v3(205.84,104.04) v3(206.25,179.35) v3(207,110.77) v3(207,109.88) v3(207,109) v3(207,108.11) v3(207,107.22) v3(207,106.33) v3(207.89,109.88) v3(207.89,109) v3(207.89,108.11) v3(207.89,107.22) v3(207.89,106.33) v3(208.78,108.11) v3(208.78,107.22) v3(209.64,90.61) v3(210.05,107.73) v3(210.05,106.84) v3(210.81,109.88) v3(210.81,109) v3(210.81,108.11) v3(210.81,107.22) v3(210.81,106.33) v3(211.33,179.35) v3(211.58,110.39) v3(211.58,109.5) v3(211.58,108.61) v3(211.58,107.73) v3(211.58,106.84) v3(211.58,105.95) v3(211.83,102.8) v3(211.83,101.91) v3(212.72,175.67) v3(212.69,173.54) v3(212.69,103.69) v3(212.69,102.8) v3(212.8,177.17) v3(213.63,104.17) v3(213.63,103.28) v3(214.52,90.67) v3(216.41,179.35) v3(216.97,131.22) v3(216.97,130.28) v3(217.04,128.93) v3(217.01,127.54) v3(217.04,126.65) v3(217.04,125.76) v3(217.04,123.22) v3(217.24,122.2) v3(217.88,132.77) v3(217.93,128.93) v3(217.88,127.59) v3(217.93,126.65) v3(217.93,125.76) v3(217.93,123.22) v3(219.56,132.78) v3(219.7,128.93) v3(219.7,126.65) v3(219.7,125.76) v3(219.7,123.22) v3(220.4,122.12) v3(220.46,138.91) v3(220.46,137.64) v3(220.46,136.37) v3(220.46,135.1) v3(220.47,133.89) v3(220.51,94.59) v3(220.65,152.65) v3(220.65,147.57) v3(220.65,142.49) v3(220.59,128.93) v3(220.59,126.65) v3(220.59,125.76) v3(220.59,123.22) v3(220.65,96.48) v3(220.66,177.97) v3(220.66,172.89) v3(220.66,167.81) v3(220.66,162.75) v3(220.66,157.67) v3(220.67,132.82) v3(220.65,127.61) v3(220.68,116.99)
