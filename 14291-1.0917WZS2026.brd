# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKREQ_PCIE#3: length 16.2
  TOP w0.102: v2(129.85,76.55) 130.34,76.06 130.34,74.97 131.38,73.93 v1(131.38,73.76) 131.38,72.65 132.33,71.7 132.33,70.54 132.79,70.08 133.08,70.08 134.03,69.13 134.03,68.56 134.54,68.05 135.66,68.05 136.41,67.31 136.41,66.16 137.09,65.48 137.09,65.16 137.2,65.05 R1831.2
  BOTTOM w0.102: CPU1.AT10 130.18,76.22 v2(129.85,76.55)
CLKREQ_PCIE#4: length 16.4
  TOP w0.102: v2(130.77,75.9) 131.3,75.37 131.3,74.55 131.79,74.06 131.79,73.19 132.16,72.82 v1(132.16,72.72) 132.16,72.2 133.61,70.74 133.98,70.74 134.59,70.13 134.92,70.13 135.19,69.87 136.26,69.87 139.29,66.84 139.29,66.33 139.68,65.95 R1832.2
  BOTTOM w0.102: v2(130.77,75.9) 131.1,75.57 CPU1.AU8
CLKREQ_PCIE#5: length 18.2
  TOP w0.102: v2(131.68,75.9) 132.62,74.96 v1(132.89,74.96) 133.93,74.96 135.1,73.79 136.33,73.79 137.71,72.4 137.71,70.83 139.42,69.12 140.91,67.63 141.06,67.63 143.04,65.65 143.04,65.27 142.76,64.99 R1833.2
  BOTTOM w0.102: CPU1.AU7 132.01,75.57 v2(131.68,75.9)
CLKREQ_PEG#0: length 118.5
  TOP w0.102: v2(130.77,76.55) 131.2,76.12 131.2,75.77 131.53,75.44 131.53,74.79 132.03,74.28 132.03,73.84 134.06,71.81 134.06,71.71 134.28,71.48 134.61,71.48 134.67,71.43 134.69,71.43 134.84,71.28 134.89,71.28 135.25,70.92 135.25,70.44 135.48,70.21 135.88,70.21 136.03,70.07 136.35,70.07 139.61,66.8 139.61,66.41 v2(140.39,65.64) 140.45,65.57 140.45,64.85 R1817.2 ; v2(175.27,128.15) 175.27,125.45 174.69,124.86 v1(174.69,123.4) 174.69,123.13 173.43,121.88 v2(173.43,119.31)
  L3 w0.102: v2(140.39,65.64) 141.11,65.64 141.5,66.03 146.32,66.03 146.78,66.5 154.33,66.5 154.88,65.95 158.29,65.95 158.59,65.64 160.63,65.64 161.65,66.66 161.65,67.6 162.54,68.49 165.21,68.49 165.25,68.45 167.09,68.45 167.13,68.49 167.13,68.49 v2(167.11,68.49)
  L4 w0.102: v2(173.43,119.31) 173.73,119.01 173.73,117.64 173.06,116.96 173.06,114.71 175.82,111.95 175.82,111.19 173.32,108.69 173.32,102.96 174.01,102.27 174.01,100.47 172.74,99.2 172.74,96.87 172.1,96.23 172.1,94.55 172.08,94.53 172.08,90.19 171.3,89.42 171.3,89.06 171.65,88.71 v2(171.65,87.92)
  BOTTOM w0.102: v2(130.77,76.55) 130.64,76.55 CPU1.AR10 ; v2(167.11,68.49) 167.13,68.49 167.64,69.01 169.98,69.01 170.69,69.72 170.69,71.19 170.27,71.61 169.87,71.61 169.86,71.61 169.66,71.61 168.94,72.33 168.94,75.44 169.47,75.98 169.47,76.7 170.85,78.08 170.85,81.4 171.37,81.91 171.37,85.06 171.27,85.16 171.27,87.06 171.54,87.33 171.54,87.63 171.65,87.74 v2(171.65,87.92) ; Q7301.D 176.35,129.16 R7305.1 175,128.43 v2(175.27,128.15)
CLKRUN#: length 84.5
  TOP w0.102: v2(175.23,83.4) 174.85,83.78 174.85,84.09 R2510.1 175.68,83.97 KBC24.63 ; R1819.2 134.69,63.58 134.35,63.23 134.35,62.72 v2(134.2,62.57)
  L3 w0.102: v2(179.16,58.17) 178.85,58.48 178.05,58.48 177.9,58.64 173.75,58.64 173.75,58.64 173.75,58.64 173.57,58.81 173.12,58.81 173.12,58.81 173.11,58.81 171.69,60.24 165.43,60.24 161.78,60.24 161.06,59.53 160.53,59.53 160.52,59.52 156.18,59.52 153.74,57.08 149.8,57.08 147.47,59.41 143.96,59.41 143.84,59.29 143.38,59.29 143,59.67 140.76,59.67 139.9,60.53 136.55,60.53 136.44,60.63 135.68,60.63 134.56,61.75 134.56,62.08 134.2,62.45 v2(134.2,62.57)
  BOTTOM w0.102: v2(175.23,83.4) 175.23,83.01 177.12,81.12 v1(177.12,80.67) 177.12,80.05 177.16,80.01 177.16,79.49 177.6,79.05 177.6,77.27 178.31,76.56 178.31,74.72 178.43,74.6 178.43,74.53 179.07,73.89 179.07,72.6 180.64,71.03 180.64,68.44 180.66,68.42 180.66,66 181.15,65.52 181.15,63.09 182,62.24 182,60.71 179.47,58.17 v2(179.16,58.17)
CLKRUN#_R: length 14.3
  TOP w0.14: R1818.1 R1819.1 134.44,65.04 134.44,66.04 134.69,66.3 134.69,67.13 133.63,68.19 133.63,68.96 132.92,69.68 132.24,69.68 131.06,70.86 131.06,72.45 v1(130.27,73.24) 129.62,73.89 v2(129.62,74.96)
  BOTTOM w0.14: v2(129.62,74.96) 129.54,74.88 CPU1.AW11
CMP_STRAP0: length 5.3
  TOP w0.102: KBC24.118 183.68,65.89 184.39,65.17 v1(184.39,63.83) 184.39,62.42 184.17,62.19 R2420.1
CMP_VIN0: length 3
  TOP w0.14: R2470.2 191.25,75.49 v1(191.2,75.54) 190.93,75.81 KBC24.20
CMP_VIN0_R: length 80.4
  TOP w0.14: v2(197.6,71.36) 196.56,71.36 196.4,71.51 194.99,71.51 194.56,71.94 C2613.1 193.92,74.3 193.02,75.2 R2470.1
  L3 w0.127: v2(195.96,88.53) 195.12,89.37 195.12,89.46 192.72,91.85 192.18,91.85 191.83,92.2 190.7,92.2 187.4,95.5 187.4,97.64 186.17,98.86 184.78,98.86 182.03,101.61 178.56,101.61 177.35,102.82 174.6,102.82 174.17,103.25 172.56,103.25 171.69,102.38 159.93,102.38 159.51,101.97 158.92,101.97 158.39,101.43 156.37,101.43 v2(156.19,101.61)
  BOTTOM w0.14: v2(195.96,88.53) 196.04,88.53 196.54,88.02 196.54,87.59 195.98,87.03 195.98,83.71 196.78,82.91 196.78,81.98 197.36,81.39 197.36,77.73 197.68,77.41 197.68,75.7 v1(198.04,75.34) 198.04,73.39 197.61,72.96 197.61,71.6 197.6,71.6 v2(197.6,71.36) ; C2612.1 152.71,99.09 R2610.1 153.79,98.96 R2608.2 R2609.2 154.74,100.85 155.5,101.61 v2(156.19,101.61)
CMP_VOUT0: length 51.4
  TOP w0.102: v2(170.05,72.04) 170.11,71.98 172.33,71.98 172.96,72.61 KBC24.85
  L3 w0.102: v2(173.31,101.7) 172.84,101.7 172.01,100.87 167.13,100.87 166.46,100.21 164.06,100.21 v2(163.82,100.45)
  L4 w0.102: v2(173.31,101.7) 172.91,101.7 172.18,100.98 172.18,97.1 171.54,96.46 171.54,94.79 171.52,94.76 171.52,92.83 170.96,92.27 170.96,90.86 169.85,89.76 169.85,87.93 170.5,87.28 170.5,84.73 170.48,84.7 170.48,84.69 170.48,84.69 170.48,84.33 170.48,84.33 170.48,83.35 169.46,82.34 169.46,82.13 169.23,81.89 169.23,78.6 169,78.38 169,77.83 169.62,77.21 169.62,75.69 169.14,75.21 169.14,74.85 169.4,74.6 169.74,74.6 170.08,74.27 170.08,73.91 169.94,73.78 169.94,72.14 v2(170.05,72.04)
  BOTTOM w0.102: v2(163.82,100.45) 163.76,100.39 R2612.2 R2607.2 R2602.2 ; v2(170.05,72.04) 169.75,72.04 v1(169.45,72.33)
CMP_VOUT1: length 17.1
  TOP w0.14: KBC24.83 172.93,73.41 172.07,72.55 v1(170.46,72.55) 168.92,72.55 167.5,73.98 166.44,73.98 165.98,73.52 165.98,72.49 165.71,72.21 R2417.1 165,72.48 R2418.1 165.28,73.89 165.28,75.92 Q2408.G
CODEC_BITCLK_R: length 3.1
  TOP w0.14: R2720.2 33.13,16.35 33.01,16.23 32.53,16.23 31.97,15.67 v1(31.57,15.67) HDA27.6
CODEC_SDOUT_R: length 7.7
  TOP w0.14: R2719.2 35.03,19.32 v2(34.91,19.2) ; HDA27.5 32.32,15.27 v2(32.41,15.36)
  L3 w0.127: v2(32.41,15.36) 32.73,15.68 32.73,17.02 v2(34.91,19.2)
COMBO-GPI: length 2.7
  TOP w0.102: TP2702.1 31.32,11.16 30.04,12.43 29.74,12.43 29.55,12.62 HDA27.48
CPU_A16_TP: length 5.5
  TOP w0.102: TP1902.1 134.08,69.8 v2(133.83,70.06)
  BOTTOM w0.102: CPU1.BB9 130.82,72.16 130.83,72.15 130.83,71.63 130.86,71.61 130.86,71.01 131.75,70.12 133.74,70.12 133.8,70.06 v2(133.83,70.06)
CPU_D1_TP: length 8.3
  BOTTOM w0.089: 138.15,89.57 137.74,89.15 136.93,89.15 136.9,89.18 135.61,89.18 135.5,89.13 135.27,89.13 CPU1.M2
  BOTTOM w0.102: TP1801.1 141.69,89.99 138.58,89.99 138.15,89.57
CPU_D4_TP: length 10.6
  BOTTOM w0.102: CPU1.V1 136.58,85.61 136.66,85.53 139.76,85.53 140.51,86.28 142.74,86.28 143.37,86.91 144.58,86.91 TP1804.1
CPU_D5_TP: length 10
  BOTTOM w0.089: CPU1.V2 134.74,85.61 135.02,85.82 135.19,85.82 135.29,85.87 135.49,85.87 135.65,85.79 136.67,85.79
  BOTTOM w0.102: 136.67,85.79 136.75,85.72 139.56,85.72 140.35,86.5 142.51,86.5 143.48,87.47 TP1805.1
CPU_D6_TP: length 3.5
  BOTTOM w0.089: CPU1.M1 135.77,88.97 137.81,88.97 137.95,89.11 138.1,89.11 138.52,89.53 138.97,89.53 TP1806.1
CPU_DP1_CTRL_CLK: length 301.5
  TOP w0.14: Q5402.4 v2(18.27,68.85)
  L3 w0.127: v2(128.12,88.64) 128.18,88.64 128.6,89.06 129.49,89.06 130.11,89.68 130.94,89.68 131.18,89.91 131.18,91.65 132.38,92.86 132.38,93.02 137.26,97.9 v2(137.26,97.99) 137.26,98.18 137.73,98.65 139.26,98.65 140.19,99.58 146.5,99.58 146.93,100.01 150.99,100.01 151.85,100.87 153.69,100.87 156.26,103.44 158.9,103.44 159.42,103.96 164.84,103.96 165.61,104.73 176.08,104.73 v2(176.22,104.86) ; v2(173.12,42.25) 173.12,42.08 168.05,37.01 160.51,37.01 158.31,34.81 144.06,34.81 v2(143.89,34.64)
  L4 w0.127: v2(34.92,69.94) 34.7,69.72 24.9,69.72 24.17,68.99 19.66,68.99 19.58,68.91 19.56,68.91 19.5,68.85 v2(18.27,68.85)
  BOTTOM w0.14: v2(173.12,42.25) 173.12,47.2 173.44,47.52 173.44,52.92 175.4,54.89 175.4,56.99 177.41,59 177.41,66.29 178.27,67.15 178.27,71.22 177.56,71.93 177.56,72.91 177.56,72.92 177.56,73.26 176.92,73.9 176.92,73.97 176.8,74.09 176.8,75.21 175.16,76.85 175.16,77.32 174.88,77.6 174.88,78 174.7,78.17 174.7,81.66 174.25,82.11 174.25,83.76 178.86,88.37 178.86,89.74 179.45,90.33 179.45,96.53 176.41,99.57 176.41,104.67 v2(176.22,104.86) ; v2(143.89,34.64) 143.66,34.87 v1(142.44,34.87) 133.91,34.87 128.12,40.66 122.9,40.66 119.99,43.58 81.66,43.58 75,50.24 60.8,50.24 58.58,52.46 56.49,52.46 47.83,61.12 46.08,61.12 37.6,69.6 35.26,69.6 v2(34.92,69.94) ; RN801.4 137.21,98.07 137.26,98.02 v2(137.26,97.99) ; v2(128.12,88.64) 128.43,88.95 CPU1.L13
CPU_DP1_CTRL_DATA: length 301.6
  TOP w0.14: v2(15.44,70.88) Q5402.1
  L3 w0.127: v2(172.14,42.23) 172.14,41.64 167.89,37.39 160.35,37.39 158.15,35.19 143.98,35.19 v2(143.87,35.29) ; v2(175.75,104.24) 175.65,104.35 165.77,104.35 165,103.58 159.58,103.58 159.06,103.06 156.42,103.06 153.85,100.49 153.05,100.49 152.19,99.63 147.09,99.63 146.66,99.19 140.4,99.19 139.3,98.09 v2(137.89,98.09) 137.89,97.79 134.44,94.34 134.3,94.34 132.09,92.14 132.09,89.92 131.82,89.65 131.28,89.65 131.09,89.46 130.24,89.46 v2(129.42,88.64)
  L4 w0.127: v2(36.41,70.11) 36.11,70.41 34.23,70.41 33.92,70.1 24.74,70.1 24.01,69.37 19.5,69.37 19.42,69.29 18.22,69.29 16.63,70.88 v2(15.44,70.88)
  BOTTOM w0.14: RN801.3 137.86,98.12 137.89,98.09 v2(137.89,98.09) ; v2(36.41,70.11) 37.68,70.11 46.25,61.54 48,61.54 56.52,53.02 58.81,53.02 61.03,50.8 75.23,50.8 81.89,44.14 120.22,44.14 123.13,41.22 128.35,41.22 134.28,35.29 v1(139.21,35.29) v2(143.87,35.29) ; CPU1.L12 129.42,88.77 v2(129.42,88.64) ; v2(172.14,42.23) 172.7,42.8 172.7,47.37 173.02,47.69 173.02,53.09 174.98,55.06 174.98,57.16 176.99,59.17 176.99,59.81 177,59.81 177,64.85 176.99,64.85 176.99,66.47 177.85,67.32 177.85,71.04 177.14,71.76 177.14,73.09 176.5,73.73 176.5,73.79 176.38,73.92 176.38,75.04 174.74,76.68 174.74,77.14 174.46,77.42 174.46,77.82 174.28,77.99 174.28,81.48 173.83,81.94 173.83,83.93 178.44,88.54 178.44,89.91 179.03,90.5 179.03,96.36 175.99,99.39 175.99,104 v2(175.75,104.24)
CPU_DP1_HPD: length 326.5
  TOP w0.102: v2(168.69,95.58) v1(169.28,95.58)
  L3 w0.102: v2(130.73,88.64) 131.15,89.06 131.84,89.06 132.11,89.06 132.32,89.27 132.9,89.27 135.95,92.33 137.35,92.33 137.5,92.48 137.51,92.48 138.36,93.33 138.96,93.33 139.49,93.85 142.3,93.85 142.89,94.44 143.32,94.44 143.59,94.72 146.86,94.72 146.86,94.72 149.42,94.72 149.43,94.71 150.03,94.11 153.71,94.11 155.05,95.45 158.86,95.45 158.97,95.34 158.97,95.34 159.23,95.08 160.82,95.08 161.73,96 168.28,96 v2(168.69,95.58) ; v2(175.17,24.25) 175.17,23.7 173.87,22.4 169.79,22.4 169.43,22.76 166.08,22.76 162.6,26.24 156.56,26.24 156.3,25.98 149.48,25.98 140,16.5 135.98,16.5 130.08,10.59 96.05,10.59 91.32,15.32 78.22,15.32 74.11,19.44 74.11,22.52 74.11,22.98 73.44,23.65 73.44,23.84 66.46,30.82 65.54,30.82 65.29,31.07 64.02,31.07 62.18,32.9 60.97,32.9 58.19,35.68 58.19,37.26 56.89,38.56 56.89,56.57 48.35,65.11 47.4,65.11 32.67,79.84 v2(22.65,79.84)
  L4 w0.102: v2(175.17,24.25) 175.17,24.65 174.4,25.42 174.4,28.19 173.74,28.85 173.74,31.62 173.05,32.31 173.05,32.79 167.2,38.64 167.2,41.58 167.69,42.07 167.69,44.32 167.66,44.36 167.66,52.32 167.04,52.94 167.04,62.9 167.14,63 167.14,64.91 167.66,65.42 168.87,66.63 168.87,68.21 169.04,68.38 169.04,68.74 168.87,68.91 168.87,71.29 169.39,71.81 169.39,73.69 169.13,73.95 169.13,74.44 168.84,74.72 168.84,75.63 169.32,76.11 169.32,77.08 168.7,77.7 168.7,78.51 168.92,78.73 168.92,82.02 169.07,82.17 169.07,83.99 168.98,84.08 168.98,85.1 168.15,85.94 168.15,86.73 168.41,86.99 168.41,90.64 168.22,90.83 168.22,92.61 168.37,92.75 168.37,93.45 168.22,93.6 168.22,94.65 168.69,95.11 v2(168.69,95.58)
  BOTTOM w0.102: CPU1.L9 130.93,89.01 130.93,88.85 v2(130.73,88.64) ; R5419.1 22.63,78.53 22.63,79.61 22.65,79.63 v2(22.65,79.84)
CPU_DP2_CTRL_CLK: length 15.1
  TOP w0.14: v2(132.07,87.64) v1(132.7,87.64) ; R803.2 143.12,90.77 143.48,91.13 v2(143.51,91.13)
  L3 w0.127: v2(132.07,87.64) 134.08,87.64 134.86,88.42 137.07,88.42 138.42,89.77 139.57,89.77 139.69,89.64 140.61,89.64 141.02,90.05 142.4,90.05 143.48,91.13 v2(143.51,91.13)
  BOTTOM w0.14: v2(132.07,87.64) 132.07,87.9 CPU1.N7
CPU_DP2_CTRL_DATA: length 18.3
  TOP w0.14: v2(144.86,92.68) 144.35,92.68 v1(144.19,92.84) 144,93.03 R804.2
  L3 w0.127: v2(144.86,92.68) 144.84,92.67 142.05,92.67 141.4,92.02 140.39,92.02 139.01,90.64 138.16,90.64 138.12,90.68 136.02,90.68 134.12,88.78 133.49,88.78 132.76,88.05 131.78,88.05 v2(131.38,87.64)
  BOTTOM w0.14: v2(131.38,87.64) 131.4,87.67 131.4,87.89 CPU1.N8
CPU_DP2_HPD: length 52.3
  TOP w0.102: v2(153.52,92.24) 153.79,92.24 154.36,92.81 R807.2 R805.2 ; v2(194.25,85.83) v1(194.25,85.17) 194.25,83.38 194.61,83.02 VGABD1.16
  L3 w0.102: v2(153.52,92.24) 153.61,92.24 154.86,93.48 154.86,93.53 155.81,94.48 158.18,94.48 158.64,94.03 162.7,94.03 162.7,94.03 164.04,94.03 164.04,94.03 164.09,94.03 164.51,94.45 166.77,94.45 166.91,94.31 168.14,94.31 169.02,93.43 170.79,93.43 172.48,91.73 172.48,91.73 172.93,91.28 177.03,91.28 177.13,91.38 179.39,91.38 179.4,91.38 180.82,91.38 181.63,90.57 188.53,90.57 190.01,89.09 190.93,89.09 194.18,85.83 194.26,85.83 v2(194.25,85.83)
  BOTTOM w0.102: R806.1 153.28,92 v2(153.52,92.24)
CPU_DP2_HPD1: length 25.3
  TOP w0.102: v2(132.01,88.63) 132.01,88.69 132.35,89.03 133.38,89.03 135.09,90.75 135.87,90.75 137.08,91.95 138.96,91.95 139.56,92.56 141.22,92.56 141.62,92.15 143.31,92.15 144.08,91.38 149.02,91.38 v1(150.33,92.69) 151.58,93.94 R805.1
  BOTTOM w0.102: v2(132.01,88.63) 132.01,88.78 CPU1.L7
CPU_DP2_HPD3: length 26.6
  TOP w0.102: R807.1 153.18,93.41 v1(152.39,93.41) 151.57,93.41 149.34,91.18 144.28,91.18 143.43,90.32 141.6,90.32 141.07,90.86 140.51,90.86 140.26,91.11 139.6,91.11 139.05,90.56 135.17,90.56 132.85,88.24 131.32,88.24 v2(130.72,87.64)
  BOTTOM w0.102: CPU1.N9 131.03,87.95 v2(130.72,87.64)
CPU_POPIRCOMP: length 12.8
  TOP w0.152: v2(126.19,76.55) 126.19,76.49 125.7,76 125.7,75.69 125.53,75.52 125.53,74.84 125.84,74.53 125.84,73.21
  TOP w0.508: 125.84,73.21 125.84,72.19 125.79,72.14 v1(125.79,67.54) R412.1
  BOTTOM w0.305: CPU1.AT16 126.64,76.22 126.31,76.55 v2(126.19,76.55)
CPU_RXN_C_DGPU_TXN0: length 82.2
  TOP w0.127: C7302.1 177.7,141.45 176.99,141.45 176.68,141.76 171.94,141.76 170.26,140.08 169.53,140.08 166.21,136.77 166.21,131.06 163.87,128.72 163.87,128.08 161.62,125.83 161.62,124.14 159.16,121.68 ; 159.16,121.68 v1(159.02,121.82) ; 159.16,121.68 157.14,119.66 157.14,118.13 154.8,115.79 151.26,115.79 144.44,108.97 144.44,107.3 143.56,106.42 143.56,105.17 141.47,103.08 140.2,103.08 135.65,98.53 135.34,98.53 134.72,97.9 134.72,97.1 133.26,95.65 132.52,95.65 131.56,94.68 129.91,94.68 128.1,92.87 128.1,90.6 128.46,90.25 128.78,90.25 v2(128.94,90.09)
  BOTTOM w0.127: CPU1.H13 128.61,90.41 v2(128.94,90.09)
CPU_RXN_C_DGPU_TXN1: length 77.7
  TOP w0.127: 161.9,122.33 v1(162.02,122.21) ; 161.9,122.33 159.16,119.59 159.16,117.73 157.74,116.32 156.77,116.32 155.23,114.77 151.68,114.77 145.8,108.89 145.8,107.22 144.57,106 144.57,104.69 141.95,102.06 140.64,102.06 136.47,97.89 136.47,96.34 135.3,95.17 135.3,93.76 134.76,93.22 131.12,93.22 129.55,91.65 129.07,91.65 128.94,91.52 v2(128.94,91.39) ; 161.9,122.33 162.64,123.07 162.64,125.35 165.04,127.75 165.04,128.38 167.37,130.71 167.37,136.49 169.82,138.94 170.62,138.94 172.29,140.61 174.64,140.61 174.76,140.48 174.76,140.19 174.89,140.07 C7304.1
  BOTTOM w0.127: CPU1.G11 129.07,91.39 v2(128.94,91.39)
CPU_RXN_C_DGPU_TXN2: length 81.5
  TOP w0.127: C7306.1 173.31,142.97 172.5,142.97 172.17,142.64 170.91,142.64 168.01,139.74 166.42,139.74 163.74,137.06 162.15,137.06 159.26,134.17 159.26,131.26 160.7,129.81 160.7,124.95 160.14,124.39 ; v2(127.11,90.74) 127.43,90.74 127.6,90.91 127.6,93.06 129.7,95.16 130.8,95.16 132.1,96.46 132.86,96.46 133.86,97.46 133.86,98.29 135.52,99.96 135.52,100.25 139.12,103.85 141.07,103.85 142.25,105.03 142.25,106.22 143.17,107.15 143.17,108.8 150.94,116.57 154.48,116.57 156.37,118.45 156.37,120.61 160.14,124.39 ; 160.14,124.39 v1(160.04,124.49)
  BOTTOM w0.127: v2(127.11,90.74) 127.11,90.44 126.98,90.31 126.75,90.31 CPU1.H16
CPU_RXN_C_DGPU_TXN3: length 83.3
  TOP w0.127: C7308.1 175.04,144.32 172.65,144.32 171.76,143.43 170.6,143.43 167.69,140.52 166.1,140.52 163.42,137.84 161.65,137.84 158.48,134.66 158.48,130.92 159.63,129.77 159.63,126.03 ; 159.63,126.03 159.63,125.41 155.46,121.25 155.46,118.64 154.16,117.34 150.62,117.34 142.4,109.12 142.4,107.49 139.54,104.63 138.53,104.63 137.48,103.57 136.94,103.57 134.61,101.25 134.61,100.69 133.45,99.52 132.6,99.52 130.9,97.82 130.9,96.79 130.45,96.34 129.49,96.34 126.62,93.46 126.62,91.88 v2(127.11,91.39) ; 159.63,126.03 v1(159.49,126.03)
  BOTTOM w0.127: v2(127.11,91.39) 127.43,91.06 CPU1.G15
CPU_RXP_C_DGPU_TXP0: length 81.8
  TOP w0.127: 160.58,122.75 161.87,124.04 161.87,125.73 164.11,127.98 164.11,128.62 166.46,130.96 166.46,136.67 169.63,139.84 170.36,139.84 172.04,141.52 176.58,141.52 176.89,141.2 177.79,141.2 177.94,141.06 C7301.1 ; 160.58,122.75 157.38,119.56 157.38,118.03 154.9,115.55 151.36,115.55 144.68,108.87 144.68,107.2 143.8,106.32 143.8,105.07 141.57,102.84 140.3,102.84 135.75,98.29 135.44,98.29 134.96,97.8 134.96,97 133.36,95.41 132.62,95.41 131.66,94.44 130.01,94.44 128.34,92.77 128.34,90.7 128.56,90.49 128.86,90.49 128.94,90.57 v2(128.94,90.74) ; 160.58,122.75 v1(160.7,122.63)
  BOTTOM w0.127: v2(128.94,90.74) 128.64,90.74 128.48,90.89 CPU1.G13
CPU_RXP_C_DGPU_TXP1: length 77.2
  TOP w0.127: 159.69,120.47 158.92,119.69 158.92,117.83 157.64,116.56 156.67,116.56 155.13,115.02 151.58,115.02 145.56,108.99 145.56,107.32 144.33,106.1 144.33,104.79 141.85,102.3 140.54,102.3 136.23,97.99 136.23,96.44 135.06,95.27 135.06,93.86 134.66,93.46 131.02,93.46 129.45,91.89 129.09,91.89 v2(128.94,92.04) ; 159.69,120.47 162.4,123.17 162.4,125.45 164.8,127.85 164.8,128.48 167.13,130.81 167.13,136.59 169.72,139.18 170.52,139.18 172.19,140.85 175.31,140.85 C7303.1 ; 159.69,120.47 v1(159.58,120.57)
  BOTTOM w0.127: CPU1.F11 129.07,92.04 v2(128.94,92.04)
CPU_RXP_C_DGPU_TXP2: length 82.4
  TOP w0.127: v2(126.2,90.74) 126.61,90.32 127.36,90.32 127.84,90.81 127.84,92.96 129.8,94.92 130.9,94.92 132.2,96.21 132.96,96.21 134.1,97.36 134.1,98.19 135.76,99.86 135.76,100.15 139.22,103.61 141.17,103.61 142.49,104.93 142.49,106.12 143.42,107.05 143.42,108.7 151.04,116.32 154.58,116.32 156.61,118.35 156.61,120.51 160.95,124.85 160.95,127.02 ; 160.95,127.02 v1(161.09,127.02) ; 160.95,127.02 160.95,129.91 159.5,131.36 159.5,134.07 162.25,136.82 163.84,136.82 166.52,139.5 168.11,139.5 171.01,142.4 172.27,142.4 172.6,142.73 173.21,142.73 C7305.1
  BOTTOM w0.127: CPU1.G16 126.52,91.06 v2(126.2,90.74)
CPU_RXP_C_DGPU_TXP3: length 82.3
  TOP w0.127: 157.9,123.35 155.7,121.15 155.7,118.54 154.26,117.1 150.72,117.1 142.64,109.02 142.64,107.39 139.64,104.39 138.63,104.39 137.58,103.33 137.04,103.33 134.86,101.15 134.86,100.59 133.55,99.28 132.7,99.28 131.14,97.72 131.14,96.69 130.55,96.1 129.59,96.1 126.86,93.36 126.86,92.19 126.91,92.14 127.01,92.04 v2(127.11,92.04) ; 157.9,123.35 159.87,125.31 159.87,129.87 158.72,131.02 158.72,134.56 161.75,137.6 163.52,137.6 166.2,140.27 167.79,140.27 170.7,143.19 171.86,143.19 172.75,144.08 175.03,144.08 175.27,143.84 C7307.1 ; 157.9,123.35 v1(158,123.25)
  BOTTOM w0.127: CPU1.F15 127.37,91.71 127.11,91.97 v2(127.11,92.04)
CPVDD: length 13.7
  BOTTOM w0.508: v2(24.13,13.17) 24.97,14.01 26.52,14.01 27.08,13.45 27.08,11.96 26.55,11.43 26.55,8.56 25.63,7.63 v1(22.89,7.63) 21.88,7.63 v3(21.88,7.63)
CPVEE: length 2.4
  TOP w0.203: v1(23.12,14.4) 23.18,14.4 23.25,14.47 HDA27.34
  TOP w0.305: v1(23.12,14.4) 23.12,14.37 22.55,13.8 C2704.2
CSI2_COMP: length 4.5
  TOP w0.508: v2(129.12,92.85) 130.18,93.92 v1(130.58,93.92) R1501.1
  BOTTOM w0.305: CPU1.E13 128.85,92.73 128.99,92.73 v2(129.12,92.85)
DAT_TP_SIO: length 227.7
  TOP w0.14: v2(50.1,80.67) 50.17,80.6 50.17,79.44 50.4,79.21 RN6504.3 51.01,78.96 EC6501.1 52.31,79.08 RN6503.2 ; KBC24.79 174.74,75.01 175.28,74.47 175.29,74.47 v2(175.38,74.38)
  L3 w0.127: v2(144.18,30.54) 153.09,30.54 154.85,32.31 170.97,32.31 172.18,31.1 175.04,31.1 v2(175.85,31.91) ; v2(58.68,50.4) 58.77,50.48 58.77,59.49 54.61,63.65 50.99,63.65 45.24,69.4 45.24,70.48 41.77,73.96 41.77,74.38 41.77,74.38 41.77,78.68 43.75,80.67 v2(50.1,80.67)
  L4 w0.127: v2(175.85,31.91) 175.23,32.54 175.23,35.15 174.87,35.51 174.87,44.28 174.39,44.76 174.39,49.82 172.61,51.61 172.61,53.07 172.91,53.37 172.91,55.01 172.63,55.29 172.63,55.63 172.9,55.89 172.9,56.9 173.47,57.47 173.47,57.84 172.9,58.42 172.9,59.88 172.47,60.3 172.47,64.45 174.17,66.15 174.65,66.15 175.51,67.01 175.51,68.47 176.31,69.27 176.31,71.05 175.79,71.57 175.79,72.3 175.15,72.94 175.15,73.32 175.35,73.52 175.35,74.35 v2(175.38,74.38)
  BOTTOM w0.14: v2(58.68,50.4) 59.38,50.4 60.1,49.68 74.77,49.68 81.43,43.02 119.76,43.02 122.67,40.1 127.89,40.1 135.13,32.86 141.13,32.86 v1(143.16,30.83) 143.45,30.54 v2(144.18,30.54)
DBC_EN_R: length 9.6
  TOP w0.102: LCD1.8 76.74,173.82 v2(75.74,172.82)
  BOTTOM w0.102: R5518.1 74.48,177.56 v1(75.26,176.79) 75.74,176.3 v2(75.74,172.82)
DBC_PANEL_EN: length 230.5
  L3 w0.102: v2(144.88,78.48) 145.03,78.48 145.6,79.05 146.52,79.05 146.62,78.95 150.4,78.95 150.92,79.47 157.41,79.47 158.1,78.78 162.79,78.78 163.31,78.26 163.58,78.26 163.98,77.86 164.66,77.86 165.88,79.07 165.9,79.07 166.14,79.31 166.14,80.53 v2(166.15,80.54) ; v2(71.18,177.36) 71.56,176.98 75.15,176.98 77.74,174.39 80.98,174.39 81.23,174.64 81.23,174.83 82.18,175.79 85.25,175.79 86.15,174.89 88.24,174.89 90.2,176.85 101.05,176.85 101.38,177.18 113.82,177.18 115.42,175.58 118.76,175.58 119.11,175.92 119.64,175.92 120.29,175.27 126.65,175.27 127.4,176.03 134.74,176.03 135.91,174.85 149.18,174.85 152.3,171.73 156.2,171.73 159.08,168.85 159.08,167.89 v2(159.12,167.85)
  L4 w0.102: v2(159.12,167.85) 159.07,167.85 158.39,167.17 158.39,164.39 160.58,162.2 160.58,160.03 161.21,159.4 161.21,154.94 159.92,153.65 159.92,151.67 160.49,151.09 160.49,149.13 159.42,148.06 159.42,140.22 159.42,140.22 159.42,138.67 160.58,137.51 160.58,131.81 162.32,130.07 162.32,119.83 161.71,119.23 161.71,109.52 162.38,108.86 162.38,103.3 161.69,102.61 161.69,101.61 160.92,100.84 160.92,99.68 161.39,99.22 161.39,93.05 161.44,93 161.44,91.5 160.76,90.83 160.76,89.74 163.37,87.13 164.49,87.13 164.72,86.9 164.72,85.65 165.38,84.98 165.38,84.79 165.52,84.65 165.52,83.56 165.67,83.41 165.67,81.32 166.15,80.83 v2(166.15,80.54)
  BOTTOM w0.089: CPU1.AM5 133.39,78.49 133.39,78.18 133.6,77.97 133.93,77.97 133.95,77.99 136.02,77.99 136.5,77.5 136.97,77.5
  BOTTOM w0.102: v2(71.18,177.36) 71.85,177.36 R5518.2 ; 136.97,77.5 141.36,77.5 141.99,78.13 R2043.2 142.33,78.13 142.79,78.59 v1(144.29,78.59) 144.77,78.59 v2(144.88,78.48)
DC_IN_D: length 3.5
  TOP w0.381: PQ4402.3 105.47,166.21 105.72,166.46
  TOP w0.508: PR4405.2 v1(106.09,166.84) 105.72,166.46
DCBATOUT: length 249.8
  TOP w0.203: PU4503.12 38.74,52.15 38.5,51.92 PC4531.1
  TOP w0.508: PR4601.1 109.63,138.18 v2(109.34,138.48) ; PR4458.1 121.34,167.99 122.17,167.16 122.17,166.31 v2(122.15,166.29) ; v2(135.67,13.94) 146.52,13.94 148.35,15.77 v2(148.35,16.04) 148.35,16.83 151.66,20.14 153.54,20.14 157.49,24.08 157.49,24.69 158.9,26.11 R6002.1 ; PR8312.2 149.74,36.11 149.33,36.52 149.33,36.98 148.59,37.71 v2(148.46,37.71) ; 27.6,51.12 33.71,51.12 34.76,52.17 37.15,52.17 37.43,51.89 PC4519.1 37.73,50.82 38.31,51.39 PC4531.1 ; R6103.1 163.98,57.92 164.17,57.73 v2(164.17,57.29)
  L3 w0.508: v2(160.58,41.99) 160.19,41.6 160.19,40.84 159.82,40.46 159.29,40.46 158.57,41.18 153.56,41.18 150.33,37.96 148.71,37.96 v2(148.46,37.71)
  L4 w0.508: v2(154.19,149.53) 154.19,150.48 156.38,152.67 156.38,156.57 153.53,159.42 153.53,163.31 149.51,167.33 v2(143.41,167.33) ; v2(135.67,13.94) 118.64,13.94 117.94,13.24 106.17,13.24 105.41,14 91.36,14 88.62,16.74 79.1,16.74 77.62,18.22 74.92,18.22 73.96,19.18 72.87,19.18 72.38,19.67 72.38,23.91 67,29.29 65.99,29.29 64.93,30.35 63.73,30.35 62.11,31.96 62.11,32.19 61.64,32.66 58.57,32.66 v2(58.17,33.06) ; v2(148.46,37.71) 147.47,36.71 147.47,17.67 148.35,16.79 v2(148.35,16.04)
  BOTTOM w0.508: v2(143.41,167.33) 141.18,169.55 137.53,169.55 134.91,166.94 125.09,166.94 124.45,166.29 v2(122.15,166.29) ; v2(160.58,41.99) 162.62,41.99 163.25,42.62 163.25,44.84 163.76,45.35 163.76,50.04 164.51,50.79 164.51,55.17 164.33,55.35 164.33,57.13 v2(164.17,57.29) ; PR8202.1 206.61,92.04 v2(206.6,92.05)
  vias: v1(25.57,61.88) v1(26.51,51.84) v1(51.1,58.27) v1(54.81,30.08) v1(75.48,85.2) v1(96.69,116.96) v1(116.45,134.65) v1(213.26,95.09) v3(100.45,123.31) v3(100.45,122.43) v3(100.45,121.54) v3(100.45,120.6) v3(100.45,119.76) v3(101.11,149.03) v3(101.21,122.93) v3(101.21,122.04) v3(101.23,121.05) v3(107.23,150.32) v3(107.28,152.25) v3(107.26,149.46) v3(108.15,150.3) v3(108.17,149.41) v3(108.38,152.23) v3(109.83,133.8) v3(109.83,132.96) v3(109.83,132.12) v3(109.93,135.66) v3(109.91,134.75) v3(110.67,132.96) v3(110.67,132.12) v3(111.14,134.83) v3(111.12,133.86) v3(111.37,135.72) v3(112.76,135.54) v3(112.8,134.52) v3(113.64,135.54) v3(113.69,134.52) v3(114.48,135.54) v3(114.53,134.52) v3(115.32,135.54) v3(115.37,134.52) v3(123.72,135.66) v3(123.72,134.83) v3(123.72,133.99) v3(123.72,133.15) v3(123.72,132.31) v3(124.56,135.66) v3(124.56,134.83) v3(124.56,133.99) v3(125.4,135.66) v3(125.4,134.83) v3(137.28,154.84) v3(137.28,153.95) v3(137.28,153.12) v3(138.17,154.84) v3(138.17,153.95) v3(138.17,153.12) v3(139.06,154.84) v3(139.06,153.95) v3(139.06,153.12) v3(139.99,154.86) v3(140,154.01) v3(198.99,104.69) v3(198.99,103.58) v3(198.98,102.51) v3(198.99,101.48) v3(199.95,103.84) v3(199.95,102.72) v3(199.94,101.65) v3(199.92,100.65) v3(217.55,101.17) v3(218.38,102.95) v3(218.38,102.06) v3(218.38,101.17) v3(219.27,103.84) v3(219.27,102.95) v3(219.27,102.06) v3(219.27,101.17)
DCBATOUT_+VCCSA:
  vias: v1(137.15,133.02) v3(137.75,133.53) v3(137.75,132.47)
DCBATOUT_CAMERA:
  vias: v1(95.73,150.6)
DCBATOUT_LCD: length 45.3
  L3 w1.016: v3(87.65,176.42) 86.92,177.15 77.07,177.15 v3(76.99,177.08)
  L4 w1.016: v3(91.92,147.32) 91.89,147.32 91.31,147.91 91.31,148.61 87.4,152.52 87.4,160.29 90.29,163.18 90.29,173.77 87.65,176.41 v3(87.65,176.42)
  BOTTOM w0.508: v3(76.99,177.08) 77.07,177.15 C5515.1
  vias: v1(91.54,149.56)
DDC_CLK_HDMI: length 17.9
  TOP w0.14: v1(14.66,71.71) 15.02,72.07 RN5401.1 16.05,71.55 16.28,71.32 16.28,70.57 16.29,70.57 16.29,69.02 16.12,68.85 Q5402.3 13.73,68.85 13.4,69.18 13.4,70.21 13.01,70.6 EU5703.4 EU5703.7 11.11,70.6 10.99,70.72 10.99,71.53 10.73,71.8 8.95,71.8 8.22,71.07 8.22,69.43 7.96,69.17 HDMI1.15
DDC_CLK_PH1: length 6.1
  TOP w0.14: RN5401.4 16.05,76.37 D5401.2 18.63,77.21 v1(18.66,77.18)
DDC_DATA_HDMI: length 16.1
  TOP w0.14: HDMI1.16 9.65,69.67 10.23,69.1 EU5703.10 EU5703.1 13.26,68.42 17.71,68.42 17.76,68.36 18.49,68.36 19.01,68.89 v1(19.01,69.91) 19.01,70.09 18.69,70.41 18.07,70.41 17.81,70.15 Q5402.6 17.3,70.15 16.7,70.75 RN5401.2
DDC_DATA_PH2: length 3.7
  TOP w0.14: RN5401.3 16.7,75.05 D5401.1 16.93,75.28 v1(18.58,75.28)
DDPD_CTRLDATA: length 1.2
  TOP w0.102: v2(128.77,88.65) 129.06,88.36 TP802.1
  BOTTOM w0.102: CPU1.N12 128.77,88.49 v2(128.77,88.65)
DDR0_PAR: length 1.3
  TOP w0.102: TP501.1 106.7,76.23 v2(107,76.52)
  BOTTOM w0.102: CPU1.AT52 106.7,76.22 v2(107,76.52)
DDR1_PAR: length 1.2
  TOP w0.102: v2(110.67,77.86) 110.68,77.87 TP502.1
  BOTTOM w0.102: CPU1.AP43 111.02,77.52 110.67,77.87 v2(110.67,77.86)
DDR3_DRAMRST#: length 166.4
  TOP w0.127: v2(86.48,13.92) 86.48,14.08 86.51,14.11 v1(86.51,15.47) D1319.2 86.02,17.09 C1301.1 ; v2(150.07,65.64) 150.07,65.67 150.03,65.72 R504.2 ; v2(71.95,28.67) 72.62,29.33 D1217.2 72.57,29.6 C1217.1
  L3 w0.127: v2(152.07,23.05) 149.29,23.05 138.89,12.65 134.83,12.65 131,8.83 94.82,8.83 91.64,12.01 88.25,12.01 86.65,13.6 86.65,13.75 v2(86.48,13.92) 86.27,14.14 77.5,14.14 72.2,19.44 72.2,23.18 v2(66.82,28.56)
  L4 w0.127: v2(152.07,23.05) 150.69,24.44 150.69,26.5 151.97,27.79 151.97,56.3 155.11,59.43 155.11,62.59 152.51,65.19 150.52,65.19 v2(150.07,65.64)
  BOTTOM w0.127: DM1.30 v2(71.95,28.67) 71.84,28.56 v2(66.82,28.56) ; v2(86.48,13.92) 86.48,14.11 86.45,14.14 DM2.30
DDR_VREF_S3: length 40.9
  TOP w0.508: R4212.1 v2(55.65,42.22) ; R4210.1 v2(55.47,46.79) ; v2(55.24,36.6) 55.51,36.87 R4204.1
  L4 w0.508: v2(48.75,28.27) 48.74,28.28 48.74,28.6 49.03,28.89 50.01,28.89 55.19,34.07 55.19,36.25 55.24,36.3 v2(55.24,36.6)
  BOTTOM w0.508: v2(48.75,28.27) 48.59,28.11 48.59,27.17 47.55,26.13 45.24,26.13 42.23,23.12 42.23,19.99 42.93,19.29 v3(44.09,19.29) ; v2(55.24,36.6) 55.24,36.6 53.92,37.93 v1(53.92,39.32) 53.92,40.49 v2(55.65,42.22) 55.65,43.57 54.6,44.63 54.6,45.92 v2(55.47,46.79)
DDR_VTT_PG_CTRL_R: length 4.2
  TOP w0.127: PU5101.17 48.27,24.36 49.02,25.11 v1(49.02,25.2) 49.02,25.3 48.8,25.52 48.25,25.52 47.97,25.8 PR5109.1 47.99,26.13 PR5110.1
DGPU_HOLD_RST#: length 98
  TOP w0.127: v2(150.74,90.69) 151.02,90.4 EC2002.1 151.56,89.37 152.08,89.89 RN2009.4 152.39,90.48 153.24,89.63 v1(158.31,89.63) 159.58,89.63 160.95,91.01 165.49,91.01 165.88,90.62 167.55,90.62 169.49,88.68 175.97,88.68 v2(176.25,88.4)
  L3 w0.127: v2(133.54,88.11) 134.17,88.11 136.23,90.17 139.72,90.17 139.87,90.02 140.43,90.02 140.86,90.45 142.1,90.45 143.22,91.58 145.52,91.58 145.88,91.22 150.2,91.22 v2(150.74,90.69) ; v2(175.28,124.59) 175.28,125.74 175.61,126.07 v2(180.33,126.07)
  L4 w0.127: v2(175.28,124.59) 175.48,124.59 176.73,123.34 176.73,119.13 178.32,117.54 178.32,110.2 179.42,109.1 179.42,102.78 178.79,102.16 178.79,96.59 177.2,95.01 177.2,90.89 177.02,90.7 177.02,89.16 v2(176.25,88.4)
  BOTTOM w0.102: v2(133.54,88.11) 133.73,88.11 134.25,87.6 CPU1.P3
  BOTTOM w0.127: U7301.1 179.63,125.21 179.77,125.08 R7304.1 v2(180.33,126.07)
DGPU_PWR_EN: length 175.6
  TOP w0.127: v2(152.36,91.9) 152.08,91.62 RN2009.3 152.5,91.13 152.93,91.56 154.03,91.56 155.48,90.11 v1(156.31,90.11) 159.7,90.11 160.85,91.26 165.64,91.26 166.01,90.88 167.64,90.88 168.84,89.68 175.84,89.68 176.18,89.35 176.39,89.35 v2(176.42,89.32) ; v2(199.92,97.14) 199.45,96.67 199.45,94.88 196.08,91.51 196.08,90.16 196.55,89.68 196.55,88.25 v2(196.09,87.79) ; v2(139.26,86.46) 141.65,86.46 141.8,86.3 147.6,86.3 148.43,87.13 151.88,87.13 v2(152.69,87.94)
  L3 w0.127: v2(215.26,97.29) 214.71,97.29 214.42,97 203.69,97 203.09,97.6 200.38,97.6 v2(199.92,97.14) ; v2(176.42,89.32) 176.69,89.32 178.14,87.86 182.78,87.86 183.18,88.26 184.57,88.26 185.2,87.63 185.5,87.63 186.03,87.09 186.25,87.09 187.16,86.19 188.02,86.19 190.42,83.79 193.47,83.79 195.3,85.62 195.3,87 v2(196.09,87.79)
  L4 w0.127: v2(166.06,141.94) 166.06,141.15 169.64,137.56 169.64,130.86 174.84,125.67 174.84,124.41 175.22,124.03 175.68,124.03 176.39,123.32 176.39,119.11 178.02,117.48 178.02,110.09 179.16,108.94 179.16,102.89 178.54,102.26 178.54,96.7 176.95,95.11 176.95,91.17 176.72,90.95 176.72,89.68 176.42,89.38 v2(176.42,89.32)
  BOTTOM w0.114: v2(139.26,86.46) 139.26,86.46 138.95,86.14 137.84,86.14 137.71,86.27 135.71,86.27 CPU1.U1
  BOTTOM w0.127: v2(152.36,91.9) 152.36,89.24 152.69,88.9 v2(152.69,87.94) ; v2(215.26,97.29) 215.06,97.49 PR8260.1 ; U8301.5 171.71,134.7 171.92,134.91 171.92,135.34 170.98,136.28 R8306.1 170.98,137.84 170.59,138.24 169.62,138.24 169.19,138.67 169.19,142.56 169.05,142.7 PQ8306.2 167.95,142.7 167.07,141.82 166.18,141.82 v2(166.06,141.94)
DGPU_PWR_EN#: length 5
  BOTTOM w0.102: PQ8306.6 169.63,142.05 169.49,142.19 169.49,142.56 169.63,142.7 PQ8306.5 171.08,142.7 171.5,142.28 PR8317.1 172.06,143.11 v1(171.95,143.22)
DGPU_PWROK: length 182.1
  TOP w0.127: v2(193.04,73.54) 193.28,73.3 EC2401.1 ; v2(193.42,89.22) 193.42,90.43 197.94,94.95 197.94,97.32 198.98,98.36 199.22,98.36 v2(199.53,98.67) ; R2427.2 192.01,84.58 v1(191.76,84.84) 191.48,85.12 191.48,86.15 v2(191.6,86.27) ; R8302.1 169.8,144.81 168.93,144.81 168.48,144.35 v2(167.09,144.35)
  L3 w0.127: v2(193.42,89.22) 193.41,89.21 192.08,89.21 191.95,89.33 190.11,89.33 188.63,90.81 182.05,90.81 v2(180.37,92.49) 177.16,92.49 176.52,91.85 174.79,91.85 173.35,93.28 173.35,93.28 172.17,94.46 169.46,94.46 168.88,95.04 167.24,95.04 167,95.28 164.34,95.28 164.18,95.12 163.81,95.12 163.8,95.12 163.73,95.12 163.37,95.48 161.67,95.48 161.04,94.84 159.13,94.84 158.76,95.21 155.21,95.21 153.87,93.87 149.93,93.87 149.33,94.47 146.77,94.47 145.27,94.47 v2(145.07,94.27) ; v2(205.44,97.57) 203.8,97.57 202.7,98.67 v2(199.53,98.67)
  L4 w0.127: v2(180.37,92.49) 180.37,92.82 181.4,93.85 181.4,100.64 181.06,100.98 181.06,101.38 181.68,101.99 181.68,104.11 181.17,104.62 181.17,105.59 181.17,105.59 181.17,111.27 180.59,111.86 180.59,115.78 179.62,116.74 179.62,117.49 177.78,119.34 177.78,119.41 176.98,120.2 176.98,123.89 171.86,129 171.86,130.99 169.9,132.95 169.9,137.66 166.62,140.95 166.62,143.36 167.09,143.83 v2(167.09,144.35) ; v2(145.07,94.27) 145.05,94.29 145.05,95.55 142.94,97.67 142.94,98.03 140.12,100.85 136.14,100.85 135.88,100.59 135.88,98.05 v2(135.41,97.58)
  BOTTOM w0.127: 135.45,98.26 R1904.2 134.63,97.82 134.3,97.49 133.99,97.49 131.89,95.38 131.89,94.37 CPU1.C8 ; 135.45,98.26 135.45,97.62 v2(135.41,97.58) ; 135.45,98.26 EC1903.1 ; PU8201.13 206.89,98.33 206.51,97.95 205.82,97.95 v2(205.44,97.57) 204.78,96.91 PR8203.2 ; v2(193.42,89.22) 193.42,88.1 v2(191.6,86.27) 191.57,86.24 191.57,85.39 192.13,84.83 192.13,82.98 193.21,81.9 193.21,79.72 192.56,79.07 192.56,74.03 v2(193.04,73.54)
DGPU_PWROK_KBC: length 19.3
  TOP w0.127: KBC24.47 182.08,84.19 181.6,84.66 181.6,85.42 183.17,86.99 183.17,88.09 183.82,88.75 186.52,88.75 186.68,88.91 187.24,88.91 187.54,88.61 187.54,88.19 v1(187.54,87.71) 187.54,87.43 188.74,86.23 190.89,86.23 191.12,86 R2427.1
DGPU_RXN_C_CPU_TXN0: length 78.1
  TOP w0.127: 170.02,122.07 v1(170.15,122.07) ; 170.02,122.07 170.02,124.23 172.62,126.83 172.62,130.03 172.12,130.53 172.12,131.44 171.45,132.11 171.45,134.05 172.8,135.4 172.8,135.78 v2(172.97,135.95) ; 170.02,122.07 170.02,120.69 159.51,110.17 158.43,110.17 154.9,106.64 153.21,106.64 152.6,106.04 v2(152.6,105.95)
  BOTTOM w0.127: GPU1.AG7 181.89,136.71 181.47,136.71 180.79,136.02 175.83,136.02 175.05,135.24 172.95,135.24 172.82,135.38 172.82,135.8 v2(172.97,135.95) ; C1606.1 131.07,103.59 131.07,105.28 133.43,107.64 139.25,107.64 140.19,108.58 141.66,108.58 142.41,107.83 148.34,107.83 150.06,106.11 152.44,106.11 v2(152.6,105.95)
DGPU_RXN_C_CPU_TXN1: length 76.3
  TOP w0.127: 171.42,121.54 171.42,124.48 173.56,126.62 173.56,130.69 173.25,131.01 173.25,131.97 172.36,132.86 172.36,133.87 173.82,135.32 173.82,136.33 174.32,136.84 178.08,136.84 178.31,137.07 178.84,137.07 v2(179.33,136.59) ; 171.42,121.54 v1(171.56,121.54) ; 171.42,121.54 171.42,120.98 159.83,109.4 158.75,109.4 154.59,105.24 152.1,105.24 150.99,106.35 148.84,106.35 148.6,106.11 v2(148.61,106.09)
  BOTTOM w0.127: v2(148.61,106.09) 148.4,106.31 146.73,106.31 146.2,106.84 134.95,106.84 133.02,104.91 133.02,104.06 C1608.1 ; GPU1.AE7 183.27,137.25 182.73,137.25 182.51,137.47 181.54,137.47 181.35,137.28 179.76,137.28 179.33,136.85 v2(179.33,136.59)
DGPU_RXN_C_CPU_TXN2: length 78
  TOP w0.127: v2(177.8,137.67) 177.74,137.67 177.04,138.37 174.23,138.37 173.2,137.34 172.19,137.34 169.86,135.01 169.86,128.68 168.29,127.11 168.29,125.41 ; 168.29,125.41 v1(168.15,125.41) ; 168.29,125.41 168.29,120.39 159.09,111.19 157.97,111.19 154.47,107.69 152.76,107.69 v2(152.47,107.99)
  BOTTOM w0.127: C1610.1 129.57,105.14 129.81,105.38 129.81,105.75 132.91,108.84 138.96,108.84 139.72,109.6 142.42,109.6 143.18,108.84 148.81,108.84 149.77,107.89 151.45,107.89 151.61,107.73 152.21,107.73 v2(152.47,107.99) ; GPU1.AF9 182.69,138.55 182.34,138.19 181.58,138.19 181.29,138.48 179.36,138.48 178.33,137.45 178.02,137.45 v2(177.8,137.67)
DGPU_RXN_C_CPU_TXN3: length 80.9
  TOP w0.127: v2(151.22,109.22) 151.31,109.13 152.61,109.13 153.27,108.47 154.13,108.47 157.63,111.96 158.77,111.96 165.97,119.17 165.97,124.91 ; v2(173.16,138.75) 172.94,138.53 172.2,138.53 168.99,135.31 168.99,129.46 165.97,126.44 165.97,124.91 ; 165.97,124.91 v1(165.79,124.91)
  BOTTOM w0.127: C1612.1 125.87,104.86 125.87,105.17 127.2,106.5 129.47,106.5 132.59,109.62 138.5,109.62 139.28,110.39 142.93,110.39 143.7,109.62 149.19,109.62 149.8,109 151,109 v2(151.22,109.22) ; v2(173.16,138.75) 173.35,138.57 175.82,138.57 176.54,139.29 181.99,139.29 GPU1.AG10
DGPU_RXP_C_CPU_TXP0: length 78.9
  TOP w0.127: v2(152.42,106.56) 152.48,106.5 152.73,106.5 153.11,106.88 154.8,106.88 158.33,110.41 159.41,110.41 169.78,120.79 169.78,124 ; 169.78,124 169.78,124.33 172.38,126.93 172.38,129.93 171.88,130.43 171.88,131.34 171.21,132.01 171.21,134.15 172.55,135.5 172.55,135.79 172.39,135.95 v2(172.17,135.95) ; 169.78,124 v1(169.63,124)
  BOTTOM w0.127: v2(172.17,135.95) 172.37,135.95 172.58,135.74 172.58,135.28 172.85,135 175.15,135 175.93,135.78 180.89,135.78 181.57,136.47 181.86,136.47 182.05,136.28 GPU1.AG6 ; v2(152.42,106.56) 152.21,106.35 150.16,106.35 148.44,108.07 142.51,108.07 141.76,108.82 140.09,108.82 139.15,107.89 133.33,107.89 130.83,105.38 130.83,103.38 C1605.1
DGPU_RXP_C_CPU_TXP1: length 76.9
  TOP w0.127: 171.17,123.64 v1(171.04,123.64) ; 171.17,123.64 171.17,121.08 159.73,109.64 158.65,109.64 154.49,105.48 152.2,105.48 151.09,106.59 148.6,106.59 148.48,106.71 v2(148.48,106.88) ; 171.17,123.64 171.17,124.58 173.32,126.72 173.32,130.59 173.01,130.9 173.01,131.87 172.12,132.76 172.12,133.97 173.58,135.42 173.58,136.43 174.22,137.08 177.98,137.08 178.21,137.32 178.94,137.32 179.22,137.04 179.88,137.04 179.98,136.93 v2(179.98,136.58)
  BOTTOM w0.127: C1607.1 132.45,103.86 132.78,104.19 132.78,105.01 134.85,107.08 146.3,107.08 146.83,106.55 148.37,106.55 148.48,106.66 v2(148.48,106.88) ; v2(179.98,136.58) 179.9,136.58 179.76,136.72 179.76,136.94 179.86,137.04 181.45,137.04 181.64,137.23 182.41,137.23 182.77,136.87 GPU1.AF7
DGPU_RXP_C_CPU_TXP2: length 78.8
  TOP w0.127: v2(152.61,107.2) 152.86,107.45 154.57,107.45 158.07,110.95 159.19,110.95 168.53,120.29 168.53,121.04 ; 168.53,121.04 168.53,127.01 170.11,128.58 170.11,134.91 172.29,137.1 173.3,137.1 174.33,138.12 176.94,138.12 177.18,137.89 177.18,137.7 v2(177.12,137.65) ; 168.53,121.04 v1(168.72,121.04)
  BOTTOM w0.127: C1609.1 130.05,105.36 130.05,105.65 133.01,108.6 139.06,108.6 139.82,109.36 142.32,109.36 143.08,108.6 148.71,108.6 149.67,107.65 151.35,107.65 151.51,107.49 152.32,107.49 v2(152.61,107.2) ; GPU1.AE9 183.38,138.55 183,138.18 182.66,138.18 182.44,137.95 181.48,137.95 181.19,138.24 179.46,138.24 178.43,137.21 178.17,137.21 178.17,137.21 177.36,137.21 177.12,137.44 v2(177.12,137.65)
DGPU_RXP_C_CPU_TXP3: length 81.5
  TOP w0.127: v2(151.22,108.41) 151.22,108.51 151.59,108.88 152.51,108.88 153.17,108.23 154.23,108.23 157.73,111.72 158.87,111.72 166.21,119.07 166.21,123 ; 166.21,123 166.21,126.34 169.23,129.36 169.23,135.21 172.3,138.28 173.15,138.28 173.22,138.21 v2(173.22,138.04) ; 166.21,123 v1(166.37,123)
  BOTTOM w0.127: GPU1.AG9 182.1,138.6 182.1,138.81 181.86,139.05 176.64,139.05 175.92,138.33 173.35,138.33 173.22,138.2 v2(173.22,138.04) ; v2(151.22,108.41) 151.22,108.54 151,108.76 149.7,108.76 149.09,109.38 143.6,109.38 142.83,110.15 139.38,110.15 138.6,109.38 132.69,109.38 129.57,106.26 127.3,106.26 126.11,105.07 126.11,104.87 C1611.1
DGPU_TXN_CPU_RXN0: length 10.5
  TOP w0.127: v1(181.22,141.61) 181.22,141.45 ; 181.22,141.45 182.56,141.45 184.16,139.86 185.74,139.86 186.55,139.05 186.55,138.17 v2(186.51,138.13) ; 181.22,141.45 179.05,141.45 C7302.2
  BOTTOM w0.127: v2(186.51,138.13) GPU1.AB9
DGPU_TXN_CPU_RXN1: length 10.5
  TOP w0.127: v2(184.86,138.93) 184.86,139.04 184.78,139.12 183.7,139.12 182.81,140.01 181.45,140.01 ; 181.45,140.01 177.35,140.01 176.97,140.39 176.37,140.39 176.23,140.25 C7304.2 ; 181.45,140.01 v1(181.45,139.83)
  BOTTOM w0.127: GPU1.AC10 185.25,138.99 185.19,138.93 v2(184.86,138.93)
DGPU_TXN_CPU_RXN2: length 12.2
  TOP w0.127: 177.46,142.49 181.46,142.49 181.99,141.96 182.93,141.96 183.86,141.03 184.42,141.03 v2(184.84,140.61) ; 177.46,142.49 177.02,142.49 176.56,142.94 174.75,142.94 C7306.2 ; 177.46,142.49 v1(177.46,142.64)
  BOTTOM w0.127: GPU1.AC11 184.84,140.6 v2(184.84,140.61)
DGPU_TXN_CPU_RXN3: length 12
  TOP w0.127: 184.45,142.48 182.18,142.48 181.4,143.26 177.84,143.26 177.54,143.57 177.54,144.07 177.12,144.49 176.21,144.49 C7308.2 ; 184.45,142.48 184.85,142.48 185.54,141.8 185.54,141.59 v2(185.7,141.43) ; 184.45,142.48 v1(184.45,142.68)
  BOTTOM w0.127: GPU1.AB12 185.69,141.43 v2(185.7,141.43)
DGPU_TXP_CPU_RXP0: length 10.9
  TOP w0.127: 182.76,140.91 v1(182.65,140.8) ; 182.76,140.91 182.46,141.21 178.94,141.21 178.83,141.09 C7301.2 ; 182.76,140.91 184.06,139.62 185.64,139.62 186.31,138.95 186.31,138.52 185.85,138.07 185.73,138.07 v2(185.67,138.13)
  BOTTOM w0.127: GPU1.AC9 185.47,138.55 185.67,138.35 v2(185.67,138.13)
DGPU_TXP_CPU_RXP1: length 11
  TOP w0.127: v2(185.67,138.93) 185.46,138.93 185.03,139.36 183.8,139.36 182.91,140.25 180.03,140.25 ; 180.03,140.25 v1(180.03,140.44) ; 180.03,140.25 177.45,140.25 177.07,140.63 176.48,140.63 C7303.2
  BOTTOM w0.127: v2(185.67,138.93) GPU1.AB10
DGPU_TXP_CPU_RXP2: length 11.4
  TOP w0.127: 179.73,142.25 176.92,142.25 176.46,142.7 174.79,142.7 C7305.2 ; 179.73,142.25 181.36,142.25 181.89,141.72 182.83,141.72 183.76,140.79 183.87,140.79 v2(184.05,140.61) ; 179.73,142.25 v1(179.73,142.07)
  BOTTOM w0.127: v2(184.05,140.61) 184.45,140.21 GPU1.AD11
DGPU_TXP_CPU_RXP3: length 13
  TOP w0.127: 183.38,142.24 182.08,142.24 181.3,143.02 177.74,143.02 177.3,143.47 177.3,143.97 177.02,144.25 176.82,144.25 176.7,144.13 176.7,143.88 176.55,143.73 C7307.2 ; 183.38,142.24 184.75,142.24 185.27,141.72 185.27,141.17 185.2,141.1 184.98,141.1 184.85,141.23 v2(184.85,141.43) ; 183.38,142.24 v1(183.38,142.07)
  BOTTOM w0.127: GPU1.AC12 184.97,141.03 184.85,141.15 v2(184.85,141.43)
DIS_1D35V_VGA_S0: length 3.6
  TOP w0.508: v1(158.01,35.32) 159.02,35.32 PR8313.2 159.03,37.24 PQ8302.D
DMIC_CLK: length 247.8
  TOP w0.14: v2(34.04,14.02) 34.82,14.02 35.12,14.32 C2723.2 R2716.1 ; RN5504.4 81.42,162.68 82.11,161.99 EC5501.1 82.11,161.43 81.78,161.09 v2(81.21,161.09)
  L3 w0.127: v2(83.09,143.08) 83.09,143.79 82.08,144.79 82.08,149.98 80.26,151.8 80.26,153.24 78.77,154.73 75.83,154.73 75.22,155.35 75.22,158.41 75.85,159.04 79.16,159.04 v2(81.21,161.09)
  L4 w0.127: v2(83.09,143.08) 85.38,140.8 85.38,133.85 87.03,132.2 87.03,128.47 90.98,124.52 90.98,119.57 86.13,114.72 86.13,109.39 86.13,108.5 84.87,107.25 84.87,104.88 82.13,102.15 82.13,95.5 70.83,84.2 67.06,84.2 62.02,79.16 40.59,79.16 39.54,78.1 12.67,78.1 11.22,76.66 11.22,73.57 11.73,73.06 11.73,54.39 13.61,52.51 13.61,37.53 13.1,37.03 13.1,33.15 14.76,31.5 14.76,29.59 17.73,26.62 22.14,26.62 22.54,27.02 31.06,27.02 32.55,25.53 32.55,19.83 33.13,19.25 33.13,16.1 33.48,15.75 33.48,14.58 v2(34.04,14.02)
  BOTTOM w0.14: v2(83.09,143.08) v1(83.84,143.08)
DMIC_CLK_EDP: length 9.9
  TOP w0.14: LCD1.27 79.32,164.32 80.13,165.14 81.17,165.14 81.42,164.89 RN5504.1 84.56,164.4 v2(84.58,164.42)
  BOTTOM w0.14: v1(86.29,165.4) RN5505.1 84.96,164.8 v2(84.58,164.42)
DMIC_CLK_R: length 3.1
  TOP w0.14: HDA27.3 32.85,14.47 33.07,14.69 R2716.2
DMIC_DATA: length 245.4
  TOP w0.14: v2(33.04,14.03) 33.51,13.57 R2714.1 ; v2(80.39,161.11) 80.59,161.11 81.29,161.81 EC5502.1 81.29,162.1 80.77,162.62 RN5504.3
  L3 w0.127: v2(80.39,161.11) 78.85,159.58 75.62,159.58 74.68,158.63 74.68,155.13 75.61,154.19 78.55,154.19 79.62,153.13 79.62,151.36 81.34,149.64 81.34,144.59 v2(82.35,143.58)
  L4 w0.127: v2(82.35,143.58) 82.35,143.11 84.87,140.59 84.87,133.82 86.65,132.04 86.65,128.13 90.47,124.31 90.47,119.78 85.62,114.93 85.62,108.71 84.36,107.46 84.36,105.09 81.63,102.36 81.63,95.71 70.62,84.71 66.73,84.71 61.69,79.66 40.38,79.66 39.33,78.61 12.46,78.61 10.71,76.87 10.71,73.36 11.22,72.85 11.22,54.18 12.85,52.55 13.1,52.3 13.1,37.78 12.55,37.24 12.55,32.96 14.25,31.27 14.25,29.36 17.5,26.11 22.37,26.11 22.66,26.4 30.96,26.4 32.04,25.32 32.04,19.55 32.62,18.97 32.62,15.87 32.94,15.55 32.94,14.14 v2(33.04,14.03)
  BOTTOM w0.14: v2(82.35,143.58) v1(82.35,144.28)
DMIC_DATA_EDP: length 9.7
  TOP w0.14: v2(84.57,163.49) 84.3,163.75 v1(82.54,163.75) 80.86,163.75 80.77,163.84 RN5504.2 80.33,164.4 79.67,163.74 78.61,163.74 78.53,163.82 LCD1.28
  BOTTOM w0.14: RN5505.2 84.31,164.97 84.09,164.75 84.09,163.97 v2(84.57,163.49)
DMIC_DATA_R: length 3.5
  TOP w0.14: EC2701.1 32.65,13.07 32.62,13.1 R2714.2 32.43,13.42 v1(31.82,14.03) 31.66,14.19 31.06,14.19 30.95,14.07 HDA27.2
DMIC_PCH_CLK: length 161.3
  TOP w0.14: R1910.1 143.2,100.37 v1(146.17,103.34) 148.03,105.2 148.03,106.13 147.42,106.73 147.42,108.97 152.27,113.82 156.36,113.82 157.25,114.71 157.73,114.71 161.22,118.2 v2(161.22,120.19)
  L3 w0.127: v2(157.68,163.77) 157.67,163.77 155.36,163.77 154.23,164.9 154.23,165.85 153.44,166.65 152.47,166.65 147.81,171.31 137.67,171.31 135.01,168.65 131.09,168.65 130.86,168.88 128.83,168.88 128.83,168.87 126.75,168.87 126.74,168.88 126.28,168.88 125.19,169.97 123,169.97 122.44,170.53 114.66,170.53 113.21,171.98 109.57,171.98 108.38,173.17 106.36,173.17 106.19,173 101.78,173 101.61,173.17 91.39,173.17 88.3,170.08 87.73,170.08 85.67,168.01 v2(85.67,167.21)
  L4 w0.127: v2(157.68,163.77) 157.76,163.77 159.88,161.65 159.88,159.74 160.51,159.11 160.51,155.23 159.22,153.94 159.22,149.36 157.42,147.56 157.42,147.11 158.72,145.82 158.72,140.51 158.72,137.43 159.6,136.55 159.6,131.4 161.29,129.71 161.29,120.26 v2(161.22,120.19)
  BOTTOM w0.14: v2(85.67,167.21) 85.51,167.37 85.23,167.37 84.96,167.09 RN5505.4
DMIC_PCH_CLK_R: length 15.3
  TOP w0.14: R1910.2 140.13,98.2 139.53,98.2 138.47,97.14 138.47,95.44 138.19,95.16 138.19,94.17 137.49,93.48 135.99,93.48 134.91,92.39 134.6,92.39 v1(133.76,91.55) 133.55,91.33 v2(133.55,90.77)
  BOTTOM w0.14: CPU1.H5 133.19,90.41 v2(133.55,90.77)
DMIC_PCH_DATA: length 159.6
  TOP w0.14: v2(160.48,120.21) 160.53,120.16 160.53,118.24 157.57,115.27 156.48,115.27 155.45,114.23 152.1,114.23 146.87,109 146.87,106.5 147.47,105.89 147.47,105.52 147.41,105.46 147.41,105.43 v1(144.65,102.67) 143.22,101.24 R1913.1
  L3 w0.127: v2(157.68,163.13) 155.28,163.13 153.72,164.69 153.72,165.64 153.23,166.14 152.26,166.14 147.6,170.81 137.88,170.81 135.2,168.12 130.9,168.12 130.65,168.37 129.04,168.37 129.04,168.37 126.03,168.37 124.93,169.46 122.79,169.46 122.23,170.02 120.06,170.02 119.55,169.51 114.96,169.51 112.88,171.6 109.41,171.6 108.75,172.25 106.16,172.25 105.8,172.62 101.62,172.62 101.45,172.79 91.74,172.79 88.61,169.66 87.85,169.66 86.16,167.97 v2(86.16,167.8)
  L4 w0.127: v2(157.68,163.13) 159.37,161.44 159.37,159.53 160,158.9 160,155.44 158.71,154.15 158.71,149.96 156.92,148.16 156.92,146.9 158.21,145.61 158.21,140.72 158.21,137.22 159.09,136.34 159.09,131.19 160.49,129.8 160.49,123.1 160.48,123.1 v2(160.48,120.21)
  BOTTOM w0.14: v2(86.16,167.8) 84.86,167.8 84.31,167.24 RN5505.3
DMIC_PCH_DATA_R: length 15.8
  TOP w0.14: R1913.2 v1(140.18,99.11) 139.83,98.76 139.29,98.76 137.91,97.37 137.91,95.45 137.31,94.85 136.93,94.85 134.9,92.81 v2(131.71,92.81)
  BOTTOM w0.14: CPU1.D7 132.03,93.13 v2(131.71,92.81)
DS3_PWRCTL: length 4.6
  BOTTOM w0.127: R4102.2 158.46,82.22 158.25,82.22 157.3,81.27 v1(156.99,81.27) U4101.4
E51_RX1: length 2.8
  TOP w0.102: TP6102.1 165.56,51.55 v2(166.61,51.55)
  BOTTOM w0.102: v2(166.61,51.55) 166.83,51.77 WLAN1.46
E51_RX2: length 6.4
  TOP w0.102: TP6103.1 167.47,48.77 v2(166.61,47.91)
  BOTTOM w0.102: v2(166.61,47.91) 167.47,48.77 WLAN1.58
E51_TX1: length 4.2
  TOP w0.102: v2(169.98,52.27) 169.98,51.78 170.17,51.59 v1(170.37,51.59) 170.65,51.59 170.81,51.75 R6115.2
  BOTTOM w0.102: WLAN1.44 v2(169.98,52.27)
E51_TXD_R: length 3.7
  BOTTOM w0.102: DB3.5 157.84,15.59 158.06,15.81 v1(158.06,16.8) 158.06,17.42 157.71,17.78 R2466.1
EC_AGND: length 40.1
  TOP w0.203: 181.37,65.33 181.28,65.42 KBC24.112
  TOP w0.508: R2445.2 181.64,58.81 181.53,58.7 181.53,58.49 v2(181.31,58.27) 180.7,58.87 C2415.2 ; v2(174.34,53.16) 173.98,53.16 v1(173.6,53.53) R2444.2 C2408.1 ; C2416.2 181.58,64.11 C2422.2 182.57,63.75 v2(182.93,63.4) ; C2416.2 181.54,65.15 181.37,65.33 ; C2416.2 181.43,63.96 C2421.2 ; C2407.1 185.01,53.75 R2441.2 v2(185.78,53.76) ; v2(181,54.97) 181,55.36 180.82,55.54 180.82,55.93 C2435.2
  L3 w0.508: v2(185.78,53.76) 185.06,54.48 181.91,54.48 181.42,54.97 v2(181,54.97) 179.44,53.41 175.47,53.41 175.22,53.16 v2(174.34,53.16)
  BOTTOM w0.508: C2441.2 183.69,66.25 C2427.2 182.87,66.02 182.29,65.44 182.29,64.08 182.93,63.45 v2(182.93,63.4) 182.93,62.77 182.76,62.6 182.76,60.33 181.31,58.88 v2(181.31,58.27) 181.31,58.25 181,57.94 181,57.94 180.92,57.86 180.92,57.33 181,57.25 v2(181,54.97)
EC_MUTE#: length 233.1
  TOP w0.102: KBC24.119 184.08,67.7 v2(184.44,68.07) ; v2(30.04,12.97) 30.04,12.89 31.21,11.73 31.35,11.73 31.62,11.46 31.79,11.46 32.38,10.87 R2724.2 32.67,10.86 R2708.1
  L3 w0.102: v2(182.46,19.87) 182.46,12.29 173.97,3.8 144.75,3.8 143.29,2.34 91.55,2.34 89.39,4.5 71.15,4.5 67.97,7.68 54.38,7.68 53.42,8.64 48.1,8.64 47.68,9.06 45.67,9.06 39.84,14.89 36.97,14.89 36.58,14.49 31.47,14.49 30.04,13.06 v2(30.04,12.97)
  L4 w0.102: v2(181.77,50.92) 182.09,50.6 182.09,43.31 179.8,41.02 179.8,35.84 180.39,35.25 180.39,32.17 179.82,31.59 179.82,31.08 180.48,30.41 180.48,30.39 180.59,30.28 180.59,28.43 179.82,27.65 179.82,24.9 180.33,24.39 180.33,20.87 180.25,20.79 180.25,20.31 180.5,20.06 182.27,20.06 v2(182.46,19.87)
  BOTTOM w0.102: v2(182.46,19.87) v1(182.46,19.25) ; v2(181.77,50.92) 181.84,50.99 183.47,50.99 184.63,52.14 184.63,53.93 185.11,54.41 185.11,59.9 183.99,61.02 183.99,61.96 184.62,62.59 184.62,63.97 185.05,64.4 185.05,67.46 v2(184.44,68.07)
EC_SPI_CLK: length 3.5
  TOP w0.14: KBC24.32 189.22,80.8 190.04,81.61 190.44,81.61 190.45,81.62 R2485.2 v1(191.17,82.66)
EC_SPI_CS0#: length 2.1
  TOP w0.14: R2490.2 190.87,79.06 190.66,78.84 190.33,78.84 190.09,78.61 KBC24.27
EC_SPI_MISO: length 2.6
  TOP w0.14: R2487.2 190.68,80.25 190.68,80.07 190.02,79.41 KBC24.29
EC_SPI_MOSI: length 2.3
  TOP w0.14: R2486.2 191.13,79.91 190.49,79.27 190.31,79.27 190.05,79.01 KBC24.28
