# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3D3V_S5_WLAN: length 3.3
  BOTTOM w0.305: WLAN1.2 167.12,62.77 166.92,62.97 ; 166.36,61.96 166.68,62.27 WLAN1.4
  vias: v3(167.91,64.55) v3(167.91,63.68) v3(167.91,40.97) v3(168.83,40.97)
3D3V_TP_S5_R: length 9.1
  TOP w0.381: Q6504.S 45.4,76.39 44.92,75.91 C6503.2 44.24,75.83 R6520.1 ; v1(44.51,73.75) 44.24,74.03 R6520.1 ; R6520.1 43.5,74.98 42.6,75.88 40.43,75.88 R6521.1
3D3V_TPM: length 27.4
  TOP w0.508: v2(159.86,21.37) 160.7,21.37 161.84,20.22 163.01,20.22 v2(164.14,19.09)
  L4 w0.508: v2(168.03,19.02) 167.94,19.11 v2(165.86,19.11) 165.86,18.84 165.49,18.47 164.76,18.47 v2(164.14,19.09) ; v2(158.74,28.66) 158.36,28.27 v2(157.12,28.27) 157.12,27.92 157.65,27.39 157.65,22.03 158.31,21.37 v2(159.86,21.37)
  BOTTOM w0.381: R9112.2 164.02,19.72 164.02,19.21 v2(164.14,19.09) 164.02,18.97 C9103.1 ; Q9101.S 156.31,27.47 v2(157.12,28.27)
  BOTTOM w0.508: R9108.1 158.74,28.53 v2(158.74,28.66) 158.85,28.76 R9117.1 ; v2(165.86,19.11) 165.86,19.88 R9103.2
  vias: v1(169.54,20.98)
3D3V_TPM_1:
  vias: v1(160.98,30.03)
3D3V_VGA_CT_1: length 4.5
  TOP w0.254: v2(171.32,130.13) 171.78,129.68 v1(171.78,128.95) 171.78,127.68 C8302.1
  BOTTOM w0.203: U8301.12 170.91,130.55 v2(171.32,130.13)
3D3V_VGA_S0: length 74.8
  TOP w0.508: v2(164.61,145.52) 164.29,145.84 161.7,145.84 158.95,148.59 v1(152.47,148.59) 146.71,148.59 v2(146.3,149)
  L4 w0.508: v3(212.52,140.06) 212.8,140.35 215.45,140.35 218.77,137.03 218.77,117.22 220.78,115.2 220.78,100.7 218.53,98.45 217.35,98.45 215.47,96.57 v2(215.24,96.57)
  BOTTOM w0.356: GPU1.G9 198.38,138.55 v2(198.04,138.21) 198.53,137.71 GPU1.G8
  BOTTOM w0.508: PR8256.1 215.06,96.68 215.17,96.57 v2(215.24,96.57) ; PR8308.1 v2(146.3,149)
  vias: v1(164.3,142.58) v1(202.13,138.79) v1(213.3,151.57) v3(165.96,149.05) v3(166.61,149.66) v3(215.46,177.34) v3(216.48,177.34)
3D3V_VGA_S0_DISCHG: length 2.7
  BOTTOM w0.102: v1(166.27,141.25) 166.96,140.57 PR8318.2 167.07,140.17 PQ8307.3
27MHZ_IN: length 9.8
  BOTTOM w0.102: GPU1.C11 202.05,140.19 202.39,139.85 202.84,139.85 202.9,139.91 203.7,139.91 203.91,139.7 204.44,139.7 205.02,139.12 207.55,139.12 R7603.1 208.31,138.95 208.31,138.9 C7607.2 209.12,138.52 209.61,138.03 X7601.1
27MHZ_OUT: length 6.6
  BOTTOM w0.102: R7604.2 R7603.2 207.84,138.54 207.46,138.92 204.94,138.92 204.35,139.5 203.82,139.5 203.62,139.7 203,139.7 GPU1.B10
27MHZ_OUT_R: length 5.8
  BOTTOM w0.14: R7604.1 207.84,136.87 C7608.2 209.14,137.71 209.55,137.3 211.19,137.3 211.97,136.52 X7601.3
81208_AGND: length 21.9
  TOP w0.508: v2(114.43,151.42) 114.43,150.69 PR4602.1 114.48,149.87 PR4611.2
  BOTTOM w0.508: PR4635.2 120.26,142.77 PR4636.2 121.22,142.75 121.81,142.75 122.38,142.18 122.38,141.04 121.76,140.42 118.16,140.42 117.48,141.09 PC4628.2 ; v2(114.43,151.42) 114.43,149.08 114.83,148.68 117.42,148.68 118.15,147.95 118.15,146.85 118.51,146.49 118.51,145.7 118.08,145.26 116.79,145.26
  vias: v1(113.1,143.04) v1(114.9,142.78) v2(113.02,143.79) v2(113.91,143.79) v2(113.91,142.9) v2(113.9,142.12) v2(114.8,143.79)
+0D675V_DDR_P:
  vias: v1(41.19,22.28)
+DC_IN: length 25.3
  TOP w0.508: v2(104.49,170.46) 104.5,170.45 PQ4305.E
  L4 w0.508: v3(92.93,157.71) 93.2,157.98 93.2,166.91 98.15,171.85 102.59,171.85 103.98,170.46 v2(104.49,170.46)
  vias: v1(90.47,152.53) v1(93.54,153.37) v3(88.44,155.68) v3(88.46,156.62) v3(90.65,153.78) v3(91.05,156.75) v3(91.23,152.91) v3(91.66,153.8) v3(91.99,156.72) v3(92.88,156.72) v3(93.19,155.55) v3(93.16,154.69) v3(94.08,155.55) v3(94.05,154.69)
+PWR_SRC_1D35V:
  vias: v1(54.73,25.43) v3(54.35,24.54) v3(55.24,24.54) v3(56.13,24.54) v3(57.02,24.54)
+RTC_VCC: length 17.1
  TOP w0.508: v2(72.4,6.15) 73.12,5.43 77.48,5.43 AFTP2502.1
  BOTTOM w0.508: RTC1.1 68.49,7.67 68.9,8.08 R2502.2 70.46,8.08 v2(72.4,6.15)
+SDC_IN: length 6.3
  BOTTOM w0.508: PR4410.1 108.36,154.25 107.84,153.73 v1(105.89,153.73) 104.13,153.73 v2(103.45,154.41)
+UZ12_TPM: length 4.8
  BOTTOM w0.305: C9104.1 168.19,30.24 168.19,29.45 168.19,29.44 v1(168.19,29.34) 168.19,29.34 168.19,28.98 167.86,28.65 U9101.8
  BOTTOM w0.381: C9104.1 167.35,30.26 R9114.1 R9110.1
+V_VREF_PATH1: length 2
  TOP w0.356: v1(58.35,48.79) 58.08,48.52 C4202.2
  TOP w0.508: R4211.1 57.29,47.75 C4202.2
+V_VREF_PATH2: length 1.9
  TOP w0.356: v1(58.26,45.08) 57.57,45.08 C4203.2
  TOP w0.508: C4203.2 56.42,44.86 R4215.1
+V_VREF_PATH3: length 2.3
  TOP w0.356: v1(58.24,41.54) 57.57,41.54 57.32,41.28 C4201.2
  TOP w0.508: R4207.1 56.43,40.9 C4201.2
AC_DIS: length 233.9
  TOP w0.203: v2(175.53,79.15) 175.52,79.15 175.38,79.01 KBC24.69
  TOP w0.254: v2(177.33,119.22) 174.88,119.22 174.18,118.53 v2(173.23,118.53) ; PQ4403.G 142.11,154.62 143.37,155.88 143.37,156.92 149.71,163.25 149.71,174.47 v2(150.18,174.93) ; v2(115.18,176.56) 115.18,177.29 115.4,177.51 PR4310.1
  L3 w0.254: v2(85.68,176.16) 86.41,175.44 88.17,175.44 90.02,177.29 100.75,177.29 101.08,177.62 113.99,177.62 115.05,176.56 v2(115.18,176.56) 115.31,176.43 115.31,176.35 115.65,176.01 118.58,176.01 118.93,176.36 119.82,176.36 120.25,175.92 123.78,175.92 124.8,176.94 128.3,176.94 128.55,176.69 134.97,176.69 136.18,175.48 149.63,175.48 v2(150.18,174.93) 150.98,174.13 154.7,174.13 159.62,169.2 160.12,169.2 160.12,169.2 160.47,169.2 161.78,167.9 162.41,167.9 v2(163.64,166.67)
  L4 w0.254: v2(177.33,119.22) 177.33,119.16 179.18,117.31 179.18,116.55 180.14,115.59 180.14,111.67 180.46,111.35 180.46,107.41 180.09,107.03 180.09,104.17 180.6,103.66 180.6,102.69 179.69,101.78 179.69,96.17 178.11,94.59 178.11,89.94 178.05,89.88 178.05,85.54 176.7,84.19 176.7,81.97 176.05,81.31 176.05,79.89 176.04,79.89 176.04,79.79 176.02,79.76 176.02,79.63 v2(175.53,79.15) ; v2(173.23,118.53) 172.92,118.84 172.92,126.06 168.3,130.69 168.3,134.44 166.87,135.87 166.87,137.19 164.79,139.27 164.79,144.4 165.21,144.82 165.21,149.29 166.85,150.94 166.85,157.04 164.43,159.47 164.43,163.01 163.83,163.61 163.83,166.48 v2(163.64,166.67)
  BOTTOM w0.254: v2(85.68,176.16) 86.74,175.1 v1(86.74,167.25) 86.74,165.08 86.52,164.87 86.52,159.15 86.77,158.9 PQ4306.5
AC_DIS_M: length 9
  TOP w0.508: v2(135.29,155.62) 135.51,155.84 PR4422.2 137.75,155.84 v1(138.19,156.27) 138.62,156.71 142.33,156.71 PQ4403.D
  BOTTOM w0.406: PU4403.4 135.85,156.18 v2(135.29,155.62)
AC_IN#_G: length 3.2
  BOTTOM w0.102: PQ4306.2 90.07,158.9 90.31,159.14 PR4312.2 ; PR4312.2 PR4313.1 ; PR4312.2 v1(90.66,158.21)
AC_IN_KBC#: length 216.8
  TOP w0.102: R2493.2 R2494.2 176.31,56.31 v2(176.31,57.16)
  L3 w0.102: v2(164.96,55.61) 166.98,55.61 168.52,57.15 169.9,57.15 170.2,57.46 172.36,57.46 172.62,57.2 176.27,57.2 v2(176.31,57.16) ; v2(88.23,164.79) 88.64,165.2 88.64,166.64 93.58,171.58 101.04,171.58 101.22,171.76 108.73,171.76 109.26,171.23 112.51,171.23 113.1,170.64 113.1,169.78 113.91,168.96 119.7,168.96 120.24,169.5 120.9,169.5 121.44,168.96 124.09,168.96 125.38,167.67 125.67,167.67 125.82,167.82 130.5,167.82 130.7,167.62 135.4,167.62 135.69,167.91 138.09,170.31 146.77,170.31 155.15,161.93 v2(155.54,161.93)
  L4 w0.102: v2(164.96,55.61) 164.59,55.98 164.59,57.11 164.6,57.11 164.6,57.47 164.14,57.94 164.14,59.7 164.79,60.36 164.79,61.31 163.44,62.67 163.44,64.3 164.68,65.54 164.68,66.73 164.68,66.73 164.68,66.93 164.68,66.93 165.06,67.31 165.06,67.31 165.36,67.61 165.36,68.15 164.88,68.63 164.88,70.4 165.36,70.88 165.36,72.42 165.11,72.67 165.11,75.37 164.59,75.89 164.59,77.14 163.28,78.45 163.28,79.18 163.06,79.41 163.06,82.15 162.89,82.32 162.89,82.65 160.66,84.88 160.66,86.57 159.01,88.22 159.01,94.72 158.59,95.13 158.59,95.85 158.72,95.98 158.72,99.27 159.23,99.78 159.23,100.81 159.23,101.01 159.05,101.18 159.05,104.15 159.17,104.26 159.17,107.8 159.66,108.29 159.66,115.31 159.99,115.64 159.99,116 159.27,116.72 159.27,119.99 157.8,121.46 157.8,127.59 157.33,128.07 157.33,132.77 156.47,133.62 156.47,135.75 156.7,135.97 156.7,137.54 156.7,140.12 156.29,140.53 155.4,141.42 155.4,148.19 154.91,148.69 154.91,150.37 157.2,152.66 157.2,154.78 158.49,156.07 158.49,158.27 155.54,161.23 v2(155.54,161.93)
  BOTTOM w0.102: v2(88.23,164.79) 89.15,164.79 v1(89.31,164.63) 89.49,164.45 89.49,163.39 87.51,161.41 PQ4306.6
AC_IN_KBC#_R: length 4.9
  TOP w0.102: v1(179.39,55.53) 178.63,56.29 R2493.1 178.11,55.7 177.93,55.52 176.31,55.52 175.96,55.18 U2401.1
AC_PRESENT: length 146.8
  TOP w0.102: D1703.A 160.21,67.26 v2(160.22,67.26) ; D7601.K 206.84,132.99 207.04,132.78 207.04,129.86 206.14,128.96 205.2,128.96 204.88,128.63 201.21,128.63 198.82,126.24 197.38,126.24 196.37,125.23 194.57,125.23 193.46,124.12 193.46,123.6 192.16,122.3 192.15,122.29 189.52,122.29 188.74,121.51 188.36,121.13 187.69,121.13 186.53,119.96 186.53,119.16 185.18,117.82 183,117.82 179.56,114.38 178.87,114.38 177.84,113.35 177.84,112.65 175.61,110.42 174.38,110.42 v1(168.7,104.73) 167.84,103.87 v2(167.84,99.52)
  L3 w0.102: v2(127.84,71.78) 129.03,71.78 131.92,68.89 133.26,68.89 134.08,68.07 136.53,68.07 136.68,68.21 137.89,68.21 138.87,67.24 139.03,67.24 139.14,67.12 140.85,67.12 141.01,66.95 146.2,66.95 146.98,67.74 148.52,67.74 148.92,67.34 158.74,67.34 159.19,66.89 159.86,66.89 160.11,67.14 160.11,67.16 v2(160.22,67.26) 160.22,67.39 160.3,67.47 160.3,67.88 162.04,69.63 164.56,69.63 164.91,69.98 167.37,69.98 168.61,68.74 v2(168.61,68.56)
  L4 w0.102: v2(168.61,68.56) 168.61,69.91 168.61,71.47 169.19,72.05 169.19,73.6 168.93,73.86 168.93,74.35 168.64,74.64 168.64,75.71 169.11,76.19 169.11,77 168.49,77.62 168.49,78.13 168.49,78.59 168.72,78.82 168.72,82.1 168.87,82.26 168.87,83.9 168.78,83.99 168.78,85.02 167.95,85.85 167.95,86.78 167.5,87.22 167.5,87.25 167.5,87.25 167.5,89.12 167.95,89.58 167.95,90.48 167.82,90.62 167.82,92.78 167.96,92.92 167.96,93.28 167.82,93.42 167.82,94.95 168.05,95.18 168.05,99.31 v2(167.84,99.52)
  BOTTOM w0.089: v2(127.84,71.78) 127.89,71.82 127.89,72.41 127.99,72.69 127.99,72.86 127.97,72.96 127.79,73.13 127.57,73.13 127.11,73.59 CPU1.AY15
  BOTTOM w0.102: Q1702.3 161.67,67.92 161.1,67.35 160.31,67.35 v2(160.22,67.26) 160.1,67.15 R1709.2 159.24,64.91 EC1707.1
ACAV_IN: length 7.2
  TOP w0.127: KBC24.128 187.77,66.75 188.69,66.75 190.02,65.43 190.04,65.43 191.49,63.98 191.49,62.92 191.51,62.89 v1(191.51,62.77) 191.36,62.92 R2469.2
ACOK_IN: length 29.6
  TOP w0.254: v2(100.91,168.49) 100.91,168.17 101.52,167.56 102.38,167.56 102.89,167.05 103.68,167.05 103.94,166.79 PQ4402.2
  L4 w0.254: v2(107.64,154.49) 107.64,154.54 107.18,155 105.86,155 104.41,156.44 104.41,156.9 100.55,160.76 99.31,160.76 96.79,163.28 96.79,167.3 98.48,168.99 100.41,168.99 v2(100.91,168.49)
  BOTTOM w0.254: PR4416.1 107.48,154.72 107.64,154.56 v2(107.64,154.49) ; v2(100.91,168.49) v1(100.91,167.93)
AD+: length 74.8
  TOP w0.508: PD4402.A v2(114.55,166.02) ; v2(135.76,153.7) 136.24,154.19 PR4422.1 ; v2(119.76,166.02) 119.76,166.91 119.31,167.35 PR4431.1 ; PR4405.1 108.53,168.56 v2(109.1,167.99)
  L4 w0.508: v2(119.76,166.02) 119.68,166.1 119.02,166.1 118.33,166.78 115.31,166.78 v2(114.55,166.02) 113.16,166.02 111.19,167.99 v2(109.1,167.99) 108.9,167.79 108.9,167.05 108.13,166.28 105.18,166.28 104.46,165.56 100.85,165.56 98.88,163.6 98.88,162.21 99.69,161.4 100.86,161.4 105.06,157.19 v2(105.06,156.82) 106.05,155.83 110.65,155.83 112.24,154.24 117.44,154.24 118.59,153.1 135.16,153.1 v2(135.76,153.7)
  BOTTOM w0.508: PR4430.1 135.95,153.89 v2(135.76,153.7) ; PR4408.1 104.81,156.57 v2(105.06,156.82)
  vias: v1(103.73,156.8)
AD+_G_1: length 4.6
  TOP w0.102: PQ4402.6 103.29,167.58 103.45,167.42 103.81,167.42 103.94,167.55 PQ4402.5 103.94,168.92 PR4406.1 104.44,169.69 v1(103.77,170.35)
AD+_G_2: length 28.7
  TOP w0.254: PR4406.2 103.11,169.42 102.16,168.47 v2(101.63,168.47) ; PU4402.4 101.71,153.21 PR4403.2 101.71,154.73 102.28,155.3 102.84,155.3 103.07,155.53 v2(103.07,155.78)
  L4 w0.254: v2(103.07,155.78) 103.12,155.83 103.12,157.46 100.3,160.28 99.11,160.28 96.4,162.98 96.4,167.45 98.38,169.43 100.89,169.43 101.63,168.7 v2(101.63,168.47)
  BOTTOM w0.254: v2(103.07,155.78) 103.07,155.53 v1(102.79,155.25)
AD_IA: length 217.2
  TOP w0.102: v2(173.03,57.66) 173.63,58.25 v1(174.64,58.25) 177.66,58.25 R2421.1
  L3 w0.102: v2(165.33,160.79) 163.58,160.79 163.1,160.31 159.81,160.31 159.29,160.83 155.96,160.83 146.98,169.81 137.95,169.81 135.56,167.42 130.61,167.42 130.42,167.61 125.9,167.61 125.76,167.47 125.3,167.47 124.13,168.64 109.91,168.64 108.16,170.39 106.58,170.39 105.58,169.39 105.58,169.01 105.28,168.72 102.68,168.72 102.16,169.23 98.67,169.23 97.24,167.8 97.24,163.71 v2(97.32,163.63)
  L4 w0.102: v2(172.51,77.97) 172.13,78.34 172.13,78.87 172.71,79.45 172.71,83.61 173.58,84.48 173.58,87.75 174.06,88.22 174.06,96.87 176.44,99.25 176.44,103.13 176.85,103.54 176.85,106.57 176.06,107.37 176.06,107.91 176.3,108.16 176.3,112.08 174.29,114.09 174.29,115 173.49,115.8 173.49,116.82 174.37,117.7 174.37,123.58 174.18,123.76 174.18,125.7 168.93,130.95 168.93,134.93 167.5,136.35 167.5,137.45 165.42,139.54 165.42,143.99 165.84,144.42 165.84,147.59 167.49,149.24 167.49,157.36 165.33,159.52 v2(165.33,160.79)
  BOTTOM w0.102: v2(173.03,57.66) 173.03,58.61 172.1,59.54 172.1,65.4 171.7,65.81 171.7,72.06 172.87,73.23 172.87,75.39 172.12,76.14 172.12,76.65 172.59,77.12 172.59,77.89 v2(172.51,77.97) ; v2(97.32,163.63) 97.31,163.61 97.31,160.46 98.06,159.7 98.06,156.09 99.69,154.46 100.67,154.46 PC4423.1 102.06,154.56 102.89,154.56 103.61,155.28 PG4401.2
AD_OFF_L: length 20
  TOP w0.254: PQ4305.B 105,171.75 104.75,172 v1(104.75,172.27) 104.75,172.56 104.91,172.72 v2(106.55,172.72) ; v2(119.88,173.38) 120.89,173.38 PQ4304.C
  L4 w0.254: v2(119.88,173.38) 118.17,173.38 117.41,174.15 107.28,174.15 106.55,173.42 v2(106.55,172.72)
AD_OFF_R: length 45.7
  TOP w0.254: v2(110.56,169.79) 110.1,170.24 PR4308.1 109.37,170.57 108.83,171.1 PQ4305.C
  L3 w0.254: v2(110.56,169.79) 110.56,169.8 109.56,170.8 109.08,170.8 108.55,171.33 101.99,171.33 101.06,170.39 93.01,170.39 89.71,167.1 89.71,165.17 v2(85.3,160.76)
  BOTTOM w0.254: PR4319.1 110.54,169.81 v2(110.56,169.79) ; PC4301.2 87.82,153.03 PR4307.2 86.21,154.47 85.01,155.66 85.01,158.04 v1(85.75,158.78) 85.75,160.31 v2(85.3,160.76)
ALL_SYS_PWRGD: length 370.3
  TOP w0.127: R2481.2 182.33,87.11 180.65,85.43 v2(180.65,84.11) ; v2(183.28,51.73) 180.37,51.73 180.03,52.06 180.03,53.17 178.38,54.82 U2401.6 ; v2(163.32,40.42) 163.32,41.81 161.92,43.21 157.93,43.21 157.37,43.77 153.99,43.77 U1702.4 152.74,43.25 152.34,43.64 D1701.A ; v2(133.77,145.17) 133.77,145.65 131.67,147.75 v1(131.67,148.33) 131.67,148.7 129.77,150.61 126.5,150.61 126.04,151.07 R4011.2 122.52,151.29 D4002.1 121.8,151.26 121.48,150.94 121.48,149.42 121,148.94 R4005.2 R4002.1
  L3 w0.127: v2(144.89,37.82) 146.18,37.82 147.78,36.22 150.3,36.22 151.75,37.67 153.58,37.67 155.81,39.9 157,39.9 158.25,38.65 161.55,38.65 v2(163.32,40.42) 163.75,39.98 168.91,39.98 172.16,43.23 180.41,43.23 181.02,42.62 v2(183.03,42.62) ; v2(133.77,145.17) 132.38,146.57 123.64,146.57 121.86,144.79 120.25,144.79 118.46,146.59 116.66,146.59 116.59,146.66 111.72,146.66 110.96,147.43 110.09,147.43 109.14,146.47 108.27,146.47 106.2,144.41 105.73,144.41 104.32,144.41 102.56,142.64 100.62,142.64 99.14,141.16 95.36,141.16 94.6,140.41 94.6,135.21 98.32,131.5 98.32,124.64 98.32,124.64 98.32,124.16 96.41,122.25 96.41,118.19 90.44,112.22 90.44,106.69 91.6,105.52 v2(91.6,104.43) 91.15,104.43 90.14,103.42 90.14,102.63 90.44,102.33 90.44,100.1 88.69,98.35 82.77,98.35 65.54,81.11 64.88,81.11 63.65,79.88 v2(63.65,77.08)
  L4 w0.127: v2(180.65,84.11) 181.21,83.55 181.21,78.12 182.32,77.01 182.32,75.83 182.32,75.83 182.32,75.71 182.96,75.07 182.96,74.23 183.26,73.93 183.26,73.64 183.26,73.64 183.26,72.51 183.26,72.47 184.49,71.24 184.49,70.19 184.9,69.78 184.9,69.23 184.89,69.22 184.89,66.24 185.92,65.21 185.92,62.49 185.61,62.18 185.4,61.97 185.4,60.67 184.19,59.46 184.19,55.81 184.19,55.81 184.19,55.45 184.19,54.96 184.14,54.91 184.14,54.86 183.84,54.56 183.84,52.97 183.28,52.4 v2(183.28,51.73) 183.28,45.36 183.05,45.14 183.05,42.64 v2(183.03,42.62)
  BOTTOM w0.127: v2(63.65,77.08) 63.65,74.9 88.26,50.29 128.33,50.29 130.14,48.48 130.14,46.73 139.2,37.67 143.83,37.67 143.97,37.82 v2(144.89,37.82) ; v2(91.6,104.43) 92.01,104.84 EC1709.1 93.81,104.84 93.85,104.88 94.78,104.88 94.96,104.7 U1701.2 94.96,101.71 R1716.1
ALWON: length 247.8
  TOP w0.127: R4009.2 32.99,58.56 32.99,59.29 v1(32.35,59.92) v2(32.35,60.61) ; KBC24.121 184.88,65.29 184.81,65.22 184.81,63.34 v2(185.37,62.77)
  L3 w0.127: v2(183.37,22.75) 182.91,22.75 182.27,23.39 176.05,23.39 175.21,22.55 175.21,21.98 174.37,21.14 172.64,21.14 172,21.78 169.19,21.78 168.88,22.08 167.73,22.08 167.42,21.78 166.19,21.78 163.19,24.77 156.15,24.77 155.88,24.5 149.24,24.5 140.36,15.62 136.34,15.62 130.44,9.72 95.69,9.72 90.96,14.45 77.86,14.45 72.57,19.74 72.57,23.48 66.09,29.95 65.17,29.95 64.93,30.2 63.65,30.2 62.62,31.22 61.1,31.22 60.63,31.69 60.63,31.92 57.31,35.24 57.31,36.9 54.91,39.3 54.91,57.31 49.33,62.89 33.78,62.89 32.29,61.4 32.29,61.03 32.35,60.97 v2(32.35,60.61)
  L4 w0.127: v2(183.37,22.75) 183.59,22.97 183.59,28.07 183.29,28.36 183.29,29.77 184.82,31.31 184.82,31.76 184.67,31.91 184.67,33.54 183.71,34.51 183.71,36.14 183.37,36.47 183.37,39.54 182.83,40.08 182.83,42.19 182.59,42.43 182.59,42.8 182.8,43.01 182.8,45.24 182.82,45.27 182.82,53.22 183.12,53.52 183.12,54.25 183.94,55.07 183.94,55.35 183.94,55.71 183.94,59.15 183.94,59.56 185.15,60.77 185.15,62.08 185.35,62.28 185.35,62.76 v2(185.37,62.77)
AMBER_LED_BAT: length 3.5
  BOTTOM w0.508: v1(184.49,112.14) 184.21,111.85 R6407.1 EC6402.1 Q6403.C
AUD_AGND: length 14.2
  TOP w0.203: HDA27.38 25.55,12.33 25.3,12.08 v3(24.64,12.08) ; HDA27.25 24.33,18.64 v3(24.05,18.91)
  TOP w0.508: v2(16.12,14.35) 16.12,13.8 15.69,13.37 15.69,13.12 R307.2 ; v2(21.03,9.89) 21.28,10.14 EC2905.2 ; R2919.2 18.55,16.96 18.54,16.97 v2(18.54,17.15) ; v2(16.86,11.87) 17.1,11.63 EC2906.2 ; EC2706.1 16.67,18.94 v2(16.68,18.95) 16.67,18.97 EC2704.1 ; R2920.2 18.08,24.16 v2(17.77,24.46) ; v2(17.39,23.17) 17.32,23.25 EC9739.1
  BOTTOM w0.508: EC9743.1 17.29,23.27 v2(17.39,23.17) ; EC9745.1 14.73,13.89 v2(14.54,13.71) 13.65,14.6 R2727.1 ; v2(16.12,14.35) 16.16,14.39 16.16,14.6 EC9744.1
  vias: v1(26.11,25.02) v2(17.11,23.96) v2(19.5,21.77) v2(19.5,21.11) v2(19.53,20.3) v2(19.5,19.49) v2(20.37,21.85) v2(23.4,11.22) v2(23.37,10.5) v3(24.23,24.52) v3(26.26,24.24) v3(27.93,24.29)
AUD_HP1_JACK_L: length 3
  TOP w0.203: 23.55,15.27 HDA27.32
  TOP w0.254: R2908.1 22.39,15.19 22.47,15.27 22.73,15.27 22.73,15.27 23.55,15.27
AUD_HP1_JACK_L1: length 20.7
  TOP w0.254: v2(18.77,14.53) 18.66,14.63 18.66,15.08 18.89,15.31 18.89,15.32 19.17,15.6 19.2,15.6 19.44,15.84 R2919.1 20.22,16.01 20.29,16.01 20.48,16.01 R2912.2 20.49,15.19 R2908.2 ; R2922.2 17.76,21.96 EC2907.1 17.76,20.67 v2(18.03,20.4) ; v2(12.45,11.56) 12.68,11.33 R2907.2
  BOTTOM w0.254: v2(12.45,11.56) 14.16,11.56 14.97,12.37 16.89,12.37 17.6,13.08 17.6,13.96 18.17,14.53 v2(18.77,14.53) 18.89,14.66 18.89,16.08 19.04,16.24 19.04,17.36 18.52,17.89 v1(18.52,19.36) 18.52,19.91 v2(18.03,20.4)
AUD_HP1_JACK_R: length 9.8
  TOP w0.203: 23.55,14.87 HDA27.33
  TOP w0.254: v2(19.4,15.09) 19.4,14.86 v1(19.86,14.41) 19.96,14.3 20.25,14.3 20.61,14.66 21.75,14.66 21.76,14.67 22.39,14.67 22.59,14.87 23.55,14.87 ; R2910.1 18.94,17.94 v2(19.07,18.06)
  BOTTOM w0.254: v2(19.4,15.09) 19.73,15.42 19.73,17.45 19.12,18.06 v2(19.07,18.06)
AUD_HP1_JACK_R1: length 20.8
  TOP w0.254: R2909.2 11.64,15.64 v2(11.03,15.03) ; v2(17.67,17.28) 17.48,17.47 R2910.2 R2913.2 EC2908.1 17.47,19.63 17.47,19.85 16.86,20.46 v1(16.86,20.73) 16.86,20.76 17.24,21.14 17.24,22.36 17.46,22.58 17.74,22.58 R2920.1 18.09,22.93 R2921.2
  BOTTOM w0.254: v2(11.03,15.03) 11.03,14.65 12.8,12.88 16.63,12.88 17.09,13.34 17.09,14.17 18.22,15.3 18.22,16.73 v2(17.67,17.28)
AUD_PC_BEEP: length 4
  TOP w0.203: 30.38,20.96 v1(30.39,20.97) ; HDA27.12 30.38,18.28
  TOP w0.254: v1(30.39,20.97) 31.21,20.97 R2715.1 ; 30.38,18.28 30.22,18.44 30.22,20.8 30.38,20.96
AUD_PC_BEEP_3246: length 4.9
  TOP w0.203: 28.35,19.56 HDA27.16
  TOP w0.254: v2(30.11,21.78) 30.36,22.03 R2723.1 ; 28.35,19.56 28.35,19.8 v2(28.52,19.97)
  BOTTOM w0.254: v2(30.11,21.78) 29.52,21.78 28.95,21.21 28.95,20.4 v2(28.52,19.97)
AUD_PC_BEEP_C: length 4.7
  TOP w0.254: D2701.3 34.14,23.67 33.76,24.05 32.75,24.05 R2717.1 ; R2717.1 31.76,24.24 C2720.1 ; R2717.1 v1(32.56,25.15)
AUD_PC_BEEP_R: length 1.9
  TOP w0.254: R2715.2 31.25,21.81 R2723.2 31.7,23.02 C2720.2
AUD_PORTA_L_HPMIC1: length 12.1
  TOP w0.381: HPMIC1.1 9.56,2.91 10.75,2.91 11.61,3.77 11.61,8.47 v1(12.21,9.07) 12.69,9.55 ED303.1 13.61,9.93 14.55,10.87 R2907.1
AUD_PORTA_R_HPMIC1: length 13.7
  TOP w0.381: R2909.1 12.4,14.61 ED304.1 13.65,14.41 12.99,13.75 v2(12.99,13.54)
  L4 w0.381: v2(12.99,13.54) 12.06,13.54 11.59,14.02 5.35,14.02 HPMIC1.2
  BOTTOM w0.381: v2(12.99,13.54) v1(13.65,13.54)
AUD_SENSE: length 21.9
  TOP w0.254: v2(29.14,23.3) 29.26,23.19 R2709.2 ; v2(18.11,13.7) 18.49,13.7 19.1,13.09 R2923.2
  BOTTOM w0.254: v2(18.11,13.7) 18.11,13.75 18.26,13.9 19.2,13.9 21.08,15.78 21.08,20.16 21.8,20.89 21.8,21.23 v1(22.32,21.75) 25.57,25 27,25 27.33,24.67 27.33,24.03 28.04,23.32 29.13,23.32 v2(29.14,23.3)
AUD_SENSE_A: length 5.6
  TOP w0.203: v1(29.55,20.06) HDA27.13
  TOP w0.254: R2722.2 29.41,23.75 29.79,23.37 29.79,22.22 29.64,22.07 29.6,22.07 R2709.1 29.26,21.55 29.55,21.25 v1(29.55,20.06)
AUD_SPK_L+: length 16.1
  TOP w0.203: v3(27.33,11.13) 27.15,11.3 HDA27.42
  L3 w1.016: v3(39.58,14) 39.58,12.96 38.87,12.25 35.85,12.25 35.37,11.76 32.56,11.76 32.31,12.02 31.49,12.02 31.48,12.02 28.22,12.02 28.08,11.88 28.05,11.88 27.33,11.16 v3(27.33,11.13)
  vias: v1(39.42,13.33)
AUD_SPK_L+_C: length 19
  TOP w1.016: 45.32,11.86 58.26,11.86 58.85,11.27 64.05,11.27
AUD_SPK_L-: length 15.6
  TOP w0.203: v3(28.29,10.29) 27.93,10.65 v1(27.93,10.88) 27.93,11.43 27.55,11.82 HDA27.43
  L3 w1.016: v3(28.29,10.29) 28.75,10.75 30.95,10.75 30.97,10.73 30.97,10.73 31.21,10.49 36.18,10.49 36.36,10.67 39.51,10.67 v3(40.33,11.49)
AUD_SPK_L-_C: length 19
  TOP w1.016: 64.05,9.99 58.25,9.99 57.65,10.59 45.27,10.59
AUD_SPK_R+: length 11.7
  TOP w0.203: v3(30.35,9.48) 29.76,10.06 29.76,10.49 v1(29.15,11.1) 28.98,11.28 28.98,11.48 28.35,12.1 HDA27.45
  L3 w1.016: v3(30.35,9.48) 30.42,9.48 30.68,9.22 37.49,9.22 v3(37.65,9.39)
AUD_SPK_R+_C: length 19
  TOP w1.016: 64.05,8.72 48.17,8.72 47.75,9.13 45.21,9.13
AUD_SPK_R-: length 13.3
  TOP w0.203: v3(28.9,9.17) 29.08,9.35 v1(29.08,9.89) 29.08,10.47 28.68,10.87 28.68,11.2 27.95,11.92 HDA27.44
  L3 w1.016: v3(28.9,9.17) 28.9,9.1 30.17,7.83 v3(37.36,7.83)
AUD_SPK_R-_C: length 20.4
  TOP w1.016: 64.05,7.44 47.65,7.44 47.23,7.86 43.8,7.86
AUD_VREF: length 3.1
  TOP w0.203: v1(23.16,16.96) 23.25,16.87 HDA27.28
  TOP w0.254: C2705.2 21.78,17.52 22.6,17.52 v1(23.16,16.96)
AUX_EN_WOWL: length 27.8
  TOP w0.14: R2401.2 R2499.2 173.59,62.04 173.59,60.23 170.17,56.8 v1(169,56.8) 166.67,56.8 v2(165.93,56.06) ; R1721.2 161,56.22 v2(159.18,58.04) 158.7,57.57 158.7,57.37 158.66,57.32 R6105.2 157.82,54.69 R6104.1
  L3 w0.127: v2(165.93,56.06) 165.41,56.59 160.63,56.59 v2(159.18,58.04)
AUX_EN_WOWL_R: length 53.9
  TOP w0.14: R1721.1 161,54.4 159.29,52.69 159.29,51.58 156.72,49.01 150.31,49.01 148.83,50.5 147.94,50.5 ; 147.94,50.5 147.91,50.53 145.69,50.53 145.37,50.84 143.78,50.84 143.03,51.59 141.85,51.59 141.49,51.95 136.21,51.95 133.17,54.99 v2(133.17,56.31) ; 147.94,50.5 v1(147.95,50.5)
  BOTTOM w0.089: CPU1.BB17 125.97,70.94 126.46,70.45 126.46,68.35 126.64,68.17
  BOTTOM w0.14: v2(133.17,56.31) 132.98,56.31 128.55,60.73 128.55,63.82 128.04,64.33 128.04,66.29 126.83,67.5 126.83,67.98 126.64,68.17
BAT1_LED#: length 7
  TOP w0.102: KBC24.1 189.22,67.96 189.74,67.44 189.74,66.68 189.74,66.67 189.74,66.32 190.74,65.31 R2484.1 192.12,65.31 192.7,64.74 Q2412.S 192.7,63.73 v1(192.53,63.56)
BAT2_LED#: length 21.9
  TOP w0.102: KBC24.106 178.88,65.73 178.59,65.45 177.13,65.45 176.9,65.22 174.22,65.22 173.35,64.35 173.35,64.09 173.09,63.83 172.83,63.83 172.64,63.64 171.54,63.64 170.97,64.22 169.58,64.22 168.46,65.34 165.31,65.34 v1(164.36,66.3) 162.86,67.8 R2488.1 162.26,68.64 Q2413.S
BAT_AMBER: length 17.5
  TOP w0.305: LEDBD1.1 190.44,123.12
  TOP w0.508: v2(186.09,121.97) 187.95,121.97 AFTP6308.1 189.11,123.12 190.44,123.12
  BOTTOM w0.508: v2(186.09,121.97) 186.09,117.18 185.77,116.87 185.77,111.69 185.11,111.03 R6407.2
BAT_WHITE: length 21.8
  TOP w0.305: 190.02,123.75 190.66,123.75 190.79,123.62 LEDBD1.2
  TOP w0.508: v2(186.83,122.66) 187.74,122.66 188.83,123.75 AFTP6307.1 190.02,123.75
  BOTTOM w0.508: R6406.2 185.1,108.05 186.56,109.51 186.56,116.31 187.42,117.17 187.42,119.12 186.83,119.71 v2(186.83,122.66)
BATT_WHITE_LED#: length 49.5
  TOP w0.102: Q2412.D 194.6,67.99 194.1,68.48 v1(193.47,68.48) 193.28,68.67 v2(192.87,68.67)
  L3 w0.102: v2(192.46,90.1) 192.38,90.19 190.46,90.19 188.98,91.66 187.01,91.66 186.51,92.17 185.07,92.17 184.79,92.44 v2(182.54,92.44)
  BOTTOM w0.102: v2(192.46,90.1) 192.54,90.18 193.48,90.18 193.86,89.81 193.86,88.01 192.8,86.95 192.8,83.09 193.75,82.13 193.75,77.15 194.15,76.75 194.15,71.84 193.59,71.28 193.59,69.39 v2(192.87,68.67) ; Q6406.4 182.13,99.94 181.81,99.62 181.81,99.58 181.77,99.55 181.77,98.09 182.54,97.32 v2(182.54,92.44)
BATT_WHITE_LED#_M: length 2.9
  BOTTOM w0.381: 182.74,103.68 182.48,103.93 Q6406.3
  BOTTOM w0.508: v1(184.67,103.83) 184.32,103.47 R6404.1 182.94,103.47 182.74,103.68
BATT_WHITE_LED_R#: length 4.5
  BOTTOM w0.102: v1(184.62,105.06) 183.92,104.36 R6404.2 182.76,105.06 181.44,105.06 Q6404.B
BEEP: length 228.3
  TOP w0.203: v2(182.71,83.3) 182.88,83.14 KBC24.45
  TOP w0.254: v2(37.94,19.98) 37.94,20.13 38,20.19 RN2701.1
  L3 w0.254: v2(183.13,21.26) 177.62,15.75 162.77,15.75 161.56,14.55 146.94,14.55 137.85,5.46 93.25,5.46 90.49,8.23 72.81,8.23 70.22,10.81 59.15,10.81 58.14,11.82 49.34,11.82 48.97,12.18 47.4,12.18 44.71,14.88 44.71,16.62 43.46,17.87 41.62,17.87 40.03,19.46 38.46,19.46 v2(37.94,19.98)
  L4 w0.254: v2(183.13,21.26) 183.13,21.69 184.31,22.87 184.31,30.01 185.27,30.98 185.27,31.94 185.12,32.09 185.12,40.12 183.94,41.3 183.94,43.51 183.72,43.72 183.72,44.86 184.51,45.64 184.51,54.28 184.9,54.67 184.9,59.18 186.08,60.36 186.08,61.69 186.33,61.95 186.59,62.21 186.59,65.49 186.12,65.97 186.12,68.86 185.57,69.41 185.57,70.06 185.16,70.47 185.16,71.52 183.94,72.75 183.94,74.21 183.63,74.51 183.63,75.35 182.99,75.99 182.99,78.43 182.15,79.27 182.15,82.73 182.72,83.3 v2(182.71,83.3)
  BOTTOM w0.254: v2(182.71,83.3) v1(182.71,82.74)
BKLGT_PWM: length 59.9
  TOP w0.102: v2(183.77,80.03) 183.28,80.53 KBC24.44 ; Q6501.G 198.89,115.97 R6505.1 199.11,117.24 198.21,118.14 196.97,118.14 196.08,119.04 v2(195.55,119.04)
  L4 w0.102: v2(183.77,80.03) 183.77,80.59 183.15,81.21 183.15,83.51 180.69,85.97 180.69,91.5 180.53,91.66 180.53,92.04 180.8,92.31 180.8,92.55 181.65,93.39 181.65,98.81 v2(182.2,99.37)
  BOTTOM w0.102: v2(195.55,119.04) 195.52,119.04 194.02,120.53 191.82,120.53 187.82,116.54 187.82,114.68 187.09,113.95 v1(187.09,109.2) 187.09,107.17 186.53,106.61 186.53,104.77 182.76,101 182.76,99.92 v2(182.2,99.37)
BKLT_CTRL: length 17
  TOP w0.14: v2(76.09,165.08) 74.45,165.08 72.92,166.61 v2(71.3,166.61)
  BOTTOM w0.14: v2(76.09,165.08) 76.09,165.08 R5524.1 ; D5503.3 67.37,162.05 69.53,164.21 RN5502.8 69.56,166.61 v2(71.3,166.61) 72.39,166.61 v1(72.61,166.84) 72.95,167.18 RN5503.7
BLON_OUT_C: length 11.2
  TOP w0.102: v2(71.09,167.93) 71.42,168.26 75.35,168.26 v2(76.81,166.81) 77.07,166.81 77.58,167.32 LCD1.21
  BOTTOM w0.102: v2(71.09,167.93) 71.09,167.73 v1(70.79,167.43) 70.6,167.23 RN5502.7 ; v2(76.81,166.81) 76.68,166.68 RN5503.3
BLUETOOTH_EN: length 67.3
  TOP w0.102: R6113.1 164.2,56.28 164.71,56.28 v1(165.19,56.76) v2(165.97,57.54)
  L3 w0.102: v2(165.06,84.15) 163.56,84.15 163.26,84.45 160.13,84.45 159.27,85.3 157.78,85.3 156.11,83.63 150.83,83.63 150.4,83.2 149.04,83.2 148.58,83.66 145.99,83.66 145.61,83.28 144.28,83.28 v2(143.85,83.71)
  L4 w0.102: v2(165.06,84.15) 165.32,83.89 165.32,83.47 165.47,83.32 165.47,81.02 165.66,80.82 165.66,80.07 165.66,80.07 165.66,78.83 165.82,78.67 166.49,78 166.49,74.09 166.2,73.81 166.2,73.09 166.43,72.86 166.43,70.44 166.37,70.38 166.37,67.93 166.88,67.43 166.88,66.49 166.88,66.13 166.5,65.76 166.27,65.76 164.76,64.24 164.76,63.22 166.19,61.78 166.19,57.76 v2(165.97,57.54) ; v2(138.39,84) 138.39,84.16 138.78,84.55 140.54,84.55 141.32,83.77 143.71,83.77 143.72,83.76 143.79,83.76 v2(143.85,83.71)
  BOTTOM w0.089: 136.95,83.8 136.01,83.8 135.9,83.84 135.82,83.88 135.62,83.88 135.45,83.81 135.26,83.81 CPU1.AB2
  BOTTOM w0.102: R2002.2 144.84,82.71 v2(143.85,83.71) ; v2(138.39,84) 138.39,83.81 138.19,83.61 137.14,83.61 136.95,83.8
BLUETOOTH_EN_NGFF: length 8.7
  TOP w0.102: v2(166.6,49.06) 164.19,51.47 AFTP5804.1 164.19,53.77 R6113.2
  BOTTOM w0.102: v2(166.6,49.06) 167.31,49.77 WLAN1.54
BOARD_ID: length 24.8
  TOP w0.102: R2499.1 173.41,63.87 173.55,64 173.55,64.26 174.17,64.89 178.92,64.89 179.36,64.44 v1(179.64,64.44) 179.81,64.61 v2(180.49,64.61) 180.49,64.73 180.88,65.12 KBC24.111 ; v2(178,57.16) 177.5,57.67 175.74,57.67 175.45,57.37 R2494.1 R2495.1
  BOTTOM w0.102: v2(178,57.16) 178,58.01 179.27,59.27 179.99,59.27 180.59,59.87 180.59,60.97 180.69,61.07 180.69,64.41 v2(180.49,64.61)
BOARD_ID2: length 9.1
  BOTTOM w0.089: CPU1.AB3 134.56,83.47 134.73,83.47 134.96,83.36 135.16,83.36 135.25,83.39 135.53,83.39 135.61,83.36 136.23,83.36 136.38,83.21 137.54,83.21
  BOTTOM w0.102: 137.54,83.21 v1(137.99,83.21) 138.34,83.21 138.42,83.29 140.05,83.29 140.19,83.15 141.58,83.15 142.09,82.64 R2008.1 142.26,81.82 R2005.2
BOARD_ID3: length 17.6
  TOP w0.102: v2(137.21,66.12) 136.89,66.44 136.89,66.91 v1(136.89,66.91)
  L4 w0.102: v2(137.21,66.12) 136.05,66.12 134.86,67.31 134.86,67.61 132.76,69.7 v2(132.76,70.72)
  BOTTOM w0.089: CPU1.BA7 131.75,72.85 131.75,72.11 132.15,71.71 132.15,71.66 132.76,71.05 v2(132.76,70.72)
  BOTTOM w0.102: v2(137.21,66.12) 137.38,65.94 138.31,65.94 138.51,65.74 139.66,65.74 140.22,65.18 140.83,65.18 141.94,64.07 R2026.1 142.57,63.95 R2025.2
BOARD_ID_C: length 3.8
  TOP w0.102: R2495.2 173.67,55.81 173.6,55.75 R2444.1 C2408.2 ; R2495.2 173.67,57.09 v1(173.82,57.24) ; R2495.2 R2443.2
BOOST_MON: length 177.4
  TOP w0.254: v2(148.56,140.92) 148.44,141.05 148.35,141.05 148.05,141.35 148.05,142.91 146.91,144.05 144.71,144.05 v1(144.07,144.69) 143.67,145.09 138.11,145.09 129.9,153.31 120.28,153.31 119.11,154.47 112.18,154.47 110.92,155.73 109.37,155.73 107.08,158.02 101.8,158.02 v2(100.78,157) ; v2(175.26,116.13) 175.14,116.13 174.46,116.8 171.05,116.8 170.89,116.65 168,116.65 158.52,107.16 158.1,107.16 157.95,107.16 v2(157.61,107.5)
  L4 w0.254: v2(157.61,107.5) 157.32,107.79 157.32,112.91 156.48,113.75 156.07,113.75 151.56,118.27 151.56,120 151.58,120.02 151.58,123.23 151.56,123.25 151.56,127 153.42,128.86 153.42,134.49 153.84,134.91 153.84,137.17 151.26,139.75 150.74,139.75 149.57,140.92 v2(148.56,140.92)
  BOTTOM w0.254: R2423.1 183.26,67.07 182.99,67.34 182.99,68.95 181.65,70.3 181.65,70.87 182.14,71.36 182.14,71.97 181.71,72.4 181.55,72.4 179.78,74.16 179.78,74.19 179.74,74.23 179.74,76.13 178.33,77.55 178.33,79.3 178.33,79.3 178.33,79.35 177.97,79.71 177.97,80.29 178,80.32 178,81.31 177.99,81.32 177.99,81.38 176.71,82.67 176.71,84.88 179.16,87.33 179.42,87.33 180.64,88.55 180.64,90.63 181.05,91.04 181.05,91.77 181.32,92.04 181.32,96.87 177.65,100.54 177.65,112.47 175.26,114.85 v2(175.26,116.13) ; PC4424.1 100.1,157 v2(100.78,157) PG4414.2
BT+: length 49.5
  TOP w0.508: v2(116.07,165.89) 116.67,165.3 PD4405.A
  TOP w0.762: 161.5,179.02 BATT1.1 ; BATT1.1 163,180.52 ; BATT1.1 161.5,180.52 ; BATT1.1 163,179.02 ; 159.5,179.02 BATT1.2 ; BATT1.2 161,179.02 ; BATT1.2 161,180.52 ; BATT1.2 159.46,180.56
  L3 w0.508: v2(144.23,168.28) 138.43,168.28 136.02,165.87 130.15,165.87 129.83,166.19 127.86,166.19 127.12,165.45 125.22,165.45 123.52,167.15 117.03,167.15 116.07,166.19 v2(116.07,165.89)
  BOTTOM w0.762: 161.5,180.52 BATT1.1 ; BATT1.1 161.5,179.02 ; BATT1.1 163,180.52 ; BATT1.1 163,179.02 ; 159.5,179.02 BATT1.2 ; BATT1.2 161,180.52 ; BATT1.2 159.35,180.67 ; BATT1.2 161,179.02
  vias: v1(135.61,175.35) v1(135.6,175.32) v1(145.48,172.65) v1(150.78,169.24) v1(158.35,171.3) v3(131.77,175.42) v3(131.77,173.51) v3(131.77,171.61) v3(131.77,169.7) v3(132.61,175.42) v3(132.61,173.51) v3(132.61,171.61) v3(132.61,169.7) v3(133.45,175.42) v3(133.45,173.51) v3(133.45,171.61) v3(133.45,169.7) v3(134.28,175.42) v3(134.28,173.51) v3(134.28,171.61) v3(134.28,169.7) v3(160.01,176.94) v3(160.01,175.92) v3(160.01,174.91) v3(160.01,173.89) v3(160.4,172.88) v3(161.03,176.94) v3(161.03,175.92) v3(161.03,174.91) v3(161.03,173.89) v3(161.41,172.88) v3(162.05,176.94) v3(162.05,175.92) v3(162.55,172.88)
BT+_1: length 71
  TOP w0.254: PG4417.1 v2(164.84,176.56)
  L4 w0.254: v2(107.18,172.72) 107.18,173.07 107.5,173.38 112.39,173.38 112.67,173.11 117.41,173.11 118.53,171.99 118.95,171.99 119.71,172.75 120.93,172.75 121.66,172.02 126.61,172.02 126.87,171.76 129.74,171.76 130.32,172.33 152.34,172.33 158.01,178.01 163.39,178.01 v2(164.84,176.56)
  BOTTOM w0.254: v2(107.18,172.72) 107.18,170.97 v1(106.81,170.6) 106.29,170.08 PR4414.2
BUFRST#: length 8
  BOTTOM w0.102: GPU1.D11 201.26,140.19 201.6,139.85 201.88,139.85 202.19,139.54 202.19,139.21 202.43,138.97 203.6,138.97 v1(205.86,136.71) 206.8,135.77 R7628.2
CAP_LED: length 6.6
  TOP w0.305: KB1.4 190.83,115.05 191.1,115.32 191.1,116.69 191.71,117.3 v2(191.71,117.99) AFTP6243.1
  BOTTOM w0.508: R6506.2 191.71,118.61 v2(191.71,117.99)
CAP_LED#: length 11
  TOP w0.102: KBC24.93 170.03,69.41 169.96,69.34 168.97,69.34 168.65,69.66 166.69,69.66 166.33,69.31 Q2414.S 166.33,68.29 166.44,68.19 R2489.1 166.76,67.61 167.22,67.15 v1(167.22,66.58)
CAP_LED#_S: length 84.9
  TOP w0.102: v2(166.64,73.32) 166.64,71.64 165.86,70.86 Q2414.D
  L3 w0.102: v2(195.87,70.36) 193.91,70.36 192.95,71.33 191.62,71.33 191.01,70.72 187.19,70.72 186.59,71.31 185.7,71.31 185.35,70.96 183.54,70.96 183.26,71.23 176.23,71.23 176.04,71.42 175.95,71.42 175.55,71.82 175.55,72.21 174.89,72.87 171.43,72.87 171.11,72.56 169.38,72.56 168.63,73.32 v2(166.64,73.32)
  BOTTOM w0.102: R6508.1 197.66,117.17 197.68,117.15 EC6507.1 197.68,115.12 v1(197.32,114.76) 196.95,114.38 196.95,109.43 195.77,108.25 195.77,101.47 195.38,101.08 195.38,97.21 196.45,96.15 196.45,95.13 196.99,94.58 196.99,90.79 195.5,89.3 195.5,87.31 195.44,87.25 195.44,83.74 195.05,83.34 195.05,77.53 195.46,77.12 195.46,71.27 195.87,70.86 v2(195.87,70.36)
CAP_LED_Q: length 2.6
  BOTTOM w0.508: Q6502.C 194.36,118.95 R6506.1 192.94,119.52 v1(192.57,119.88)
CAP_LED_R#: length 2.9
  BOTTOM w0.102: R6508.2 197.66,118.73 197.79,118.86 v1(197.79,119.31) 197.79,119.57 197.4,119.96 Q6502.B
CBN: length 2.7
  TOP w0.203: 23.67,13.93 23.81,14.07 HDA27.35
  TOP w0.254: 23.67,13.93 23.12,13.38 23.12,13.19 v1(23.09,13.16) 22.7,13.16 22.51,12.97 22.19,12.97 C2703.1
CBP: length 4.7
  TOP w0.203: HDA27.37 24.79,12.85
  TOP w0.254: 24.79,12.85 24.52,12.85 24.33,12.65 22.97,12.65 22.61,12.3 21.48,12.3 21.29,12.49 C2703.2
CFG0: length 10
  BOTTOM w0.089: CPU1.E68 97.86,93.5 97.86,93.96 97.76,94.06 97.76,94.28 97.91,94.43 97.91,94.86 97.94,94.94 97.94,94.94 97.94,95.46 97.79,95.61 97.79,96.04 97.62,96.21
  BOTTOM w0.14: 97.62,96.21 97.31,96.52 93.37,96.52 93.11,96.78 TP9933.1
CFG1: length 9.4
  BOTTOM w0.089: CPU1.B67 97.5,94.45 97.73,94.68 97.73,94.89 97.76,94.97 97.76,94.97 97.76,95.23 97.76,95.38 97.61,95.53 97.61,95.68 97.61,95.68 97.61,95.86 97.27,96.19 96.46,96.19
  BOTTOM w0.14: 96.46,96.19 92.83,96.19 92.65,96.37 90.32,96.37 TP9925.1
CFG2: length 13.3
  BOTTOM w0.089: CPU1.D65 98.46,93.52 98.46,94.16 98.41,94.3 98.41,94.57 98.45,94.66 98.45,94.86 98.41,94.95 98.41,95.34 98.58,95.51 98.58,96.03 98.32,96.29 97.89,96.29 97.68,96.5
  BOTTOM w0.14: 97.68,96.5 97.37,96.8 93.52,96.8 93.11,97.21 TP9929.1
CFG3: length 11.6
  BOTTOM w0.114: CPU1.D67 97.5,94 97.22,94.28 97.22,94.95 97.15,95.02 97.15,95.21 96.97,95.38 96.92,95.38 96.43,95.88 93.95,95.88 93.71,95.64
  BOTTOM w0.14: R604.1 88.36,96.04 88.41,95.99 TP9926.1 89.6,95.99 89.68,96.07 91.99,96.07 92.43,95.64 93.71,95.64
CFG4: length 5.5
  BOTTOM w0.089: CPU1.E70 95.46,92.78 95.21,93.03 94.87,93.03 94.62,93.29 94.18,93.29
  BOTTOM w0.114: 94.18,93.29 92.13,93.29 TP9928.1
  BOTTOM w0.14: R605.1 90.81,93.68 TP9928.1
CFG5: length 10.9
  BOTTOM w0.089: 94.72,94.17 94.72,94.17 94.83,94.28 95.31,94.28 95.45,94.15 95.81,94.15 96.04,93.92 96.08,93.92 96.61,93.39 CPU1.C68
  BOTTOM w0.14: 94.72,94.17 94.65,94.11 93.04,94.11 92.5,94.64 91,94.64 90.79,94.44 88.79,94.44 88.25,93.91 87.4,93.91 TP9924.1
CFG6: length 8.5
  BOTTOM w0.114: CPU1.D68 95.58,93.31 95.23,93.65 92.43,93.65 92.24,93.84
  BOTTOM w0.14: TP9932.1 88.89,94.14 91.94,94.14 92.24,93.84
CFG7: length 11.3
  BOTTOM w0.089: CPU1.C67 96.25,94.07 96.06,94.26 96.06,94.64 95.9,94.8 95.9,95.17 95.87,95.2
  BOTTOM w0.114: 93.39,94.87 93.54,94.87 93.87,95.2 93.89,95.2 94.1,95.41 95.68,95.41 95.87,95.22 95.87,95.2
  BOTTOM w0.14: TP9930.1 89.81,94.77 89.82,94.79 90.82,94.79 90.9,94.87 93.39,94.87
CFG8: length 5.6
  BOTTOM w0.089: CPU1.F71 95.48,92.21 93.71,92.21 93.63,92.29
  BOTTOM w0.14: 93.63,92.29 93.29,92.64 90.8,92.64 TP9943.1
CFG9: length 5.1
  BOTTOM w0.089: CPU1.G69 95.92,91.89 95.39,91.89 95.25,92.03 93.49,92.03 93.38,92.13 93.15,92.13
  BOTTOM w0.14: 93.15,92.13 TP9935.1
CFG10: length 7.9
  BOTTOM w0.089: 93.86,92.7 94.17,92.39 95.22,92.39 95.24,92.41 95.71,92.41 96.03,92.09 CPU1.F70
  BOTTOM w0.14: TP9939.1 90,93.01 93.56,93.01 93.86,92.7
CFG11: length 8.3
  L4 w0.127: v2(93.14,91.19) 93.41,91.19 94.05,91.84 95.83,91.84 95.9,91.77 97.33,91.77 v2(97.44,91.88)
  BOTTOM w0.14: TP9936.1 90.96,90.81 91.7,90.81 91.88,90.99 92.94,90.99 v2(93.14,91.19) ; v2(97.44,91.88) 97.04,91.48 CPU1.G68
CFG12: length 6.7
  BOTTOM w0.089: 93.2,89.63 93.93,90.36 94.07,90.36 94.08,90.37 94.83,90.37 95.02,90.56 95.76,90.56 CPU1.H70
  BOTTOM w0.14: 93.2,89.63 92.12,88.55 90.61,88.55 TP9942.1
CFG13: length 7.1
  BOTTOM w0.14: CPU1.G71 94.14,91.53 92.57,89.96 90.4,89.96 TP9940.1
CFG14: length 6
  BOTTOM w0.089: 94.11,90.9 94.35,91.14 96.2,91.14 96.47,90.87 CPU1.H69
  BOTTOM w0.14: 94.11,90.9 93.06,89.85 92.96,89.85 92.07,88.97 TP9941.1
CFG15: length 8.4
  BOTTOM w0.089: 93.4,91.79 95.24,91.79 95.5,91.53 CPU1.G70
  BOTTOM w0.14: TP9937.1 88.26,91.62 91.61,91.62 91.85,91.86 92.48,91.86 92.55,91.79 93.4,91.79
CFG16: length 2.3
  TOP w0.14: TP9927.1 99.07,93.24 99.07,92.63 99.56,92.15 v2(99.56,92.06)
  BOTTOM w0.14: v2(99.56,92.06) 99.72,92.06 CPU1.E63
CFG17: length 2.9
  TOP w0.14: TP9931.1 100.46,92.8 101,92.25 101,91.83 v2(100.57,91.4)
  BOTTOM w0.14: CPU1.F63 100.2,91.77 v2(100.57,91.4)
CFG18: length 10.9
  L4 w0.127: v2(98.53,92.09) 98.3,92.32 96.57,92.32 96.44,92.2 96.07,92.2 96.01,92.27 93.18,92.27 v2(92.32,91.41)
  BOTTOM w0.14: CPU1.E66 98.2,92.42 v2(98.53,92.09) ; v2(92.32,91.41) 91.82,91.41 91.56,91.15 90.03,91.15 TP9934.1
CFG19: length 7.3
  L4 w0.127: v2(97.43,91) 96.05,91 95.65,91.4 94.15,91.4 93.32,90.58 v2(92.38,90.58)
  BOTTOM w0.14: CPU1.F66 97.43,91.15 v2(97.43,91) ; TP9938.1 92.14,90.34 v2(92.38,90.58)
CFG_RCOMP: length 19.3
  L4 w0.203: v2(102.42,92.04) 101.12,93.34 92.97,93.34 90.16,90.52 v2(88.31,90.52)
  BOTTOM w0.203: CPU1.E60 102.1,92.36 v2(102.42,92.04) ; R601.1 87.55,89.71 87.75,89.51 v1(88.06,89.51) 88.31,89.51 88.54,89.74 88.54,90.29 v2(88.31,90.52)
CHARGER_SRC:
  vias: v1(119.88,156.93) v3(116.33,156.87) v3(117.22,156.87) v3(118.1,156.87)
CHG_AGND: length 16.4
  BOTTOM w0.508: v2(112.54,156.77) 112.36,156.6 111.86,156.6 PC4412.1 111.48,154.56 110.55,153.64 PC4404.1 PC4403.1 ; PR4425.2 98.65,158.17 PC4424.2 98.65,156.52 99.93,155.23 99.93,155.21 PC4423.2 100.09,155.35 100.93,156.19 102.08,156.19 v2(102.36,155.91) ; PR4424.2 101,161.85 100.53,162.32 v2(100.53,162.64) ; v2(100.59,164.38) 100.72,164.52 101.26,164.52 PR4423.2 ; PC4421.2 108.2,169.45 v2(107.69,169.96) 107.31,169.57 PC4422.2
  vias: v1(106.24,161.65) v2(105.94,160.23) v2(106.57,160.86) v2(106.57,160.23) v2(106.57,159.59) v2(107.21,160.23)
CHG_AMBER_LED#: length 50.1
  TOP w0.102: v2(163.07,71.36) 162.09,71.36 Q2413.D
  L3 w0.102: v2(163.07,71.36) 163.1,71.4 163.5,71.4 164.07,71.97 167.01,71.97 167.4,71.58 168,71.58 168.13,71.71 169.69,71.71 169.93,71.47 170.73,71.47 171.17,71.91 174.72,71.91 175.02,71.61 v2(175.17,71.61)
  L4 w0.102: v2(175.17,71.61) 175.17,72.05 174.78,72.44 174.78,73.52 174.9,73.63 174.9,74.69 175.09,74.89 175.09,80.31 175.36,80.58 175.36,81.89 176.27,82.8 176.27,84.37 177.62,85.72 177.62,90.06 177.67,90.11 177.67,94.81 179.26,96.4 179.26,101.96 180.04,102.74 180.04,103.31 v2(180.09,103.37)
  BOTTOM w0.102: v2(180.09,103.37) 180.65,103.93 Q6406.1 ; v2(163.07,71.36) v1(162.45,71.36)
CHG_AMBER_LED#_M: length 7
  BOTTOM w0.381: Q6406.6 180.31,102.05 179.97,102.39
  BOTTOM w0.508: R6405.1 179.3,108.13 v1(179.3,105.21) 179.3,103.06 179.97,102.39
CHG_AMBER_LED_R#: length 2.6
  BOTTOM w0.102: v1(178.38,109.04) R6405.2 179.44,109.15 Q6403.B
CL_CLK: length 98.9
  TOP w0.14: R6109.1 172.42,53.51 v2(172.46,53.56)
  L3 w0.127: v2(176.42,97.94) 175.23,97.94 174.58,97.29 165.35,97.29 165.23,97.17 160.94,97.17 160.38,96.61 160.13,96.61 159.87,96.87 153.35,96.87 152.35,95.86 150.88,95.86 150.19,96.55 138.72,96.55 138.09,95.92 138.09,95.39 137.19,94.49 137.19,94.21 v2(137.09,94.11)
  BOTTOM w0.089: 136.62,93 136.62,92.86 135.8,92.04 135.76,92.02 135.61,92.02 135.6,92.02 135.48,91.97 135,91.97 134.82,91.8 134.64,91.8 CPU1.G3
  BOTTOM w0.14: 136.62,93 136.62,93.22 137.09,93.69 v2(137.09,94.11) ; v2(172.46,53.56) 174.32,55.41 174.32,59.77 174.28,59.81 174.28,65.06 177.15,67.93 177.15,69.66 176.71,70.1 176.71,72.27 176.42,72.56 175.15,72.56 174.32,73.4 174.32,76.97 173.53,77.76 173.53,80.37 173.19,80.7 173.19,84.43 175.53,86.77 175.53,87.11 175.53,87.15 176.33,87.95 176.45,87.95 178.02,89.52 178.02,90.08 178.43,90.5 178.43,95.93 v1(177.58,96.78) v2(176.42,97.94)
CL_CLK_R: length 3.7
  TOP w0.14: v1(169.38,52.69) 169.87,53.17 v2(169.92,53.17) 170.26,53.51 R6109.2
  BOTTOM w0.14: v2(169.92,53.17) 169.52,52.77 WLAN1.42
CL_DATA: length 96.6
  TOP w0.14: v2(172.45,54.2) 172.24,54.42 R6119.1
  L3 w0.127: v2(137.7,94.27) 137.7,94.46 138.47,95.23 138.47,95.76 138.88,96.17 150.03,96.17 150.72,95.48 152.51,95.48 153.51,96.49 159.71,96.49 159.98,96.22 160.53,96.22 161.09,96.78 165.38,96.78 165.51,96.91 174.74,96.91 175.39,97.56 176.17,97.56 176.51,97.22 v2(176.51,96.89)
  BOTTOM w0.089: 136.94,93.12 136.85,93.02 136.85,92.8 135.89,91.85 135.65,91.85 135.51,91.79 135.28,91.79 CPU1.G2
  BOTTOM w0.14: v2(176.51,96.89) 176.88,96.89 178.01,95.76 178.01,90.69 177.46,90.14 177.46,89.67 176.65,88.86 176.06,88.86 175.11,87.91 175.11,86.94 172.77,84.6 172.77,82.67 v1(172.77,82.67) 172.77,80.53 173.11,80.19 173.11,77.59 173.9,76.8 173.9,73.22 174.98,72.14 175.56,72.14 176.29,71.42 176.29,69.93 176.73,69.48 176.73,68.11 173.86,65.23 173.86,59.64 173.9,59.6 173.9,55.65 v2(172.45,54.2) ; v2(137.7,94.27) 137.7,93.88 136.94,93.12
CL_DATA_R: length 4.4
  TOP w0.14: v1(169.58,54.1) 170.12,54.64 v2(170.12,54.67) 170.36,54.42 R6119.2
  BOTTOM w0.14: v2(170.12,54.67) 170.12,54.2 169.19,53.27 WLAN1.40
CL_RST#: length 96.8
  TOP w0.14: R6108.1 172.31,55.3 172.45,55.16 v2(172.45,54.84)
  L3 w0.127: v2(138.91,95.57) 139.12,95.79 149.87,95.79 150.56,95.1 152.66,95.1 153.67,96.11 159.55,96.11 159.82,95.84 160.7,95.84 161.25,96.39 165.53,96.39 165.67,96.53 169.01,96.53 169.14,96.4 169.14,95.34 169.26,95.21 169.52,95.21 169.65,95.34 169.65,96.4 169.77,96.53 170.03,96.53 170.15,96.4 170.15,95.49 170.28,95.36 170.53,95.36 170.66,95.49 170.66,96.4 170.79,96.53 171.81,96.53 171.93,96.4 171.93,95.08 172.06,94.95 172.31,94.95 172.44,95.08 172.44,96.4 172.57,96.53 173.25,96.53 173.4,96.38 v2(173.4,96.01)
  L4 w0.127: v2(172.59,76.49) 172.59,77.24 171.76,78.07 171.76,79.02 172.34,79.6 172.34,83.78 173.21,84.65 173.21,87.96 173.68,88.43 173.68,95.73 v2(173.4,96.01)
  BOTTOM w0.089: CPU1.G1 135.89,91.57 136.84,92.53 137.52,92.53 137.79,92.8
  BOTTOM w0.14: v2(172.59,76.49) 172.81,76.71 173.32,76.71 173.47,76.56 v1(173.47,74.68) 173.47,73.06 174.72,71.81 174.72,71.42 174.99,71.15 175.59,71.15 175.71,71.03 175.71,68.41 175.52,68.21 175.52,67.48 173.44,65.41 173.44,59.46 173.48,59.42 173.48,55.87 v2(172.45,54.84) ; 137.79,92.8 137.89,92.89 137.89,93.36 139.32,94.8 EC1805.1 139.32,95.17 v2(138.91,95.57)
CL_RST#_R: length 5.2
  TOP w0.14: R6108.2 170.52,55.58 169.61,55.58 169.48,55.44 v2(169.48,54.67) 168.87,54.67 v1(168.65,54.89)
  BOTTOM w0.14: WLAN1.38 169.09,53.77 169.48,54.16 v2(169.48,54.67)
CLK_LAN_REQ4#_R: length 9.9
  TOP w0.127: Q3102.E v2(48.1,162.9) 48.54,162.9 48.82,162.62 49.96,162.62 R3104.2 49.98,162.62 R3103.2 ; LOM31.12 46.33,166.04 46.33,166.03 46.33,165.75 v2(46.34,165.75)
  BOTTOM w0.127: v2(48.1,162.9) 47.32,162.9 46.34,163.89 v1(46.34,164.93) v2(46.34,165.75)
CLK_LAN_REQ#_EN: length 4.2
  TOP w0.127: Q3102.B 45.31,164.87 44.77,164.33 v1(44.77,163.75) 44.77,162.89 44.45,162.57 R3102.2
CLK_PCI_LPC: length 52.5
  TOP w0.14: R1804.2 EC1802.1 133.01,63.05 132.86,62.9 v1(132.86,60.18) 132.86,59.13 131.6,57.86 131.6,54.32 135.5,50.42 140.86,50.42 141.07,50.21 141.07,47.96 142.29,46.74 144.17,46.74 146.5,44.4 158.72,44.4 v2(159.19,43.93)
  BOTTOM w0.14: v2(159.19,43.93) 159.67,43.45 159.67,42.02 158.99,41.33 158.99,40.27 160.59,38.67 DB1.9
CLK_PCI_LPC_MEC: length 77
  TOP w0.14: v2(178.59,81) 178.26,81 178.08,81.18 KBC24.57 ; R1805.2 136.37,63.95 EC1801.1 135.44,64.87 135.44,65.64 135.22,65.86 v2(135.22,65.97)
  L3 w0.127: v2(135.22,65.97) 135.22,65.31 136.11,64.42 137.89,64.42 138.07,64.24 141.02,64.24 141.13,64.13 144.08,64.13 144.15,64.2 146.79,64.2 147.27,63.72 148.6,63.72 149.13,64.25 153.53,64.25 154.25,63.53 156.48,63.53 156.97,64.01 163.19,64.01 163.97,64.79 167.39,64.79 167.69,65.09 168.14,65.09 168.83,64.4 170.75,64.4 171.33,63.82 173.1,63.82 174.25,64.98 177.22,64.98 180.13,62.06 v2(181.57,62.06)
  L4 w0.127: v2(181.57,62.06) 181.57,62.36 181.55,62.38 181.55,63.94 181.71,64.09 181.71,67.82 181.59,67.94 181.59,69.66 181.2,70.06 181.2,70.08 180.84,70.44 180.84,72.2 181.01,72.37 181.01,72.74 180.84,72.91 180.56,73.18 180.56,73.97 180.27,74.27 180.27,76.07 179.08,77.26 179.08,78.33 179.52,78.77 179.52,80.57 179.1,81 v2(178.59,81)
  BOTTOM w0.14: v2(178.59,81) 178.61,81.02 v1(178.61,81.72)
CLK_PCIE_VGA: length 109.9
  TOP w0.127: 165.06,121.65 165.06,126.42 168.38,129.74 168.38,135.47 172.35,139.44 173.69,139.44 174.22,138.92 182.06,138.92 183.06,137.92 183.65,137.92 184.05,137.52 v2(184.05,137.3) ; 165.06,121.65 165.06,120.11 164.01,119.05 164.01,117.96 158.62,112.57 157.39,112.57 154.43,109.62 153.69,109.62 153.31,109.23 v2(153.31,109.07) ; 165.06,121.65 v1(165.21,121.65)
  BOTTOM w0.089: 110.57,99.68 110.57,99.66 110.53,99.62 110.53,97.68 111.11,97.11 111.11,95.47 110.97,95.33 110.97,95.02 111.01,94.88 111.01,94.63 110.97,94.51 110.97,94.37 111.04,94.16 111.04,94.08 CPU1.C42
  BOTTOM w0.127: v2(153.31,109.07) 153.31,109.24 153.07,109.48 151.92,109.48 151.24,110.15 143.93,110.15 143.15,110.94 139.06,110.94 138.28,110.16 132.36,110.16 129.45,107.25 116.66,107.25 115.01,105.6 112.63,105.6 110.25,103.22 110.25,100.37 110.57,100.05 110.57,99.68 ; v2(184.05,137.3) 183.65,137.7 GPU1.AE8
CLK_PCIE_VGA#: length 110.2
  TOP w0.127: 164.82,125.87 164.82,126.52 168.14,129.84 168.14,135.57 172.25,139.68 173.79,139.68 174.32,139.16 182.16,139.16 183.16,138.16 v2(184.06,138.16) ; 164.82,125.87 164.82,120.21 163.76,119.15 163.76,118.06 158.52,112.81 157.29,112.81 154.33,109.86 v2(153.31,109.86) ; 164.82,125.87 v1(164.67,125.87)
  BOTTOM w0.089: 110.32,99.68 110.32,99.66 110.36,99.62 110.36,97.61 110.93,97.03 110.93,95.55 110.8,95.41 110.8,94.99 110.84,94.86 110.84,94.66 110.8,94.54 110.8,94.34 110.86,94.13 110.86,93.97 111.01,93.44 CPU1.D42
  BOTTOM w0.127: 110.32,99.68 110.32,99.95 110.01,100.27 110.01,103.32 112.53,105.84 114.91,105.84 116.56,107.49 129.35,107.49 132.26,110.4 138.18,110.4 138.96,111.18 143.25,111.18 144.03,110.4 151.34,110.4 152.02,109.72 153.17,109.72 v2(153.31,109.86) ; v2(184.06,138.16) 184.45,137.77 GPU1.AD8
CLK_TP_SIO: length 231.4
  TOP w0.14: v2(50.74,80.68) 50.76,80.65 RN6504.4 50.77,79.85 EC6503.1 52.31,79.73 RN6503.1 ; KBC24.78 175.41,75.41 175.74,75.08 175.74,74.88 v2(175.77,74.88)
  L3 w0.127: v2(58.89,49.6) 59.28,49.99 59.28,59.72 54.62,64.38 50.99,64.38 45.75,69.61 45.75,70.69 42.28,74.17 42.28,78.47 43.96,80.16 50.31,80.16 50.61,80.46 50.61,80.55 v2(50.74,80.68) ; v2(179.03,29.96) 179.02,29.97 177.92,29.97 177.54,29.59 175.81,29.59 174.82,30.58 172.1,30.58 170.82,31.86 155.12,31.86 153.27,30.01 144.35,30.01 v2(144.2,29.86)
  L4 w0.127: v2(179.03,29.96) 179.03,29.98 178.61,30.4 178.61,32.28 177.16,33.73 177.16,36.19 176.67,36.68 176.67,50.31 176.99,50.62 176.99,57.66 177.34,58.02 177.34,66.37 177.72,66.74 177.72,69.76 177.58,69.9 177.58,72.69 177.28,72.99 177.28,73.73 177.04,73.97 176.68,73.97 175.77,74.88 v2(175.77,74.88)
  BOTTOM w0.14: v2(144.2,29.86) 144.08,29.99 143.27,29.99 v1(141.41,31.84) 140.95,32.3 134.9,32.3 127.66,39.55 122.44,39.55 119.52,42.46 81.2,42.46 74.53,49.12 59.37,49.12 v2(58.89,49.6)
CLKREQ_PCIE#1: length 94.1
  TOP w0.102: v2(132.6,76.55) 133.53,76.55 v1(135.49,74.59) 135.86,74.22 136.47,74.22 138.12,72.57 138.12,71.1 141.18,68.04 141.23,68.04 142.92,66.34 144.06,66.34 144.53,65.87 R1829.2 ; R6112.2 162.95,49.57 v2(162.7,49.32)
  L3 w0.102: v2(162.7,49.32) 163.41,48.61 166.81,48.61 167.13,48.93 v2(171.28,48.93) ; v2(132.6,76.55) 133.81,76.55 134.43,77.17 141.65,77.17 141.72,77.24 145.71,77.24 147.24,75.71 149.43,75.71 150.33,74.8 150.61,74.8 151,74.4 153.99,74.4 154.26,74.13 154.46,74.13 154.67,74.33 159.5,74.33 159.63,74.2 159.98,74.2 169.31,74.2 169.42,74.09 v2(169.64,74.09)
  L4 w0.102: v2(169.64,74.09) 169.61,74.06 169.61,71.76 169.91,71.46 170.43,71.46 170.61,71.28 170.61,71.17 170.65,71.13 170.65,70.77 170.61,70.73 170.61,66.3 170.25,65.93 170.25,63.54 170.85,62.93 170.85,49.36 v2(171.28,48.93)
  BOTTOM w0.102: v2(132.6,76.55) 132.47,76.55 CPU1.AT7
CLKREQ_PCIE#2: length 283.5
  TOP w0.102: v2(131.68,76.55) 132.17,76.06 132.17,75.77 132.56,75.37 134.1,75.37 v1(134.34,75.13) 135.48,73.99 136.41,73.99 137.92,72.49 137.92,71.02 141.1,67.83 141.14,67.83 142.89,66.09 143.12,66.09 143.53,65.68 v2(143.53,65.46) 143.71,65.28 R1830.2 ; R3104.1 49.96,163.49 49.24,163.49 48.84,163.88 Q3102.C 47.76,163.55 46.19,163.55 v2(45.83,163.91)
  L3 w0.102: v2(161.56,163.14) 161.25,163.46 160.57,163.46 160.06,163.96 159.17,163.96 155.3,167.83 152.96,167.83 148.3,172.5 136.89,172.5 135.06,170.67 134.72,170.67 134.72,170.67 129.46,170.67 128.85,170.06 126.84,170.06 124.98,171.92 123.9,171.92 121.69,171.92 121.52,172.09 120.18,172.09 119.94,171.85 119.46,171.85 115.02,171.85 113.78,173.08 110.03,173.08 108.76,174.35 105.87,174.35 105.7,174.18 102.27,174.18 102.03,174.42 91.02,174.42 88.18,171.58 87.6,171.58 82.62,166.6 80.7,166.6 80.27,166.17 74.53,166.17 74.01,165.65 56.98,165.65 56.05,166.58 46.17,166.58 45.8,166.2 45.8,163.94 v2(45.83,163.91) ; v2(143.53,65.46) 145.42,65.46 145.79,65.83 146.4,65.83 146.87,66.3 154.24,66.3 154.79,65.75 158.17,65.75 158.48,65.44 161.11,65.44 161.85,66.18 161.85,67.52 162.62,68.29 165.13,68.29 165.17,68.25 166.73,68.25 v2(167.13,67.85)
  L4 w0.102: v2(167.13,67.85) 166.69,68.29 166.69,68.29 166.68,68.31 166.68,69.37 167.4,70.09 167.4,71.26 167.23,71.43 167.23,71.44 166.98,71.69 166.98,72.76 167.27,73.06 167.27,73.58 166.89,73.96 166.89,78.17 166.22,78.84 166.22,79.3 166.53,79.61 166.79,79.86 166.79,81.18 166.08,81.89 166.08,83.58 165.93,83.73 165.93,84.82 165.79,84.96 165.79,85.15 165.12,85.82 165.12,86.56 165.12,87.07 164.66,87.54 164.02,87.54 161.92,89.64 161.92,91.01 162.12,91.22 162.12,93.29 162.07,93.34 162.07,99.5 161.86,99.72 161.86,100.81 162.38,101.33 162.38,102.32 163.06,103.01 163.06,108.05 163.46,108.45 163.46,117.6 164.39,118.53 164.39,120.62 163.73,121.27 163.73,126.61 164.02,126.9 164.02,129.67 164.02,130.08 164.78,130.83 164.78,133.69 164.43,134.03 162.56,135.9 162.56,136.5 160.1,138.96 160.1,139.93 160.1,139.94 160.1,147.77 161.18,148.85 161.18,151.38 160.82,151.74 160.82,153.58 161.91,154.67 161.91,160.27 161.56,160.62 v2(161.56,163.14)
  BOTTOM w0.102: CPU1.AT8 131.36,76.22 v2(131.68,76.55)
