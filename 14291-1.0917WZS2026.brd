# Allegro board 14291-1.0917WZS2026.brd (continued)
## Nets (continued)
HDA_SDOUT: CPU1.BB22 R1909.2 R1912.2
HDA_SPKR_R: D2701.2 RN2701.3(B)
HDA_SYNC: CPU1.BA22 R1908.2
HDD_DET#: CPU1.U8 EC6001.1 HDD1.10 R2044.2
HDD_DEVSLP: CPU1.J1 R6007.1
HDD_DEVSLP_R: HDD1.20 R6007.2
HDD_FALL_INT: CPU1.M3 R6702.2 U6701.12
HDD_PWR_EN: CPU1.J4 R6004.2
HDD_PWR_EN_R: Q6001.2 R6004.1 R6005.1
HDMI_CLK: C5403.1 CPU1.G56
HDMI_CLK#: C5402.1 CPU1.F56
HDMI_CLK#_R: C5402.2 R5401.1 RN5403.7(B)
HDMI_CLK#_R_C: EU5702.2 EU5702.9 HDMI1.12 R5401.2 R5414.1
HDMI_CLK_R: C5403.2 R5402.1 RN5403.8(B)
HDMI_CLK_R_C: EU5702.1 EU5702.10 HDMI1.10 R5402.2 R5414.2
HDMI_DATA0: C5405.1 CPU1.G53
HDMI_DATA0#: C5404.1 CPU1.F53
HDMI_DATA0#_R: C5404.2 R5403.1 RN5403.5(B)
HDMI_DATA0#_R_C: EU5702.5 EU5702.6 HDMI1.9 R5403.2 R5417.1
HDMI_DATA0_R: C5405.2 R5404.1 RN5403.6(B)
HDMI_DATA0_R_C: EU5702.4 EU5702.7 HDMI1.7 R5404.2 R5417.2
HDMI_DATA1: C5407.1 CPU1.F58
HDMI_DATA1#: C5406.1 CPU1.E58
HDMI_DATA1#_R: C5406.2 R5407.1 RN5402.5(B)
HDMI_DATA1#_R_C: EU5701.5 EU5701.6 HDMI1.6 R5407.2 R5416.1
HDMI_DATA1_R: C5407.2 R5408.1 RN5402.6(B)
HDMI_DATA1_R_C: EU5701.4 EU5701.7 HDMI1.4 R5408.2 R5416.2
HDMI_DATA2: C5409.1 CPU1.F55
HDMI_DATA2#: C5408.1 CPU1.E55
HDMI_DATA2#_R: C5408.2 R5405.1 RN5402.7(B)
HDMI_DATA2#_R_C: EU5701.2 EU5701.9 HDMI1.3 R5405.2 R5415.1
HDMI_DATA2_R: C5409.2 R5406.1 RN5402.8(B)
HDMI_DATA2_R_C: EU5701.1 EU5701.10 HDMI1.1 R5406.2 R5415.2
HDMI_HPD_B: Q5401.B R5411.2
HDMI_HPD_E: Q5401.E R5412.1 R5419.2
HDMI_PLL_GND: Q5403.D R5418.2 RN5402.1(A) RN5402.2(A) RN5402.3(A) RN5402.4(A) RN5403.1(A) RN5403.2(A) RN5403.3(A) RN5403.4(A)
HOST_DEBUG_TX: KBC24.81 R2466.2 R2478.1 R6115.1
HPD_HDMI_CON: EU5703.2 EU5703.9 HDMI1.19 R5410.1 R5411.1
I2C0_SCL: CPU1.N3 RN2007.1(A)
I2C0_SCL_TCH_PAD: CPU1.U6 EC6504.1 Q6503.1 R6518.1
I2C0_SDA: CPU1.M4 RN2007.2(A)
I2C0_SDA_TCH_PAD: CPU1.U7 EC6502.1 Q6503.4 R6519.1
I2C1_SCL: CPU1.N2 RN2008.1(A)
I2C1_SCL_R: AFTP6237.1 Q6503.6 R6515.2 R6518.2 RN6502.4(B) TPAD1.6
I2C1_SDA: CPU1.N1 RN2008.2(A)
I2C1_SDA_R: AFTP6240.1 Q6503.3 R6511.2 R6519.2 RN6502.3(B) TPAD1.7
I2CA_SCL: GPU1.B7 RN7603.3(B)
I2CA_SDA: GPU1.A7 RN7603.4(B)
I2CB_SCL: GPU1.C9 RN7605.3(B)
I2CB_SDA: GPU1.C8 RN7605.4(B)
I2CC_SCL: GPU1.A9 RN7604.4(B)
I2CC_SDA: GPU1.B9 RN7604.3(B)
I_ADP: C2435.1 KBC24.110 R2421.2
I_BATT: C2441.1 KBC24.114 R2423.2
I_SYS: C2427.1 KBC24.113 R2422.2
ICSP_CLK_R: DB3.2 R2463.1
ICSP_CLOCK: KBC24.101 R2463.2
ICSP_CLR: KBC24.87 R2414.1 R2465.2
ICSP_CLR_R: DB3.6 R2465.1
ICSP_DATA: KBC24.102 R2464.2
ICSP_DATA_R: DB3.3 R2464.1
IFPAB_IOVDD: GPU1.W6 GPU1.Y6 RN7402.3(B)
IFPAB_PLLVDD: GPU1.V7 GPU1.W7 RN7402.4(B)
IFPC_IOVDD: GPU1.R6 RN7401.3(B)
IFPC_PLLVDD: GPU1.R7 GPU1.T7 RN7401.4(B)
IFPD_IOVDD: GPU1.P6 RN7404.3(B)
IFPD_PLLVDD: GPU1.M7 GPU1.N7 RN7404.4(B)
IFPEF_IOVDD: GPU1.H6 GPU1.J6 RN7403.4(B)
IFPEF_PLLVDD: GPU1.J7 GPU1.K7 RN7403.3(B)
INT_TP#: AFTP6241.1 R2045.1 R2431.1 R6514.1 TPAD1.4
IR_CAMERA_DET#: CPU1.AY7 EC5504.1 R2051.2 R5540.2
IR_CAMERA_DET#_R: IRCCD1.4 R5540.1
ISOLATE#: LOM31.20 R3106.2 R3107.1
ITP_PMODE: CPU1.E8 TP9922.1
JACK_PLUG: ED305.1 HPMIC1.5 R2923.1
JACK_PLUG_DET: ED301.1 HPMIC1.6 R307.1
JDREF: HDA27.15 R2707.1
KB_BL_CTRL#: AFTP6247.1 KBLIT1.4 Q6501.D
KB_DET#: AFTP6202.1 CPU1.BB7 KB1.30 R2009.1
KB_LED_BL_DET: CPU1.W8 R6503.1 R6507.1
KB_LED_DET_C: AFTP6246.1 C6502.1 KBLIT1.2 R6503.2
KBC_BEEP_R: D2701.1 RN2701.4(B)
KBC_PWRBTN#: R2432.1 R6403.1
KBC_PWRBTN#_C: AFTP6101.1 EC6401.1 ED6401.1 G6401.2 G6402.2 PWR1.2 PWSW2.3 PWSW2.4 R6403.2
KSI0: AFTP6228.1 KB1.22 KBC24.98 RN2412.8(B)
KSI1: AFTP6227.1 KB1.24 KBC24.99 RN2412.6(B)
KSI2: AFTP6218.1 KB1.26 KBC24.6 RN2411.8(B)
KSI3: AFTP6234.1 KB1.23 KBC24.7 RN2412.7(B)
KSI4: AFTP6230.1 KB1.27 KBC24.104 RN2411.7(B)
KSI5: AFTP6214.1 KB1.25 KBC24.105 RN2412.5(B)
KSI6: AFTP6222.1 KB1.28 KBC24.107 RN2411.6(B)
KSI7: AFTP6221.1 KB1.29 KBC24.108 RN2411.5(B)
KSO0: AFTP6207.1 KB1.13 KBC24.2 RN2404.5(B)
KSO1: AFTP6206.1 KB1.15 KBC24.14 RN2409.7(B)
KSO2: AFTP6226.1 KB1.14 KBC24.15 RN2409.8(B)
KSO3: AFTP6208.1 KB1.16 KBC24.16 RN2409.6(B)
KSO4: AFTP6224.1 KB1.20 KBC24.37 RN2410.6(B)
KSO5: AFTP6215.1 KB1.21 KBC24.38 RN2410.5(B)
KSO6: AFTP6223.1 KB1.18 KBC24.39 RN2410.8(B)
KSO7: AFTP6213.1 KB1.19 KBC24.50 RN2410.7(B)
KSO8: AFTP6231.1 KB1.17 KBC24.46 RN2409.5(B)
KSO9: AFTP6219.1 KB1.7 KBC24.68 R2449.2 R2450.1
KSO10: AFTP6232.1 KB1.5 KBC24.72 RN2403.8(B)
KSO11: AFTP6220.1 KB1.6 KBC24.74 RN2403.7(B)
KSO12: AFTP6233.1 KB1.12 KBC24.75 RN2404.6(B)
KSO13: AFTP6203.1 KB1.9 KBC24.76 RN2403.5(B)
KSO14: AFTP6216.1 KB1.8 KBC24.77 RN2403.6(B)
KSO15: AFTP6229.1 KB1.10 KBC24.86 RN2404.8(B)
KSO16: AFTP6225.1 KB1.11 KBC24.92 RN2404.7(B)
L_BKLT_CTRL: CPU1.R11 R5530.1
L_BKLT_EN: CPU1.R12 R2435.1
L_BKLT_EN_EC: KBC24.91 R2435.2 R2436.1
LAN_EN: KBC24.3 R2491.1
LAN_ENABLE_R_C: Q3101.D R3109.2 R3110.1
LAN_MDI0N: EC3102.2 LOM31.2 U3201.2 U3201.9 XF3103.11
LAN_MDI0P: EC3101.2 LOM31.1 U3201.1 U3201.10 XF3103.12
LAN_MDI1N: EC3104.2 LOM31.5 U3201.5 U3201.6 XF3103.8
LAN_MDI1P: EC3103.2 LOM31.4 U3201.4 U3201.7 XF3103.9
LAN_MDI2N: EC3106.2 LOM31.7 U3202.2 U3202.9 XF3103.5
LAN_MDI2P: EC3105.2 LOM31.6 U3202.1 U3202.10 XF3103.6
LAN_MDI3N: EC3108.2 LOM31.10 U3202.5 U3202.6 XF3103.2
LAN_MDI3P: EC3107.2 LOM31.9 U3202.4 U3202.7 XF3103.3
LANXIN: C3101.1 LOM31.28 X3101.1
LANXOUT: C3107.1 LOM31.29 X3101.3
LCD_BRIGHTNESS: LCD1.20 RN5503.2(A)
LCD_CBL_DET#: CPU1.W4 R2047.2 R5539.2
LCD_CBL_DET#_R: LCD1.23 R5539.1
LCD_TST: D5503.2 KBC24.26 R2419.1 RN5503.8(B)
LCD_TST_C: LCD1.10 RN5503.1(A)
LCD_TST_EN: D5502.2 R2419.2
LCDVDD: R5523.2 U5501.3
LCDVDD_EN: D5502.3 R5506.2 U5501.1
LCDVDD_LCD: C5536.2 C5538.1 LCD1.4 LCD1.5 LCD1.6 LCD1.7 R5523.1
LDO1_CAP: C2702.2 HDA27.27 R2711.2
LDO2_CAP: C2712.2 HDA27.39
LDO3_CAP: C2718.1 HDA27.7
LED0: LOM31.27 TP3103.1
LED1: LOM31.26 R3114.1
LED2: LOM31.25 TP3101.1
LED_SATA_DIAG_OUT#: KBC24.30 Q6408.4 R6402.2
LID_CL_SIO#: D2402.K KBC24.41 R2433.1 R6408.1
LID_CLOSE#_C: AFTP6104.1 EC6405.1 PWR1.3 R6408.2
LINE1-L_C: C2907.2 R2922.1
LINE1-L_R: C2908.2 R2921.1
LINE1_L: C2907.1 HDA27.22
LINE1_R: C2908.1 HDA27.21
LINE1_VREFO_L: HDA27.31 R2912.1
LINE1_VREFO_R: HDA27.30 R2913.1
LOM_CABLE_DETECT#: CPU1.J3 R1609.2 R3114.2
LOM_TCT: C3119.1 XF3103.1 XF3103.4 XF3103.7 XF3103.10
LPC_FRAME#_DEBUG: DB1.6 R6801.2
LPC_LAD0: KBC24.59 RN1806.8(B) RN6801.4(A)
LPC_LAD0_C: DB1.2 RN6801.5(B)
LPC_LAD0_R: CPU1.AY13 RN1806.1(A)
LPC_LAD1: KBC24.60 RN1806.6(B) RN6801.3(A)
LPC_LAD1_C: DB1.3 RN6801.6(B)
LPC_LAD1_R: CPU1.BA13 RN1806.3(A)
LPC_LAD2: KBC24.61 RN1806.7(B) RN6801.2(A)
LPC_LAD2_C: DB1.4 RN6801.7(B)
LPC_LAD2_R: CPU1.BB13 RN1806.2(A)
LPC_LAD3: KBC24.62 RN1806.5(B) RN6801.1(A)
LPC_LAD3_C: DB1.5 RN6801.8(B)
LPC_LAD3_R: CPU1.AY12 RN1806.4(A)
LPC_LFRAME#: KBC24.58 R1801.1 R6801.1
LPC_LFRAME#_R: CPU1.BA12 R1801.2
LPSS_UART2_CTS#: CPU1.AD4 R2046.1 TP2009.1
LPSS_UART2_RXD: CPU1.AD1 DB2.3 R2048.1
LPSS_UART2_TXD: CPU1.AD2 DB2.2 R2049.1
M_A_A0: CPU1.AY50 DM1.98
M_A_A1: CPU1.BB50 DM1.97
M_A_A2: CPU1.AY51 DM1.96
M_A_A3: CPU1.BA50 DM1.95
M_A_A4: CPU1.BB52 DM1.92
M_A_A5: CPU1.BA51 DM1.91
M_A_A6: CPU1.BA52 DM1.90
M_A_A7: CPU1.AW52 DM1.86
M_A_A8: CPU1.AY52 DM1.89
M_A_A9: CPU1.BB54 DM1.85
M_A_A10: CPU1.AT50 DM1.107
M_A_A11: CPU1.BA54 DM1.84
M_A_A12: CPU1.AW54 DM1.83
M_A_A13: CPU1.AU46 DM1.119
M_A_A14: CPU1.AY54 DM1.80
M_A_A15: CPU1.BA55 DM1.78
M_A_BS0: CPU1.AU52 DM1.109
M_A_BS1: CPU1.AT48 DM1.108
M_A_BS2: CPU1.AY55 DM1.79
M_A_CAS#: CPU1.AU48 DM1.115
M_A_CKE0: CPU1.BA56 DM1.73
M_A_CKE1: CPU1.BB56 DM1.74
M_A_CLK0: CPU1.AT53 DM1.101
M_A_CLK1: CPU1.AT55 DM1.102
M_A_CLK#0: CPU1.AU53 DM1.103
M_A_CLK#1: CPU1.AU55 DM1.104
M_A_CS#0: CPU1.AU45 DM1.114
M_A_CS#1: CPU1.AU43 DM1.121
M_A_DIMA_ODT0: CPU1.AT45 DM1.116
M_A_DIMA_ODT1: CPU1.AT43 DM1.120
M_A_DQ0: CPU1.AL71 DM1.16
M_A_DQ1: CPU1.AL68 DM1.7
M_A_DQ2: CPU1.AN68 DM1.4
M_A_DQ3: CPU1.AN69 DM1.5
M_A_DQ4: CPU1.AL70 DM1.15
M_A_DQ5: CPU1.AL69 DM1.18
M_A_DQ6: CPU1.AN70 DM1.6
M_A_DQ7: CPU1.AN71 DM1.17
M_A_DQ8: CPU1.AR70 DM1.22
M_A_DQ9: CPU1.AR68 DM1.21
M_A_DQ10: CPU1.AU71 DM1.35
M_A_DQ11: CPU1.AU68 DM1.36
M_A_DQ12: CPU1.AR71 DM1.24
M_A_DQ13: CPU1.AR69 DM1.23
M_A_DQ14: CPU1.AU70 DM1.33
M_A_DQ15: CPU1.AU69 DM1.34
M_A_DQ16: CPU1.BB65 DM1.41
M_A_DQ17: CPU1.AW65 DM1.42
M_A_DQ18: CPU1.AW63 DM1.52
M_A_DQ19: CPU1.AY63 DM1.53
M_A_DQ20: CPU1.BA65 DM1.39
M_A_DQ21: CPU1.AY65 DM1.40
M_A_DQ22: CPU1.BA63 DM1.50
M_A_DQ23: CPU1.BB63 DM1.51
M_A_DQ24: CPU1.BA61 DM1.56
M_A_DQ25: CPU1.AW61 DM1.57
M_A_DQ26: CPU1.BB59 DM1.67
M_A_DQ27: CPU1.AW59 DM1.70
M_A_DQ28: CPU1.BB61 DM1.59
M_A_DQ29: CPU1.AY61 DM1.58
M_A_DQ30: CPU1.BA59 DM1.69
M_A_DQ31: CPU1.AY59 DM1.68
M_A_DQ32: CPU1.AY39 DM1.129
M_A_DQ33: CPU1.AW39 DM1.131
M_A_DQ34: CPU1.AY37 DM1.141
M_A_DQ35: CPU1.AW37 DM1.143
M_A_DQ36: CPU1.BB39 DM1.130
M_A_DQ37: CPU1.BA39 DM1.132
M_A_DQ38: CPU1.BA37 DM1.140
M_A_DQ39: CPU1.BB37 DM1.142
M_A_DQ40: CPU1.AY35 DM1.147
M_A_DQ41: CPU1.AW35 DM1.149
M_A_DQ42: CPU1.AY33 DM1.160
M_A_DQ43: CPU1.AW33 DM1.158
M_A_DQ44: CPU1.BB35 DM1.146
M_A_DQ45: CPU1.BA35 DM1.148
M_A_DQ46: CPU1.BA33 DM1.157
M_A_DQ47: CPU1.BB33 DM1.159
M_A_DQ48: CPU1.AY31 DM1.166
M_A_DQ49: CPU1.AW31 DM1.165
M_A_DQ50: CPU1.AY29 DM1.176
M_A_DQ51: CPU1.AW29 DM1.174
M_A_DQ52: CPU1.BB31 DM1.164
M_A_DQ53: CPU1.BA31 DM1.163
M_A_DQ54: CPU1.BA29 DM1.177
M_A_DQ55: CPU1.BB29 DM1.175
M_A_DQ56: CPU1.AY27 DM1.183
M_A_DQ57: CPU1.AW27 DM1.182
M_A_DQ58: CPU1.AY25 DM1.192
M_A_DQ59: CPU1.AW25 DM1.194
M_A_DQ60: CPU1.BB27 DM1.180
M_A_DQ61: CPU1.BA27 DM1.181
M_A_DQ62: CPU1.BA25 DM1.191
M_A_DQ63: CPU1.BB25 DM1.193
M_A_DQS_DN0: CPU1.AM70 DM1.10
M_A_DQS_DN1: CPU1.AT69 DM1.27
M_A_DQS_DN2: CPU1.BA64 DM1.45
M_A_DQS_DN3: CPU1.AY60 DM1.62
M_A_DQS_DN4: CPU1.BA38 DM1.135
M_A_DQS_DN5: CPU1.AY34 DM1.152
M_A_DQS_DN6: CPU1.BA30 DM1.169
M_A_DQS_DN7: CPU1.AY26 DM1.186
M_A_DQS_DP0: CPU1.AM69 DM1.12
M_A_DQS_DP1: CPU1.AT70 DM1.29
M_A_DQS_DP2: CPU1.AY64 DM1.47
M_A_DQS_DP3: CPU1.BA60 DM1.64
M_A_DQS_DP4: CPU1.AY38 DM1.137
M_A_DQS_DP5: CPU1.BA34 DM1.154
M_A_DQS_DP6: CPU1.AY30 DM1.171
M_A_DQS_DP7: CPU1.BA26 DM1.188
M_A_RAS#: CPU1.AU50 DM1.110
M_A_WE#: CPU1.AT46 DM1.113
M_B_A0: CPU1.BA46 DM2.98
M_B_A1: CPU1.AY46 DM2.97
M_B_A2: CPU1.AY47 DM2.96
M_B_A3: CPU1.BB46 DM2.95
M_B_A4: CPU1.BA47 DM2.92
M_B_A5: CPU1.AY48 DM2.91
M_B_A6: CPU1.BA48 DM2.90
M_B_A7: CPU1.AP48 DM2.86
M_B_A8: CPU1.BB48 DM2.89
M_B_A9: CPU1.AP50 DM2.85
M_B_A10: CPU1.AW46 DM2.107
M_B_A11: CPU1.AN48 DM2.84
M_B_A12: CPU1.AN50 DM2.83
M_B_A13: CPU1.BA43 DM2.119
M_B_A14: CPU1.AN52 DM2.80
M_B_A15: CPU1.AN53 DM2.78
M_B_BS0: CPU1.BB44 DM2.109
M_B_BS1: CPU1.BA44 DM2.108
M_B_BS2: CPU1.AP52 DM2.79
M_B_CAS#: CPU1.AY43 DM2.115
M_B_CKE0: CPU1.AN56 DM2.73
M_B_CKE1: CPU1.AP55 DM2.74
M_B_CLK0: CPU1.AP45 DM2.101
M_B_CLK1: CPU1.AP46 DM2.102
M_B_CLK#0: CPU1.AN45 DM2.103
M_B_CLK#1: CPU1.AN46 DM2.104
M_B_CS#0: CPU1.BB42 DM2.114
M_B_CS#1: CPU1.AY42 DM2.121
M_B_DIMB_ODT0: CPU1.BA42 DM2.116
M_B_DIMB_ODT1: CPU1.AW42 DM2.120
M_B_DQ0: CPU1.AF65 DM2.23
M_B_DQ1: CPU1.AF64 DM2.22
M_B_DQ2: CPU1.AK65 DM2.33
M_B_DQ3: CPU1.AK64 DM2.35
M_B_DQ4: CPU1.AF66 DM2.21
M_B_DQ5: CPU1.AF67 DM2.24
M_B_DQ6: CPU1.AK67 DM2.34
M_B_DQ7: CPU1.AK66 DM2.36
M_B_DQ8: CPU1.AF70 DM2.18
M_B_DQ9: CPU1.AF68 DM2.4
M_B_DQ10: CPU1.AH71 DM2.5
M_B_DQ11: CPU1.AH68 DM2.7
M_B_DQ12: CPU1.AF71 DM2.16
M_B_DQ13: CPU1.AF69 DM2.15
M_B_DQ14: CPU1.AH70 DM2.6
M_B_DQ15: CPU1.AH69 DM2.17
M_B_DQ16: CPU1.AT66 DM2.39
M_B_DQ17: CPU1.AU66 DM2.41
M_B_DQ18: CPU1.AP65 DM2.51
M_B_DQ19: CPU1.AN65 DM2.53
M_B_DQ20: CPU1.AN66 DM2.40
M_B_DQ21: CPU1.AP66 DM2.42
M_B_DQ22: CPU1.AT65 DM2.50
M_B_DQ23: CPU1.AU65 DM2.52
M_B_DQ24: CPU1.AT61 DM2.56
M_B_DQ25: CPU1.AU61 DM2.59
M_B_DQ26: CPU1.AP60 DM2.68
M_B_DQ27: CPU1.AN60 DM2.69
M_B_DQ28: CPU1.AN61 DM2.58
M_B_DQ29: CPU1.AP61 DM2.67
M_B_DQ30: CPU1.AT60 DM2.70
M_B_DQ31: CPU1.AU60 DM2.57
M_B_DQ32: CPU1.AU40 DM2.132
M_B_DQ33: CPU1.AT40 DM2.129
M_B_DQ34: CPU1.AT37 DM2.141
M_B_DQ35: CPU1.AU37 DM2.140
M_B_DQ36: CPU1.AR40 DM2.131
M_B_DQ37: CPU1.AP40 DM2.130
M_B_DQ38: CPU1.AP37 DM2.142
M_B_DQ39: CPU1.AR37 DM2.143
M_B_DQ40: CPU1.AT33 DM2.146
M_B_DQ41: CPU1.AU33 DM2.149
M_B_DQ42: CPU1.AU30 DM2.157
M_B_DQ43: CPU1.AT30 DM2.159
M_B_DQ44: CPU1.AR33 DM2.148
M_B_DQ45: CPU1.AP33 DM2.147
M_B_DQ46: CPU1.AR30 DM2.158
M_B_DQ47: CPU1.AP30 DM2.160
M_B_DQ48: CPU1.AU27 DM2.177
M_B_DQ49: CPU1.AT27 DM2.165
M_B_DQ50: CPU1.AT25 DM2.176
M_B_DQ51: CPU1.AU25 DM2.163
M_B_DQ52: CPU1.AP27 DM2.164
M_B_DQ53: CPU1.AN27 DM2.166
M_B_DQ54: CPU1.AN25 DM2.174
M_B_DQ55: CPU1.AP25 DM2.175
M_B_DQ56: CPU1.AT22 DM2.183
M_B_DQ57: CPU1.AU22 DM2.180
M_B_DQ58: CPU1.AU21 DM2.181
M_B_DQ59: CPU1.AT21 DM2.193
M_B_DQ60: CPU1.AN22 DM2.191
M_B_DQ61: CPU1.AP22 DM2.182
M_B_DQ62: CPU1.AP21 DM2.192
M_B_DQ63: CPU1.AN21 DM2.194
M_B_DQS_DN0: CPU1.AH66 DM2.27
M_B_DQS_DN1: CPU1.AG69 DM2.10
M_B_DQS_DN2: CPU1.AR66 DM2.45
M_B_DQS_DN3: CPU1.AR61 DM2.62
M_B_DQS_DN4: CPU1.AT38 DM2.135
M_B_DQS_DN5: CPU1.AT32 DM2.152
M_B_DQS_DN6: CPU1.AR25 DM2.169
M_B_DQS_DN7: CPU1.AR22 DM2.186
M_B_DQS_DP0: CPU1.AH65 DM2.29
M_B_DQS_DP1: CPU1.AG70 DM2.12
M_B_DQS_DP2: CPU1.AR65 DM2.47
M_B_DQS_DP3: CPU1.AR60 DM2.64
M_B_DQS_DP4: CPU1.AR38 DM2.137
M_B_DQS_DP5: CPU1.AR32 DM2.154
M_B_DQS_DP6: CPU1.AR27 DM2.171
M_B_DQS_DP7: CPU1.AR21 DM2.188
M_B_RAS#: CPU1.AW44 DM2.110
M_B_WE#: CPU1.AY44 DM2.113
M_VREF_CA_DIMMA: C1201.1 C1202.1 C1218.1 DM1.126 R4203.1 R4204.2 R4205.1 R4206.2 R4208.1
M_VREF_CA_DIMMB: C1306.1 C1308.1 C1309.1 DM2.126 R4205.2
M_VREF_DQ_DIM0: C4202.1 CPU1.AY68 R4202.1
M_VREF_DQ_DIM1: C4203.1 CPU1.BA67 R4213.1
M_VREF_DQ_DIMMA: C1204.1 C1205.1 C1206.1 DM1.1 R4201.2 R4202.2 R4209.1 R4210.2
M_VREF_DQ_DIMMB: C1302.1 C1305.1 C1310.1 DM2.1 R4212.2 R4213.2 R4214.1 R4216.2
MASK_BASE_LEDS#: KBC24.23 Q6402.G Q6406.2 Q6406.5 Q6407.G R2438.1
MCT: C3201.1 RN3201.5(B) RN3201.6(B) RN3201.7(B) RN3201.8(B)
MCT0: RN3201.1(A) XF3103.24
MCT1: RN3201.2(A) XF3103.21
MCT2: RN3201.3(A) XF3103.18
MCT3: RN3201.4(A) XF3103.15
MDO0+: AFTP3107.1 RJ45.1 XF3103.13
MDO0-: AFTP3102.1 RJ45.2 XF3103.14
MDO1+: AFTP3101.1 RJ45.3 XF3103.16
MDO1-: AFTP3106.1 RJ45.6 XF3103.17
MDO2+: AFTP3103.1 RJ45.4 XF3103.19
MDO2-: AFTP3104.1 RJ45.5 XF3103.20
MDO3+: AFTP3105.1 RJ45.7 XF3103.22
MDO3-: AFTP3108.1 RJ45.8 XF3103.23
ME_FWP_EC: KBC24.80 MESW1.C MESW1.C1 R1909.1
ME_SUS_PWR_ACK: KBC24.42 R2401.1 RN1702.1(A)
ME_SUS_PWR_ACK_R: CPU1.AR13 R1708.1 R2039.2 RN1702.4(B)
MEM_SMBCLK: CPU1.R7 Q1801.3 RN1811.3(B)
MEM_SMBDATA: CPU1.R8 Q1801.6 RN1811.4(B)
MESW1_B: MESW1.B R9804.1
MIC2_VREFO: HDA27.29 RN2901.1(A) RN2901.2(A)
MIC_CAP: C2713.1 HDA27.19
MIC_GND: LCD1.26 R5531.1
MODEL_ID: KBC24.109 R2497.1 U2401.4
MODEL_ID_C: C2407.2 R2441.1 R2442.2 R2497.2 U2401.3
MSM#: CPU1.AP56 TP617.1
N12P_JTAG_TCK: GPU1.AE5 RN7602.3(B)
N12P_JTAG_TDI: GPU1.AE6 TP7605.1
N12P_JTAG_TDO: GPU1.AF6 TP7601.1
N12P_JTAG_TMS: GPU1.AD6 TP7602.1
N12P_JTAG_TRST: GPU1.AG4 RN7602.4(B)
N12P_XTAL_OUTBUFF: GPU1.C10 R7602.1 R7617.2
NCT7718_ALERT#: R2603.2 THM26.6
NCT7718_DXN: C2606.2 C2607.2 Q2603.E THM26.3
NCT7718_DXP: C2606.1 C2607.1 Q2603.B Q2603.C THM26.2
NCTF_A5: CPU1.A5 TP2307.1
NCTF_A70: CPU1.A70 TP2301.1
NCTF_B71: CPU1.B71 TP2302.1
NCTF_BA1: CPU1.BA1 TP2305.1
NCTF_BA2: CPU1.BA2 TP2306.1
NCTF_BA71: CPU1.BA71 TP2303.1
NCTF_BB70: CPU1.BB70 TP2304.1
NCTF_C1: CPU1.C1 TP2308.1
OVER_CURRENT_P8#: D7602.K KBC24.21
OVERT#: C7609.1 Q7602.4 R7613.2 R7645.2 R7656.1
OVERT_GPU#: GPU1.A6 R7656.2
P2800_VGA_DXN: GPU1.E12 TP7603.1
P2800_VGA_DXP: GPU1.F12 TP7604.1
P_H_S#: Q7602.3 R7653.1
P_SYS: PG4415.2 PR4425.1 PR4671.1 R2422.1
PANEL_BKEN_EC: KBC24.117 RN5503.6(B)
PANEL_SIZE_ID: CPU1.AP13 R5521.2 R5525.2 R5526.1
PANEL_SIZE_ID_CONN: LCD1.22 R5525.1
PBAT_PRES1#: AFTP3902.1 BATT1.5 RN4302.8(B)
PBAT_PRES#: D4304.3 EC4306.2 KBC24.97 PC4310.2 PG4416.1 PQ4303.2 PR4315.2 PR4316.1 R2415.1 RN4302.1(A)
PBAT_SMBCLK1: AFTP3904.1 BATT1.3 RN4302.6(B)
PBAT_SMBDAT1: AFTP3903.1 BATT1.4 RN4302.7(B)
PCH_ALW_ON: KBC24.71 R2496.1 R4102.1
PCH_BATLOW#: CPU1.AU13 R1723.2
PCH_DPC_AUXN: CPU1.E48 VGABD1.11
PCH_DPC_AUXP: CPU1.F48 VGABD1.12
PCH_DPC_N0: CPU1.C50 VGABD1.5
PCH_DPC_N1: CPU1.C52 VGABD1.8
PCH_DPC_P0: CPU1.D50 VGABD1.6
PCH_DPC_P1: CPU1.D52 VGABD1.9
PCH_DPWROK: CPU1.BB20 R1704.2 R1718.1
PCH_JTAG_TCK: CPU1.B56 R407.1 TP9917.1
PCH_JTAG_TDI: CPU1.D59 R408.1 R9928.1
PCH_JTAG_TDO: CPU1.A56 R409.1 R9935.2 TP9916.1
PCH_JTAG_TMS: CPU1.C59 R416.1 R9927.1
PCH_PLTRST#: CPU1.AN10 R1713.2
PCH_PLTRST#_EC: C2402.2 KBC24.56 R2410.1
PCH_POPIRCOMP: CPU1.AU16 R413.1
PCH_RSMRST#: EC1712.1 KBC24.88 R1702.2
PCH_SMBCLK: DM1.202 DM2.202 EC6505.1 Q1801.4 R6515.1 R9920.1 RN1810.3(B) U6701.1 VGABD1.15
PCH_SMBDATA: DM1.200 DM2.200 EC6506.1 Q1801.1 R6511.1 R9918.1 RN1810.4(B) U6701.4 VGABD1.14
PCH_SPI_CS2#: CPU1.AU1 R1816.2
PCH_THERMTRIP: CPU1.C63 R419.2 R420.1
PCH_WAKE#: CPU1.BB15 R1703.2 R1705.2
PCI_CLK_LPC0: CPU1.AW9 R1804.1
PCI_CLK_LPC1: CPU1.AY9 R1805.1
PCIE_CLK_XDP_N: CPU1.F43 TP9909.1
PCIE_CLK_XDP_P: CPU1.E43 TP9908.1
PCIE_LAN_WAKE#: D1702.2 LOM31.21 R3113.1
PCIE_RCOMPN: CPU1.F5 R1604.1
PCIE_RCOMPP: CPU1.E5 R1604.2
PCIE_RX_CON_N6: C3111.1 LOM31.17
PCIE_RX_CON_P6: C3109.1 LOM31.18
PCIE_RX_CPU_N5: CPU1.F16 WLAN1.43
PCIE_RX_CPU_N6: C3111.2 CPU1.G18
PCIE_RX_CPU_P5: CPU1.E16 WLAN1.41
PCIE_RX_CPU_P6: C3109.2 CPU1.F18
PCIE_TX_CON_N5: C1601.1 WLAN1.37
PCIE_TX_CON_N6: C1603.1 LOM31.14
PCIE_TX_CON_P5: C1602.1 WLAN1.35
PCIE_TX_CON_P6: C1604.1 LOM31.13
PCIE_TX_CPU_N5: C1601.2 CPU1.C19
PCIE_TX_CPU_N6: C1603.2 CPU1.D20
PCIE_TX_CPU_P5: C1602.2 CPU1.D19
PCIE_TX_CPU_P6: C1604.2 CPU1.C20
PCIE_WAKE#: D1702.3 R1705.1
PCIE_WLAN_WAKE#: D1702.1 R1714.2 R6121.1 WLAN1.55
PCIE_WLAN_WAKE#_R: R6121.2 WLAN1.70
PD4403_A: PD4404.A PQ4408.B
PD4403_K: PD4404.K PR4458.2
PD#: HDA27.47 R2708.2
PECI_EC: C2405.1 KBC24.94 R2437.1
PEG_CLK1_CPU: CPU1.A42 EC6103.1 WLAN1.47
PEG_CLK1_CPU#: CPU1.B42 EC6102.1 WLAN1.49
PEG_CLK2_CPU: CPU1.C41 LOM31.15
PEG_CLK2_CPU#: CPU1.D41 LOM31.16
PEG_TX_CPU_N0: C1606.2 CPU1.B17
PEG_TX_CPU_N1: C1608.2 CPU1.D16
PEG_TX_CPU_N2: C1610.2 CPU1.D17
PEG_TX_CPU_N3: C1612.2 CPU1.B19
PEG_TX_CPU_P0: C1605.2 CPU1.A17
PEG_TX_CPU_P1: C1607.2 CPU1.C16
PEG_TX_CPU_P2: C1609.2 CPU1.C17
PEG_TX_CPU_P3: C1611.2 CPU1.A19
PEX_TERMP: GPU1.AF25 R7301.1
PEXTSTCLK_OUT: GPU1.AF22 R7307.1
PEXTSTCLK_OUT#: GPU1.AE22 R7307.2
PIRQA#: CPU1.BB11 R1607.1
PLT_RST#: C1701.1 EC1703.1 Q3103.E R1713.1 R1715.1 R2410.2 R3108.1 R4007.1 R5538.2 R6116.1 R6802.1 U7301.2 U9101.17
PLT_RST#_DEBUG: DB1.7 R6802.2
PLT_RST#_LAN: LOM31.19 Q3103.C R3108.2 RN3101.3(B)
PLT_RST_NGFF#: AFTP5805.1 R6116.2 WLAN1.52
PM_LAN_ENABLE: Q3101.G R2491.2 R3111.1
PM_LAN_ENABLE_C: C3110.2 Q3104.G R3110.2
PM_PCH_PWROK: CPU1.BA20 EC1713.2 R1706.2 R1732.2
PM_RSMRST#: CPU1.AY17 Q1701.3 R1702.1 R1704.1 R1720.2 R1733.2 TP9903.1
PM_RSMRST#_M: Q1702.5 Q1702.6 R1737.2
PM_RSMRST#_R: Q1702.2 R1720.1
PM_SLP_S0_STG#: R4020.2 R4028.2 U4003.1
PM_SLP_S3_STG#: R4021.2 R4022.1 U4003.2
PME#: CPU1.AU11 TP1707.1
POWER_SW_IN#: C2426.1 KBC24.127 R2432.2 R2451.1
PQ3802_1: PQ4302.B PR4302.1 PR4309.2
PQ3808D: PC4308.2 PQ4308.D
PQ3808G: PC4309.1 PQ4308.G PR4315.1
PQ3809_D: PQ4306.3 PR4314.2
PQ4303_5: PC4310.1 PQ4303.5 PR4318.1
PQ4405_2: PQ4405.2 PR4462.1 PR4463.1
PQ4405_3: PQ4405.3 PR4455.1
PQ4405_5: PC4426.1 PQ4405.5 PR4413.2
PQ4405_6: PC4426.2 PQ4405.6 PR4450.1
PQ4408_C: PQ4408.C PR4451.1 PR4462.2
PQ4408_E: PQ4408.E PR4431.2 PR4433.1
PR4601_1: PR5101.2 PR5106.1
PR4605_2: PC5119.1 PR5105.2
PROC_SELECT#: CPU1.C64 R603.1
PROJECT_ID1: CPU1.AY8 R2015.2 R2016.1
PROJECT_ID2: CPU1.BA8 R2017.2 R2018.1
PS_ID: KBC24.36 PD4302.3 PR4304.2 PR4305.2
PS_ID_R: AFTP3802.1 DCIN1.4 PR4317.1
PS_ID_R1: PQ4301.S PR4305.1 PR4306.2
PS_ID_R2: PD4303.1 PD4303.2 PQ4301.D PR4306.1 PR4309.1 PR4317.2
PS_S3CNTRL: Q4001.5 Q4001.6 R4004.2
PSID_DISABLE#_R_C: PQ4301.G PQ4302.C PR4303.2
PSYS: PR4671.2 PU4601.46
PTP_DIS#: D2405.K KBC24.90
PTP_INT#_EC: KBC24.33 R2431.2
PU4301_G: PC4308.1 PR4319.2 PU4301.4
PURE_HW_SHUTDOWN#: C2610.1 C7610.1 D4001.K Q2602.D Q4002.C R2612.1 R7653.2
PWR_1D0V_BOOT: PR5302.1 PU5301.6
PWR_1D0V_BOOT_R: PC5305.1 PR5302.2
PWR_1D0V_BYP: PR5303.1 PU5301.7
PWR_1D0V_EN: PC5311.1 PR5307.1 PR5309.2 PR5311.2 PU5301.1
PWR_1D0V_FB: PC5306.2 PR5301.2 PR5305.1 PU5301.4
PWR_1D0V_ILMT: PR5308.2 PU5301.3
PWR_1D0V_LDO: PC5304.1 PU5301.5
PWR_1D0V_LX: PC5305.2 PL5301.1 PU5301.10
PWR_1D0V_PG: PR5304.2 PR5310.2 PU5301.2
PWR_1D5V_EN: PC5407.1 PR5405.2 PU5402.3
PWR_1D05V_EN: PC8302.1 PR8305.2 PU8301.5
PWR_1D05V_FB: PC8305.2 PR8302.1 PR8303.2 PU8301.6
PWR_1D05V_PGOOD: PR8304.2 PR8320.1 PU8301.4
PWR_1D05V_PHASE: PL8301.1 PU8301.1 PU8301.2 PU8301.3
PWR_1D05V_PVDD: PC8306.1 PC8307.1 PG8301.1 PG8302.1 PG8303.1 PR8301.1 PU8301.9 PU8301.10
PWR_1D05V_SVIN: PC8301.1 PR8301.2 PU8301.8
PWR_1D8V_EN: PC5406.1 PR5401.1 PR5406.2 PR5407.2 PU5401.8
PWR_1D8V_POK: PR5402.2 PR5408.2 PU5401.7
PWR_1D35V_DRVH: PU5101.14 PU5102.4
PWR_1D35V_DRVL: PU5101.11 PU5103.4
PWR_1D35V_EN: PC5106.1 PR5107.2 PU5101.16
PWR_1D35V_MODE: PR5108.1 PU5101.19
PWR_1D35V_REFIN: PC5102.1 PR5101.1 PR5103.2 PU5101.8
PWR_1D35V_SW: PC5119.2 PL5101.1 PR5112.1 PU5101.13 PU5102.1 PU5102.2 PU5102.3 PU5103.5 PU5103.6 PU5103.7 PU5103.8
PWR_1D35V_TRIP: PR5102.1 PU5101.18
PWR_1D35V_VBST: PR5105.1 PU5101.15
PWR_1D35V_VDDQS: PG5107.1 PU5101.9
PWR_1D35V_VREF: PC5103.1 PR5103.1 PU5101.6
PWR_1D35V_VTTREF: PC5118.1 PR5111.1 PU5101.5
PWR_3D3V_CS2: PR4517.1 PU4503.5
PWR_3D3V_DRVH2: PU4503.10 PU4504.4
PWR_3D3V_DRVL2: PU4503.11 PU4505.4
PWR_3D3V_EN2: PR4506.2 PU4503.6
PWR_3D3V_FB2: PC4523.2 PR4512.2 PR4523.1 PU4503.4
PWR_3D3V_FB2_R: PC4523.1 PR4535.2
PWR_3D3V_LL2: PC4535.2 PL4502.2 PR4533.1 PU4503.8 PU4504.1 PU4504.2 PU4504.3 PU4505.5 PU4505.6 PU4505.7 PU4505.8
PWR_3D3V_SNUB: PC4520.1 PR4533.2
PWR_3D3V_VBST2: PR4528.2 PU4503.9
PWR_3D3V_VBST2_1: PC4535.1 PR4528.1
PWR_5V_CS1: PR4531.1 PU4503.1
PWR_5V_DRVH1: PU4501.4 PU4503.16
PWR_5V_DRVL1: PU4502.4 PU4503.15
PWR_5V_EN1: PR4504.2 PU4503.20
PWR_5V_EN1_R: PR4501.2 PR4504.1 PR4507.2 PR4530.1
PWR_5V_FB1: PC4522.2 PR4526.1 PR4527.2 PU4503.2
PWR_5V_FB1_R: PC4522.1 PR4525.2
PWR_5V_LL1: PC4516.2 PL4501.1 PR4529.1 PU4501.1 PU4501.2 PU4501.3 PU4502.5 PU4502.6 PU4502.7 PU4502.8 PU4503.18
PWR_5V_SNUB: PC4536.1 PR4529.2
PWR_5V_VBST1: PR4524.1 PU4503.17
PWR_5V_VBST1_1: PC4516.1 PR4524.2
PWR_5V_VCLK: PU4503.19 TP4501.1
PWR_5V_VO1: PG4532.2 PR4525.1 PR4527.1 PU4503.14
PWR_+VCCSA: PG5022.2 PG5025.2 PG5026.2 PG5027.2 PG5028.2 PG5029.2 PG5030.2 PG5031.2 PL5001.2
PWR_CHG_1: PD4402.K PD4405.K PR4407.1
PWR_CHG_ACDET: PC4413.1 PR4408.2 PR4409.1 PU4401.6
PWR_CHG_ACN: PC4402.1 PC4404.2 PG4403.2 PR4404.1 PU4401.1
PWR_CHG_ACOK: D1703.K PR4416.2 PR4432.1 PR4435.2 PR4463.2 PU4401.5 R2469.1
PWR_CHG_ACP: PC4402.2 PC4403.2 PG4402.2 PR4404.2 PU4401.2
PWR_CHG_AD_OFF_R: PQ4303.6 PQ4304.B PR4310.2 PR4311.1
PWR_CHG_BATPRES#: PG4416.2 PU4401.15
PWR_CHG_BATSRC: PR4414.1 PU4401.17
PWR_CHG_BTST: PC4414.1 PD4403.K PU4401.25
PWR_CHG_CMPIN: PR4421.2 PR4424.1 PU4401.13
PWR_CHG_CMPOUT: PU4401.14 TP4404.1
PWR_CHG_CMSRC: PR4410.2 PU4401.3
PWR_CHG_HIDRV: PU4401.26 PU4404.4
PWR_CHG_IADP: PG4401.1 PU4401.7
PWR_CHG_IDCHG: PG4414.1 PU4401.8
PWR_CHG_ILIM: PR4420.2 PR4423.1 PU4401.21
PWR_CHG_LODRV: PU4401.23 PU4405.4
PWR_CHG_PHASE: PC4414.2 PL4401.1 PU4401.27 PU4404.1 PU4404.2 PU4404.3 PU4405.5 PU4405.6 PU4405.7 PU4405.8
PWR_CHG_PHASE_1: PG4412.2 PL4401.2 PR4415.1 PU4403.5 PU4403.6 PU4403.7 PU4403.8
PWR_CHG_PMON: PG4415.1 PU4401.9
PWR_CHG_PROCHOT#: PR4418.2 PU4401.10
PWR_CHG_REGN: PC4401.2 PD4403.A PR4435.1 PU4401.24
PWR_CHG_SCL: PG4410.1 PU4401.12
PWR_CHG_SDA: PG4409.1 PU4401.11
PWR_CHG_SRN: PR4419.1 PU4401.19
PWR_CHG_SRN_1: PC4420.2 PC4422.1 PG4413.1 PR4419.2
PWR_CHG_SRP: PR4417.1 PU4401.20
PWR_CHG_SRP_1: PC4420.1 PC4421.1 PG4412.1 PR4417.2
PWR_CHG_STAT#: PU4401.16 TP4405.1
PWR_CHG_VCC: PC4412.2 PR4407.2 PU4401.28
PWR_DCBATOUT_1D0V: EC5301.1 PC5301.1 PC5310.1 PG5304.1 PG5308.1 PG5309.1 PG5310.1 PU5301.8
PWR_DCBATOUT_3D3V: PC4509.1 PC4525.1 PC4528.1 PG4521.1 PG4524.1 PG4525.1 PG4531.1 PU4504.5 PU4504.6 PU4504.7 PU4504.8
PWR_DCBATOUT_5V: PC4527.1 PC4529.1 PC4530.1 PG4518.1 PG4520.1 PG4534.1 PG4536.1 PG4542.1 PG4543.1 PU4501.5 PU4501.6 PU4501.7 PU4501.8
PWR_LED: EC6406.1 Q6405.C R6409.1
PWR_LED#: KBC24.4 Q2416.S R2498.1
PWR_LED#_B: Q6405.B Q6407.D
PWR_LED#_R: AFTP6305.1 LEDBD1.4 R6409.2
PWR_LED#_S: Q2416.D Q6407.S
PWR_LEVEL: D7601.A D7602.A GPU1.D7 R7605.2
PWR_VCCGT_BOOTA: PR4802.1 PU4801.35
PWR_VCCGT_BOOTA_RC: PC4809.1 PR4802.2
PWR_VCCGT_COMP: PC4617.2 PC4618.2 PU4601.4
PWR_VCCGT_COMP_R: PC4618.1 PR4631.2
PWR_VCCGT_CSCOMP: PC4620.1 PC4621.1 PR4634.2 PR4639.2 PR4640.1 PU4601.6
PWR_VCCGT_CSNA: PG4809.1 PR4646.2
PWR_VCCGT_CSP1: PC4623.2 PR4651.2 PU4601.10
PWR_VCCGT_CSP2: PR4603.2 PU4601.9
PWR_VCCGT_CSPA: PG4808.1 PR4637.1 PR4651.1
PWR_VCCGT_CSREF: PC4623.1 PC4626.1 PR4646.1 PU4601.8
PWR_VCCGT_CSSUM: PC4620.2 PC4621.2 PR4637.2 PR4638.2 PU4601.7
PWR_VCCGT_DIFFOUT: PR4625.1 PR4626.1 PU4601.2
PWR_VCCGT_DISB#_A: PR4808.2 PU4801.2
PWR_VCCGT_FB: PC4614.2 PC4617.1 PR4626.2 PR4631.1 PU4601.3
PWR_VCCGT_FB_R: PC4614.1 PR4625.2
PWR_VCCGT_GL1: PU4801.8 PU4801.9 PU4801.10 PU4801.11
PWR_VCCGT_ICCMAX: PR4662.1 PU4601.18
PWR_VCCGT_ILIM: PR4640.2 PU4601.5
PWR_VCCGT_ILIM_R: PR4634.1 PR4638.1 PR4639.1
PWR_VCCGT_IOUT: PC4615.2 PR4632.2 PU4601.1
PWR_VCCGT_NTC: PR4655.1 PR4656.2 PR4661.1
PWR_VCCGT_PHASEDA: PC4809.2 PU4801.32 PU4801.34
PWR_VCCGT_PWMA: PU4601.16 PU4801.4
PWR_VCCGT_SNUB_1: PC4810.1 PR4804.2
PWR_VCCGT_SWA: PG4808.2 PL4801.1 PR4804.1 PU4801.12 PU4801.13 PU4801.14 PU4801.15 PU4801.16 PU4801.17 PU4801.18
PWR_VCCGT_TSENSE: PC4630.1 PR4655.2 PU4601.11
PWR_VCCGT_VCCA: PC4808.1 PR4803.1 PU4801.6
PWR_VCCGT_VSN: PC4612.2 PR4619.1 PU4601.48
PWR_VCCGT_VSN_R: PC4611.2 PC4612.1 PR4618.2 PR4619.2
PWR_VCCGT_VSP: PC4611.1 PR4617.2 PU4601.47
PWR_VCCIO_EN: PC5227.1 PR5216.2 PR5218.2 PU5203.4
PWR_VCCSA_BST: PR5013.1 PU5001.1
PWR_VCCSA_BST_RC: PC5008.1 PR5013.2
PWR_VCCSA_COMP: PC4602.2 PC4604.2 PU4601.43
PWR_VCCSA_COMP_R: PC4602.1 PR4602.2
PWR_VCCSA_CSN: PC4606.1 PC4607.1 PG5022.1 PR4606.2 PU4601.41
PWR_VCCSA_CSN_NTC: PR4606.1 PR4609.2
PWR_VCCSA_CSP: PG5021.1 PR4612.2
PWR_VCCSA_CSP1B: PC4606.2 PC4607.2 PR4609.1 PR4612.1 PU4601.40
PWR_VCCSA_DRVH: PU5001.8 PU5002.4
PWR_VCCSA_DRVL: PU5001.5 PU5003.4
PWR_VCCSA_ICCMAX: PR4660.1 PU4601.20
PWR_VCCSA_ILIM: PC4632.1 PR4611.1 PU4601.42
PWR_VCCSA_IOUT: PC4609.1 PR4613.1 PU4601.39
PWR_VCCSA_PWM: PU4601.36 PU5001.2
PWR_VCCSA_SNUB: PC5031.1 PR5014.2
PWR_VCCSA_SW: PC5008.2 PG5021.2 PL5001.1 PR5014.1 PU5001.7 PU5002.1 PU5002.2 PU5002.3 PU5003.5 PU5003.6 PU5003.7 PU5003.8
PWR_VCCSA_VSN: PC4603.2 PR4605.2 PU4601.44
PWR_VCCSA_VSN_R: PC4603.1 PC4605.2 PR4604.2 PR4605.1
PWR_VCCSA_VSP: PC4608.2 PR4608.2 PU4601.45
PWR_VCCSA_VSP_R: PC4605.1 PR4607.2 PR4608.1 PR4616.1
PWR_VCCSA_VSP_RC: PC4608.1 PR4616.2
PWR_VCORE_ADDR_BOOT: PR4663.1 PU4601.21
PWR_VCORE_ALERT#: PR4666.2 PU4601.33
PWR_VCORE_BOOT: PR4701.1 PU4701.35
PWR_VCORE_BOOT_RC: PC4706.1 PR4701.2
PWR_VCORE_COMP: PC4601.1 PC4619.1 PU4601.26
PWR_VCORE_COMP_R: PC4601.2 PR4636.1
PWR_VCORE_CSN: PC4616.2 PC4634.2 PG4708.1 PR4633.1 PU4601.28
PWR_VCORE_CSNNTC: PR4629.2 PR4633.2
PWR_VCORE_CSP: PG4707.1 PR4627.2
PWR_VCORE_CSP_1A: PC4616.1 PC4634.1 PR4627.1 PR4629.1 PU4601.29
PWR_VCORE_DISB#: PR4704.2 PU4701.2
PWR_VCORE_DRVON: PR4704.1 PR4808.1 PU4601.35 PU5001.3
PWR_VCORE_EN: PR4630.1 PU4601.37
PWR_VCORE_GL: PU4701.8 PU4701.9 PU4701.10 PU4701.11
PWR_VCORE_ICCMAX: PR4658.1 PU4601.19
PWR_VCORE_ILIM: PC4633.1 PR4635.1 PU4601.27
PWR_VCORE_IOUT: PC4613.1 PR4628.1 PU4601.30
PWR_VCORE_NTC: PR4650.1 PR4652.1 PR4653.2
PWR_VCORE_PHASED: PC4706.2 PU4701.32 PU4701.34
PWR_VCORE_PWM: PU4601.22 PU4701.4
PWR_VCORE_ROSC_COREGT: PR4664.1 PU4601.14
PWR_VCORE_ROSC_SAUS: PR4659.1 PU4601.15
PWR_VCORE_SCLK: PR4665.2 PU4601.34
PWR_VCORE_SDIO: PR4667.2 PU4601.32
PWR_VCORE_SNUB: PC4709.1 PR4703.2
PWR_VCORE_SW: PG4707.2 PL4701.1 PR4703.1 PU4701.12 PU4701.13 PU4701.14 PU4701.15 PU4701.16 PU4701.17 PU4701.18
PWR_VCORE_TSENSE: PC4628.1 PR4650.2 PU4601.23
PWR_VCORE_VCC: PC4708.1 PR4702.1 PU4701.6
PWR_VCORE_VCC_R: PC4631.1 PR4657.2 PU4601.13
PWR_VCORE_VR_RDY: PR4670.1 PU4601.38
PWR_VCORE_VRHOT#: PR4668.1 PU4601.31
PWR_VCORE_VRMP: PC4629.1 PR4601.2 PU4601.12
PWR_VCORE_VSN: PC4622.2 PR4644.1 PU4601.25
PWR_VCORE_VSN_R: PC4622.1 PC4625.1 PR4644.2 PR4645.2
PWR_VCORE_VSP: PR4647.1 PR4649.1 PU4601.24
PWR_VCORE_VSP_R: PC4625.2 PC4627.2 PR4647.2 PR4648.2
PWR_VCORE_VSP_RC: PC4627.1 PR4649.2
PWR_VGA_CORE_BOOT1: PR8210.1 PU8201.1
PWR_VGA_CORE_BOOT1_1: PC8211.1 PR8210.2
PWR_VGA_CORE_BOOT2: PR8211.1 PU8201.15
PWR_VGA_CORE_BOOT2_1: PC8216.1 PR8211.2
PWR_VGA_CORE_EN: PC8225.2 PQ8305.2 PR8256.2 PR8260.2 PU8201.3
PWR_VGA_CORE_EN#: PQ8305.5 PQ8305.6 PR8315.1
PWR_VGA_CORE_LGATE1: PR8224.1 PU8201.19 PU8202.8 PU8204.8
PWR_VGA_CORE_LGATE2: PU8201.17 PU8206.8 PU8208.8
PWR_VGA_CORE_PHASE1: PC8211.2 PL8201.1 PR8216.1 PU8201.20 PU8202.9 PU8204.9
PWR_VGA_CORE_PHASE2: PC8216.2 PL8202.1 PR8215.1 PU8201.16 PU8206.9 PU8208.9
PWR_VGA_CORE_PSI: PC8226.2 PR8257.2 PR8258.2 PR8259.1 PU8201.4
PWR_VGA_CORE_REFADJ: PR8222.1 PU8201.6
PWR_VGA_CORE_REFIN: PC8204.1 PR8208.1 PR8209.1 PU8201.7
PWR_VGA_CORE_RGND: PC8201.1 PC8204.2 PC8217.1 PC8219.2 PC8223.2 PR8209.2 PR8213.1 PR8220.1 PU8201.10
PWR_VGA_CORE_SS: PC8205.1 PU8201.11
PWR_VGA_CORE_TON: PR8201.2 PU8201.9
PWR_VGA_CORE_TON_1: PC8202.2 PR8201.1 PR8202.2
PWR_VGA_CORE_UGATE1: PU8201.2 PU8202.1 PU8204.1
PWR_VGA_CORE_UGATE2: PU8201.14 PU8206.1 PU8208.1
PWR_VGA_CORE_VID: PC8203.2 PR8207.2 PU8201.5
PWR_VGA_CORE_VREF: PC8201.2 PR8206.1 PU8201.8
PWR_VGA_CORE_VSNS: PC8219.1 PC8222.1 PR8212.2 PR8221.1 PU8201.12
PWR_VGA_SNUB1: PC8206.1 PR8216.2
PWR_VGA_SNUB2: PC8218.1 PR8215.2
Q402_1: Q3103.B RN3101.4(B)
Q4009_G: Q4009.G R2728.2 R2729.2
Q6204_G: Q6503.2 Q6503.5 R6512.1
Q6205_Q: Q6505.D R6522.2
Q7601_G: Q7601.2 Q7601.5 R7657.2
Q9101.G: Q9101.G R9115.1
REFIN_VREF: PC8223.1 PR8206.2 PR8208.2 PR8222.2
REGOUT: C3102.1 LOM31.24 R3101.1
RESET_OUT#: EC1704.1 KBC24.73 Q2602.G Q4001.3 R1706.1
RING2: EC2906.1 HDA27.17 R2911.2 RN2901.4(B)
RING2_HPMIC1: ED306.1 HPMIC1.4 R2911.1
RISING TIME: C4008.1 D4005.K U4006.1
RISING TIME2: C4006.1 D4004.K U4002.1
ROM_CS#: GPU1.D12 R7626.1
ROM_SCLK: GPU1.C12 R7608.2 R7614.1
ROM_SI: GPU1.B12 R7616.2 R7618.1 R7619.1 R7638.2 R7639.2 R7640.2 R7642.1 R7655.1
ROM_SO: GPU1.A12 R7611.2 R7620.1
RSET: LOM31.31 R3112.2
RSMRST_PWRGD#: D4002.3 R4029.2 R4030.2 R4031.2 R4032.2 R4033.2
RSVD_F65: CPU1.F65 TP612.1
RSVD_G65: CPU1.G65 TP613.1
RSVD_TP_AK12: CPU1.AK12 TP606.1
RSVD_TP_AK13: CPU1.AK13 TP605.1
RSVD_TP_AW70: CPU1.AW70 TP615.1
RSVD_TP_AW71: CPU1.AW71 TP614.1
RSVD_TP_BA68: CPU1.BA68 TP602.1
RSVD_TP_BA70: CPU1.BA70 TP601.1
RSVD_TP_BB68: CPU1.BB68 TP603.1
RSVD_TP_BB69: CPU1.BB69 TP604.1
RT8812_PVCC: PC8207.1 PR8223.2 PU8201.18
RTC_AUX_S5: C2117.1 C2118.1 C2119.1 C2503.1 D2501.3 R1730.1 R2106.1 R2473.2 RN1901.1(A) RN1901.2(A)
RTC_DET#: CPU1.P1 Q2505.D R2040.2
RTC_PWR: D2501.2 Q2505.G R2502.1 R2504.1
RTC_RST#: C1901.1 CPU1.AM16 EC1807.1 G1901.2 Q1901.D RN1901.3(B)
RTC_X1: C1804.1 CPU1.AM18 R1815.1 X1802.4
RTC_X2: C1803.1 CPU1.AM20 R1815.2 X1802.1
RTCRST_ON: EC1808.1 KBC24.31 Q1901.G R1902.1
RUNPWROK: KBC24.48 R2481.1
SA0_DIMA: DM1.197 R1201.1
SA0_DIMB: DM2.197 R1301.1
SA1_DIMA: DM1.201 R1202.1
SA1_DIMB: DM2.201 R1302.2
SATA_LED: EC6407.1 Q6401.C R6401.1
SATA_LED#: CPU1.H1 Q6408.1 R1606.2
SATA_LED#_B: Q6401.B Q6402.D
SATA_LED#_M: Q6402.S Q6408.3 Q6408.6
SATA_LED_R: AFTP6306.1 LEDBD1.3 R6401.2
SATA_RX_CON_N0: C6004.2 HDD1.5 U6001.4 U6001.7
SATA_RX_CON_P0: C6003.2 HDD1.6 U6001.5 U6001.6
SATA_RX_CPU_N0: C6004.1 CPU1.F20
SATA_RX_CPU_P0: C6003.1 CPU1.E20
SATA_TX_CON_N0: C6006.1 HDD1.3 U6001.2 U6001.9
SATA_TX_CON_P0: C6005.1 HDD1.2 U6001.1 U6001.10
SATA_TX_CPU_N0: C6006.2 CPU1.B21
SATA_TX_CPU_P0: C6005.2 CPU1.A21
SD_RCOMP: CPU1.AB7 R1901.1
SD_READ_MODE#: CPU1.AN5 IOBD1.9 R2050.2
SERIRQ: CPU1.AY11 KBC24.55 R2032.2
SERIRQ_TPM: R9102.1 U9101.27
SIO_EXT_SCI#: KBC24.66 R2411.1
SIO_EXT_SCI#_R: CPU1.J2 R1608.2 R2411.2
SIO_EXT_SMI#: KBC24.10 R2412.1 R2457.1
SIO_EXT_SMI#_R: CPU1.L6 R802.1 R2412.2
SIO_EXT_WAKE#: CPU1.AD3 KBC24.116 R2041.2
SIO_PWRBTN#: CPU1.BA15 KBC24.52 R9926.1
SIO_RCIN#: CPU1.AW13 KBC24.53 R2021.2
SIO_SLP_A#: CPU1.AN16 TP1706.1
SIO_SLP_S0#: CPU1.AT11 R4028.1
SIO_SLP_S3#: CPU1.AP15 D1701.K KBC24.70 PR5110.2 PR5216.1 PR5405.1 Q4001.2 R2728.1 R4010.1 R4021.1 U1702.2
SIO_SLP_S4#: CPU1.BA16 KBC24.67 PR5107.1 R4023.1 U4005.2
SIO_SLP_S5#: CPU1.AY16 TP1703.1
SIO_SLP_SUS#: CPU1.AN15 KBC24.96 PR5309.1 PR5407.1 Q4004.G R1729.2
SKTOCC#: CPU1.A65 TP402.1
SLEEVE: EC2905.1 HDA27.18 R2906.2 RN2901.3(B)
SLEEVE_HPMIC1: ED302.1 HPMIC1.3 R2906.1
SLP_LAN#: CPU1.AW15 TP1704.1
SM_DRAMRST#: CPU1.AT13 D502.2 R504.1 R505.2
SM_INTRUDER#: CPU1.AP16 R1730.2
SM_PGCNTL: CPU1.AW67 PR5109.2
SM_RCOMP_0: CPU1.AR18 R501.1
SM_RCOMP_1: CPU1.AT18 R502.1
SM_RCOMP_2: CPU1.AU18 R503.1
SMBC_THERM_NV: GPU1.D9 Q7601.1 RN7601.2(A)
SMBCLK1: D4306.3 EC4309.1 KBC24.9 PG4410.2 PR4412.2 RN2402.3(B) RN4302.3(A)
SMBCLK2: KBC24.12 Q2604.3 R2483.1 RN2603.4(B)
SMBD_THERM_NV: GPU1.D8 Q7601.4 RN7601.1(A)
SMBDA1: D4305.3 EC4310.1 KBC24.8 PG4409.2 PR4411.2 RN2402.4(B) RN4302.2(A)
SMBDA2: KBC24.11 Q2604.6 R2482.1 RN2603.3(B)
SML0_SMBCLK: CPU1.R9 RN1807.5(B)
SML0_SMBDATA: CPU1.W2 RN1807.6(B)
SML1_SMBCLK: CPU1.W3 Q2601.3 Q2604.4 Q7601.6 R2483.2 RN1807.7(B)
SML1_SMBDATA: CPU1.V3 Q2601.6 Q2604.1 Q7601.3 R2482.2 RN1807.8(B)
SP_PLLVDD: C7601.1 C7602.1 C7603.1 C7604.1 GPU1.M6 GPU1.N6 L7602.2
SPI0_MOSI_XDP: R1826.1 TP9905.1
SPI1_CLK_ROM_R: EC2505.1 R2511.1 SKT26.6 SPI252.6
SPI1_HOLD_ROM_R: R2509.1 RN2502.2(A) SKT26.7 SPI252.7
SPI1_SI_ROM_R: EC2506.1 R2512.1 SKT26.5 SPI252.5
SPI1_SO_ROM_R: EC2504.1 R2513.2 SKT26.2 SPI252.2
SPI1_WP_ROM_R: R2514.2 RN2502.1(A) SKT26.3 SPI252.3
SPI_CLK_CPU: CPU1.AV2 R1806.2
SPI_CLK_ROM: R1806.1 R2485.1 R2505.2 R2511.2 R9107.1
SPI_CLK_ROM_R: EC2503.1 R2505.1 SKT25.6 SPI25.6
SPI_CLK_ROM_TPM: R9107.2 U9101.19
SPI_CS2#_R: Q9102.G R1816.1 R9103.1 R9115.2 R9116.2 U9101.20
SPI_CS_CPU_N0: CPU1.AU3 R1812.2
SPI_CS_CPU_N1: CPU1.AU2 R1828.2
SPI_CS_ROM_N0: R1812.1 R2490.1 R2501.1 SKT25.1 SPI25.1
SPI_CS_ROM_N1: R1828.1 R2515.1 SKT26.1 SPI252.1
SPI_HOLD_CPU: CPU1.AU4 R1811.2 R1835.2 R1836.1
SPI_HOLD_ROM: R1811.1 R2503.2 R2509.2
SPI_HOLD_ROM_R: R2503.1 RN2501.2(A) SKT25.7 SPI25.7
SPI_IRQ#: R9104.1 U9101.18
SPI_SI_CPU: CPU1.AV3 R1808.2 R1824.2 R1825.1 R1826.2
SPI_SI_ROM: R1808.1 R2486.1 R2506.2 R2512.2 R9105.1
SPI_SI_ROM_R: EC2501.1 R2506.1 SKT25.5 SPI25.5
SPI_SI_ROM_TPM: R9105.2 U9101.21
SPI_SO_CPU: CPU1.AW3 R1807.2
SPI_SO_ROM: R1807.1 R2487.1 R2507.1 R2513.1 R9106.1
SPI_SO_ROM_R: EC2502.1 R2507.2 SKT25.2 SPI25.2
SPI_SO_ROM_TPM: R9106.2 U9101.24
SPI_WP_CPU: CPU1.AW2 R1809.2 R1827.2 R1834.2
SPI_WP_ROM: R1809.1 R2508.1 R2514.1
SPI_WP_ROM_R: R2508.2 RN2501.1(A) SKT25.3 SPI25.3
SPKR: CPU1.AW5 R2006.2 RN2701.2(A)
SRTC_RST#: C1902.1 CPU1.AN18 EC1806.1 RN1901.4(B)
STRAP0: GPU1.D1 R7621.1 R7625.2 R7646.2
STRAP1: GPU1.D2 R7622.1 R7635.2 R7647.1
STRAP2: GPU1.E4 R7606.2 R7637.1
STRAP3: GPU1.E3 R7609.1 R7615.2 R7650.1
STRAP4: GPU1.D3 R7632.1 R7634.2 R7654.1
STRAP_REF0_GND_N9: GPU1.F6 R7607.2
SUS_CLK: R1813.2 R2428.2
SUS_STAT#/LPCPD#: CPU1.BA11 R1814.2
SUSACK#: KBC24.34 RN1702.2(A)
SUSACK#_R: CPU1.AP11 R1708.2 RN1702.3(B)
SUSCLK_R: CPU1.BA17 EC1803.2 R1813.1
SYS_PEX_RST_MON#: D7301.2 R7304.2 R7306.1 R7313.1 R7629.2 U7301.4
SYS_PEX_RST_MON_GPU#: GPU1.E9 R7629.1 R7643.1
SYS_PWROK: CPU1.B6 EC1702.1 KBC24.89 R1717.1
T_CRIT#: R2601.1 R2604.2 THM26.4
TESTMODE: GPU1.AD9 R7302.1
THERM_SYS_SHDN#: Q2602.S R2601.2 R2602.1
THM_SML1_CLK: C2608.1 Q2601.4 RN2602.4(B) THM26.8
THM_SML1_DATA: C2609.1 Q2601.1 RN2602.3(B) THM26.7
TOUCH_PANEL_INTR#: CPU1.A7 D2402.A R2429.1 R5537.2
TOUCHPAD_INTR#: CPU1.BA5 R2045.2
TP1_AY4: CPU1.AY4 TP610.1
TP2_BB3: CPU1.BB3 TP611.1
TP4_BB5: CPU1.BB5 TP609.1
TP5_AU5: CPU1.AU5 TP607.1
TP6_AT5: CPU1.AT5 TP608.1
TP_EN#: KBC24.49 R2409.1 R6516.1
TP_LOCK#: AFTP6242.1 D2405.A R6509.2 TPAD1.3
TP_ON#_GATE: C6503.1 Q6504.G Q6505.G R6516.2
TP_RESET: C5540.1 LCD1.38 R5538.1
TP_RS: C5541.1 LCD1.37 R5537.1
TP_VDD: AFTP6239.1 C6504.1 Q6504.D R6509.1 R6513.1 R6514.2 R6517.2 R6522.1 RN6502.1(A) RN6502.2(A) RN6504.1(A) RN6504.2(A) TPAD1.8
TPAN_VDD: F5502.2 LCD1.40 R5520.1
TPAN_VDD_F: F5502.1 R5520.2 R5522.2 R5527.2
TPCLK_C: AFTP6238.1 RN6503.4(B) TPAD1.1
TPDATA_C: AFTP6236.1 RN6503.3(B) TPAD1.2
TPM_GPIO0: R9119.1 U9101.29
TPM_GPIO2: Q9101.D Q9102.D R9117.2 R9118.1 R9120.1 U9101.3
TPM_GPIO4: R9116.1 U9101.13
TPM_VDD14: R9111.1 U9101.14
TPM_VDD22: R9112.1 U9101.22
TPM_VSB: R9113.1 U9101.1
TPS51216_PHS_SET: PC5122.1 PR5112.2
UART0_CTS#: CPU1.U4 TP2014.1
UART0_RTS#: CPU1.U3 TP2013.1
UART0_TXD: CPU1.U2 TP2012.1
UART1_CTS#: CPU1.AB4 TP2017.1
UART1_RTS#: CPU1.AC3 TP2016.1
UART1_RXD: CPU1.AC1 TP2015.1
USB3_PRX_CTX_N1_C: R3608.1 U3601.1 U3601.10 USB1.5
USB3_PRX_CTX_N2_C: R3612.1 U3602.1 U3602.10 USB2.5
USB3_PRX_CTX_P1_C: R3607.1 U3601.2 U3601.9 USB1.6
USB3_PRX_CTX_P2_C: R3611.1 U3602.2 U3602.9 USB2.6
USB3_PTX_CRX_N1_C: R3606.1 U3601.4 U3601.7 USB1.8
USB3_PTX_CRX_N1_R: C3601.2 R3606.2
USB3_PTX_CRX_N2_C: R3610.1 U3602.4 U3602.7 USB2.8
USB3_PTX_CRX_N2_R: C3604.2 R3610.2
USB3_PTX_CRX_P1_C: R3605.1 U3601.5 U3601.6 USB1.9
USB3_PTX_CRX_P1_R: C3602.2 R3605.2
USB3_PTX_CRX_P2_C: R3609.1 U3602.5 U3602.6 USB2.9
USB3_PTX_CRX_P2_R: C3605.2 R3609.2
USB20_VCCA: AFTP6311.1 C3406.1 C3515.1 C3517.1 C3518.1 EU3404.5 IOBD1.11 IOBD1.12 IOBD1.13 IOBD1.14 U3503.1
USB30_RX_CPU_N1: CPU1.H8 R3608.2
USB30_RX_CPU_N2: CPU1.J6 R3612.2
USB30_RX_CPU_P1: CPU1.G8 R3607.2
USB30_RX_CPU_P2: CPU1.H6 R3611.2
USB30_TX_CPU_N1: C3601.1 CPU1.C13
USB30_TX_CPU_N2: C3604.1 CPU1.B13
USB30_TX_CPU_P1: C3602.1 CPU1.D13
USB30_TX_CPU_P2: C3605.1 CPU1.A13
USB30_VCCB: AFTP3404.1 C3509.1 C3514.1 C3516.1 C3519.1 C3618.1 EU3602.5 TC3502.1 U3502.1 USB2.1
USB30_VCCC: AFTP3401.1 C3507.1 C3508.1 C3512.1 C3513.1 C3603.1 EU3601.5 TC3501.1 U3501.1 USB1.1
USB_CAMERA_PN4: LCD1.30 TR5501.2
USB_CAMERA_PP4: LCD1.31 TR5501.3
USB_CON_PN6: LCD1.34 R5535.1
USB_CON_PN7: AFTP5806.1 R6110.1 WLAN1.5
USB_CON_PP6: LCD1.35 R5536.1
USB_CON_PP7: AFTP5807.1 R6111.1 WLAN1.3
USB_CPU_PN0: CPU1.AB9 TR3601.1
USB_CPU_PN1: CPU1.AD6 TR3602.1
USB_CPU_PN2: CPU1.AH3 TR3406.1
USB_CPU_PN3: CPU1.AD9 R9203.1
USB_CPU_PN4: CPU1.AJ1 TR5501.1
USB_CPU_PN5: CPU1.AF6 TR3301.1
USB_CPU_PN6: CPU1.AH1 R5535.2
USB_CPU_PN7: CPU1.AF8 R6110.2
USB_CPU_PP0: CPU1.AB10 TR3601.4
USB_CPU_PP1: CPU1.AD7 TR3602.4
USB_CPU_PP2: CPU1.AJ3 TR3406.4
USB_CPU_PP3: CPU1.AD10 R9204.1
USB_CPU_PP4: CPU1.AJ2 TR5501.4
USB_CPU_PP5: CPU1.AF7 TR3301.4
USB_CPU_PP6: CPU1.AH2 R5536.2
USB_CPU_PP7: CPU1.AF9 R6111.2
USB_EN#: KBC24.13 R2479.1
USB_OC0#: CPU1.A9 RN1602.7(B) U3501.3
USB_OC1#: CPU1.C9 RN1602.5(B) U3502.3
USB_OC2#: CPU1.D9 RN1602.8(B) U3503.3
USB_OC3#: CPU1.B9 R2457.2 RN1602.6(B)
USB_PN0_C: AFTP3402.1 EU3601.1 TR3601.2 USB1.2
USB_PN1_C: AFTP3405.1 EU3602.1 TR3602.2 USB2.2
USB_PN2_C: AFTP6301.1 EU3404.6 IOBD1.3 TR3406.2
USB_PN3_C: AFTP8903.1 EC9202.2 FPR1.4 R9203.2
USB_PN5_C: AFTP6304.1 IOBD1.6 TR3301.2
USB_PP0_C: AFTP3403.1 EU3601.3 TR3601.3 USB1.3
USB_PP1_C: AFTP3406.1 EU3602.3 TR3602.3 USB2.3
USB_PP2_C: AFTP6302.1 EU3404.1 IOBD1.4 TR3406.3
USB_PP3_C: AFTP8904.1 EC9201.2 FPR1.3 R9204.2
USB_PP5_C: AFTP6303.1 IOBD1.7 TR3301.3
USB_PWR_EN#: R2434.2 R2479.2 U3501.4 U3502.4 U3503.4
USB_UART_SEL_D9: CPU1.P2 TP2006.1
USBCOMP: CPU1.AB6 R1603.1
V_SM_VREF_CNT: C4201.1 CPU1.AY67 R4208.2
VCI_IN1#: KBC24.126 R2452.1
VCREF0: C2409.1 KBC24.25 R2424.1 R2448.1
VD_IN1_C: C2612.2 C2613.2 R2610.2 R2611.1
VGA_CORE: C7701.1 C7702.1 C7708.1 C7709.1 C7710.1 C7711.1 C7712.1 C7713.1 C7714.1 C7717.1 C7719.1 C7720.1 C7721.1 C7722.1 C7723.1 C7724.1 C7725.1 C7726.1 C7730.1 C7731.1 C7732.1 GPU1.K10 GPU1.K12 GPU1.K14 GPU1.K16 GPU1.K18 GPU1.L11 GPU1.L13 GPU1.L15 GPU1.L17 GPU1.M10 GPU1.M12 GPU1.M14 GPU1.M16 GPU1.M18 GPU1.N11 GPU1.N13 GPU1.N15 GPU1.N17 GPU1.P10 GPU1.P12 GPU1.P14 GPU1.P16 GPU1.P18 GPU1.R11 GPU1.R13 GPU1.R15 GPU1.R17 GPU1.T10 GPU1.T12 GPU1.T14 GPU1.T16 GPU1.T18 GPU1.U11 GPU1.U13 GPU1.U15 GPU1.U17 GPU1.V10 GPU1.V12 GPU1.V14 GPU1.V16 GPU1.V18 PL8201.2 PL8202.2 PR8212.1 PR8309.1 PT8206.1 PT8207.1 PT8208.1
VGA_CORE_DISCHG: PQ8305.3 PR8309.2
VGA_CORE_PSI: GPU1.B4 PR8257.1
VGA_CORE_VID: GPU1.E7 PR8207.1
VGACORE_GND_SENSE_1: GPU1.F1 PR8220.2
VGACORE_VDD_SENSE_1: GPU1.F2 PR8221.2
VIDEO_CLK_XTAL_SS: GPU1.A10 R7601.1
VIDEO_THERM_OVERT#: Q7602.6 TP7606.1
VR_CAP: C2418.1 KBC24.18
VR_EN: PR4630.2 PR5218.1 R4002.2
VR_RDY: PR4614.2 PR4670.2
VR_SVID_ALERT#: PR4622.2 PR4666.1 R727.2 R728.1
VR_SVID_CLK: PR4621.2 PR4665.1 R723.2 R732.2
VR_SVID_DATA: PR4623.2 PR4667.1 R709.2
VRAM_ID1: CPU1.AP8 R2023.2 R2024.1
VRAM_ID2: CPU1.AW7 R2033.2 R2034.1
WHITE_LED_BAT: EC6403.1 Q6404.C R6406.1
WIFI_RF_EN: CPU1.B7 R1503.2 R6114.1
WLAN_CLKREQ_WLAN#: AFTP5802.1 R6112.1 WLAN1.53
WLAN_DISABLE#1: AFTP5803.1 R6114.2 WLAN1.56
XCLK_BIASREF: CPU1.E42 R1803.1
XDP_BPM0: CPU1.C55 TP9947.1
XDP_BPM1: CPU1.D55 TP9944.1
XDP_BPM2: CPU1.B54 TP9946.1
XDP_BPM3: CPU1.C56 TP9945.1
XDP_DBRESET#: CPU1.B5 EC1706.1 R1701.2 TP9923.1
XDP_PRDY#: CPU1.D56 TP9919.1
XDP_PREQ#: CPU1.D61 TP9918.1
XDP_PWRBTN#: R9926.2 TP9904.1
XDP_SMBCLK: R9920.2 TP9907.1
XDP_SMBDAT: R9918.2 TP9906.1
XDP_SPI0_IO2: R1827.1 TP9921.1
XDP_TCK_JTAGX: CPU1.A59 R417.1 R9930.2 TP9915.1
XDP_TCLK: CPU1.B61 R406.1 R9930.1
XDP_TDI: CPU1.D60 R422.1 R9928.2 TP9914.1
XDP_TDO_CPU: CPU1.A61 R423.1 R9935.1
XDP_TMS: CPU1.C60 R421.1 R9927.2 TP9911.1
XDP_TRST#: CPU1.B59 CPU1.C61 R402.1 TP9910.1
XTAL1: C2425.2 KBC24.123 X2401.1
XTAL2: KBC24.125 R2428.1 R2458.2
XTAL24_IN: CPU1.E37 R1802.1 R1810.1
XTAL24_IN_R: C1801.2 R1810.2 X1801.1
XTAL24_OUT: C1802.2 CPU1.E35 R1802.2 X1801.3
XTAL_KBC_2: C2424.2 R2458.1 X2401.2
ZVM#: CPU1.AR56 TP616.1

Pads without a net: CPU1 A3 A4 A11 A15 A23 A25 A26 A27 A29 A31 A33 A36 A38 A40 A45 A47 A50 A52 A69 AB1 AB11 AB12 AB13 AB62 AC63 AD11 AD12 AE62 AE63 AF11 AF12 AF13 AG1 AG2 AG3 AG4 AG62 AH7 AH8 AH9 AH10 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK32 AK42 AK43 AK45 AK46 AK48 AK50 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL25 AL27 AL43 AL46 AL50 AL53 AL56 AL60 AL61 AL63 AM1 AM2 AM3 AM4 AM48 AM50 AM52 AM53 AM56 AM58 AN1 AN2 AN3 AN7 AN55 AP1 AP2 AP3 AP4 AP5 AP53 AT15 AU56 AU58 AU63 AW1 AW17 AW20 AW48 AW56 AW68 AW69 AY1 AY2 AY3 AY20 AY21 AY56 B2 B3 B11 B15 B23 B25 B26 B27 B29 B31 B33 B36 B38 B40 B45 B47 B50 B69 B70 BA3 BA4 BA9 BB2 BB4 BB57 BB66 C2 C4 C7 C11 C12 C15 C21 C23 C24 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C51 C54 C70 C71 D1 D3 D4 D5 D8 D12 D15 D21 D23 D24 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D51 D54 D71 E1 E2 E3 E10 E22 E23 E25 E27 E28 E30 E38 E40 E61 F6 F10 F21 F25 F30 F46 F50 F52 F60 F61 G21 G46 G50 H10 H11 H65 H66 J5 J10 J68 J71 K32 K45 K46 N11 P4 P62 U9 U11 U12 V62 W7 W10 W11 W12; D4002 2; DCIN1 3; DM1 77 122 125 198; DM2 77 122 125 198; EU3404 3 4; EU3601 4 6; EU3602 4 6; EU5703 5 6; FAN1 1; FPR1 2 5; GPU1 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B2 B3 B6 B19 C1 C2 C3 C7 C18 D4 D5 D6 D10 D16 D17 D18 E6 E10 F4 F5 F7 F9 F10 F11 G1 G2 G3 G4 G5 G6 G7 H3 H4 J1 J2 J3 J4 J5 K1 K2 K3 K4 K5 K6 L3 L4 M1 M2 M3 M4 M5 N1 N2 N3 N4 N5 P3 P4 R1 R2 R3 R4 R5 T1 T2 T3 T4 T5 T6 T24 U3 U4 U6 U24 V1 V2 V3 V4 V5 V6 V24 V25 W1 W2 W3 W4 W5 Y3 Y4; HDA27 14 23 24; HDD1 12 17; HDMI1 13 14; IOBD1 10 15 17; IRCCD1 3; KB1 2 3; KBLIT1 3; LCD1 3 33 39; MESW1 A; PU4401 4 18; PU4601 17; PU4701 1 33; PU4801 1 33; PU5402 4; PU8301 7; RN4302 4 5; RN5502 4 5; RN5503 4 5; U1701 1; U1702 1; U4005 1; U4101 5; U9101 2 4 5 6 7 10 11 12 15 25 26 28 30 31; VGABD1 3; VRAM1 J1 J9 L1 L9 M7; VRAM2 J1 J9 L1 L9 M7; VRAM3 J1 J9 L1 L9 M7; VRAM4 J1 J9 L1 L9 M7; WLAN1 6 16 17 19 20 21 22 25 26 27 28 31 32 34 48 50 59 60 61 62 64 65 66 67 68 71 73; X1801 2 4; X1802 2 3; X3101 2 4

## Via types
v1: diameter 0.356, hole 0.178, TOP to BOTTOM, 1505 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 4045 vias
v3: diameter 0.711, hole 0.406, TOP to BOTTOM, 1176 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8V_RUN_FB: length 5.1
  BOTTOM w0.254: v1(173.93,101.86) 173.54,102.25 PR5404.1 PR5403.2 ; PR5403.2 PC5405.2 ; PR5403.2 172.65,103.79 172.84,103.98 PU5401.2
3.3V_WLAN_EN: length 3.8
  TOP w0.127: v1(159.21,53.72) 158.85,53.36 158.4,53.36 157.97,53.79 R6104.2 R6101.1 157.79,52.96 Q6101.2
3.3V_WLAN_ENABLE: length 12.6
  TOP w0.127: Q6101.3 156.54,54.29 157.78,55.54 157.78,57.85 158.54,58.6 160.62,58.6 v1(160.93,58.29) 161.3,57.92 R6103.2 C6113.1 162.69,58.79 163.02,59.12 U6101.3
3.3V_WLAN_ENABLE#: length 4.1
  TOP w0.127: Q6101.6 154.13,52.31 153.66,51.85 153.4,51.85 v1(153.2,52.05) 153.2,52.86 R6102.2 153.37,52.96 Q6101.5
3V3_AON_CT_2: length 3
  TOP w0.254: v2(171.42,130.8) 171.01,130.8 v1(170.87,130.66) 170.72,130.51 170.72,129.48 C8306.1
  BOTTOM w0.203: v2(171.42,130.8) 171.71,131.09 U8301.10
3V3_AON_S0: length 135.2
  TOP w0.381: v2(202.07,129.75) 201.92,129.89 201.92,131.78 202.23,132.09 R7606.1 202.23,133.03 R7631.1
  TOP w0.508: R7605.1 207.02,135.62 207.45,135.19 Q7606.G ; v2(148.71,149.9) 149.33,150.52 v1(151.94,150.52) 158.01,150.52 162.04,146.5 164.72,146.5 166.45,144.77 v2(166.45,144.06) ; v2(200.07,129.97) 198.9,128.8 197.76,128.8 196.37,127.42 196.37,126.81 195.98,126.42 v2(195.42,126.42) 193.58,126.42 193.05,126.94 190.28,126.94 189.72,126.39 187.81,126.39 186.93,125.51 v2(186.54,125.51) ; v2(208.83,130.99) 209.36,130.99 R7649.2
  L3 w0.508: v3(183.63,129.38) 183.63,128.42 v2(186.54,125.51) ; v2(215.08,94.38) 214.92,94.54 207.01,94.54 206.03,95.51 204.21,95.51 v2(202.73,96.99) ; v3(181.46,129.04) 178.97,131.53 178.97,133.89 175.57,137.3 175.57,138.52 171.7,142.39 169.01,142.39 167.82,143.58 166.92,143.58 v2(166.45,144.06)
  L4 w0.508: v2(202.73,96.99) 202.36,96.99 197.95,101.4 197.95,113.08 198.67,113.8 198.67,117.9 196.96,119.61 196.96,124.88 v2(195.42,126.42)
  BOTTOM w0.356: GPU1.AA9 187.03,138.55 v2(187.4,138.18) 186.95,137.73 GPU1.AA8 186.95,137.66 v2(186.53,137.24) 186.09,137.68 GPU1.AB8
  BOTTOM w0.508: v2(202.73,96.99) 202.82,96.91 PR8203.1 ; PR8316.1 166.07,143.68 v2(166.45,144.06) ; 219.69,149.48 219.69,148.11 219.33,147.75 R7657.1 ; v2(148.71,149.9) 149.03,150.21 PR8304.1 ; v2(186.54,125.51) 187.73,124.32 R7645.1 ; R7615.1 200.07,128.72 v2(200.07,129.97) 201.02,129.97 201.24,129.75 v2(202.07,129.75) ; PR8258.1 v2(215.08,94.38)
  vias: v2(198.98,140.57) v2(198.96,139.78) v2(208.08,135.89) v2(211.58,135.41) v2(219.67,150.7) v3(182.49,129.39)
3V3_AON_S0_DISCHG: length 2.5
  BOTTOM w0.102: PQ8306.3 166.97,143.35 PR8316.2 166.96,142.98 166.75,142.77 v1(166.75,142.38)
3V5V_CT1:
  vias: v1(38.26,28.55)
3V5V_CT2: length 0.9
  TOP w0.254: C4002.1 v1(36.26,27.63)
3V5V_S0_ON: length 21.4
  TOP w0.127: U4001.5 37.44,32.56 37.21,32.8 v2(37.21,33.77) 37.38,33.95 38.31,33.95 38.4,33.86 38.4,33.08 38.24,32.92 U4001.3
  L3 w0.127: v2(37.21,33.77) 37.21,32.82 37.74,32.29 48.92,32.29 v2(49.75,33.13)
  BOTTOM w0.127: v2(49.75,33.13) 49.44,32.81 v1(49.44,32.41) 49.44,31.79 49.08,31.44 R4010.2
3V_5V_EN: length 8.1
  TOP w0.127: PR4506.1 34.37,57.15 PR4507.1 34.14,57.35 R4009.1 R4006.1 31,57.35 D4001.A 30.58,57.13 v2(30.58,58.15)
  BOTTOM w0.127: v2(30.58,58.15) 30.72,58 v1(31.19,58) 31.47,58 31.67,57.79 C4009.1
3V_5V_POK: length 404.4
  TOP w0.127: PU4503.7 36.94,55.54 36.72,55.76 v2(35.94,55.76) 35.47,55.76 PR4534.2 ; R4033.1 v1(132.27,146.45) 132.92,145.8 v2(132.92,145.03)
  L3 w0.127: v2(35.94,55.76) 33.14,58.56 32.03,58.56 29.73,60.86 29.73,61.22 32.93,64.42 48.69,64.42 56.47,56.65 56.47,38.64 57.95,37.16 57.95,35.58 60.87,32.66 62.08,32.66 63.92,30.83 65.19,30.83 65.44,30.58 66.36,30.58 73.2,23.74 73.2,23.55 73.86,22.88 73.86,22.62 73.86,19.34 78.12,15.08 91.22,15.08 95.95,10.35 130.18,10.35 136.08,16.25 140.1,16.25 149.31,25.47 v2(151.16,25.47) ; v2(132.92,145.03) 133.23,144.72 133.96,144.72 135.1,145.87 148.15,145.87 152.3,141.72 152.3,141.68 155.27,138.71 155.27,135.49 155.65,135.12 155.65,134.35 v2(154.93,133.63) 155.48,133.09 155.48,131.89 156.32,131.05 156.32,130.03 158.02,128.33 158.6,127.75 159.7,127.75 163.26,124.2 163.62,124.2 166.57,121.25 166.57,120.99 167.03,120.53 167.03,120.51 171.08,116.46 172.12,116.46 172.33,116.68 173.35,116.68 v2(173.92,116.11) ; v2(174.87,70.23) 174.84,70.27 172.23,70.27 172,70.5 170.04,70.5 169.78,70.76 169.78,71.06 169.77,71.07 169.77,71.16 169.45,71.47 168.23,71.47 168.1,71.34 167.3,71.34 167.17,71.47 164.91,71.47 164.21,70.77 161.6,70.77 160.2,69.37 159.48,69.37 158.07,70.78 154.37,70.78 153.83,70.24 153.32,70.24 153,70.56 151.2,70.56 v2(151.19,70.57)
  L4 w0.127: v2(174.87,70.23) 174.8,70.3 174.63,70.3 173.62,71.31 173.62,71.87 173.55,71.93 173.55,74.03 173.66,74.14 173.66,75.2 173.86,75.4 173.86,80.82 174.09,81.05 174.09,81.54 174.03,81.6 174.03,83.38 174.68,84.04 174.68,85.69 175.23,86.24 175.23,87.62 175.04,87.81 175.04,95.29 176.18,96.44 176.69,96.44 177.42,97.16 177.42,102.73 178.04,103.35 178.04,108.47 176.77,109.75 176.77,113.26 v2(173.92,116.11) ; v2(151.16,25.47) 152.33,26.64 152.33,56.29 155.36,59.33 155.36,62.72 152.16,65.92 152.16,67.19 151.51,67.85 151.51,69.24 151.19,69.55 v2(151.19,70.57)
  BOTTOM w0.127: v2(151.16,25.47) 150.03,26.6 150.03,39.03 148.58,40.47 147.28,40.47 145.19,42.56 144.09,42.56 139.8,46.85 139.8,48.04 138.25,49.6 137.19,49.6 R1725.2 136.51,48.91 R1718.2 ; EC1711.1 150.73,71.2 R1728.2 150.74,70.94 151.12,70.57 v2(151.19,70.57) ; PR5406.1 173.61,115.8 v2(173.92,116.11) ; PR5311.1 154.91,133.66 v2(154.93,133.63)
3V_5V_POK#: length 6
  BOTTOM w0.127: Q1701.5 153.94,72.29 153.86,72.21 153.86,71.77 153.99,71.63 Q1701.6 154.8,71.61 153.54,70.35 R1726.1 153.12,70.16 v1(153.12,68.89)
3V_5V_POK_C: length 5.2
  BOTTOM w0.127: Q1701.2 152.43,72.29 151.81,72.9 R1729.1 151.57,72.89 R1727.2 151.56,72.07 R1728.1 150.72,72.07 150.01,72.79 v1(149.13,72.79)
3V_FEEDBACK: length 43.7
  TOP w0.254: PR4512.1 36.6,61.15 PR4535.1 36.53,61.92 36.28,62.17 v1(31.57,62.17) 30.58,62.17 27.8,59.39 27.8,53.42 v2(28.2,53.02)
  BOTTOM w0.254: v2(28.2,53.02) 25.56,53.02 25.1,52.56 25.1,47.53 26.37,46.25 26.37,36.26 29.18,33.45 PG4535.2
5V_HDD_ENABLE: length 23.9
  TOP w0.127: R6002.2 160.84,26.47 164.56,26.47 165.63,27.54 166.74,27.54 167.81,26.47 170.61,26.47 171.74,27.61 171.74,30.27 171.94,30.47 173.45,30.47 173.93,29.98 Q6001.3 174.58,29.98 176.41,31.82 176.41,32.17 v1(176.45,32.2) 176.61,32.36 176.88,32.36 176.89,32.36 C6009.1 177.63,32.59 U6002.3
5V_HDD_ENABLE#: length 16.7
  TOP w0.127: Q6001.5 173.03,29.33 173.15,29.21 173.15,28.81 173.02,28.68 Q6001.6 172.44,27.82 170.83,26.21 167.68,26.21 166.62,27.26 165.74,27.26 164.67,26.19 161.89,26.19 v1(161.55,25.86) 160.89,25.19 R6003.2
