# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SKTOCC#: length 8.1
  BOTTOM w0.089: CPU1.A65 98.94,95.18 98.94,96.17 98.28,96.83 98.14,96.83
  BOTTOM w0.102: TP402.1 94.16,97.3 97.56,97.3 98.03,96.83 98.14,96.83
SLEEVE: length 21.3
  TOP w0.203: v3(27.02,20.85) 27.55,20.32 HDA27.18
  TOP w0.305: RN2901.3 26.62,21.25 v3(27.02,20.85)
  TOP w0.508: EC2905.1 20.57,11.45 R2906.2 20.35,10.72 v3(19.76,10.13)
  L3 w1.016: v3(27.02,20.85) 27.02,20.86 24.12,20.86 21.64,18.37 21.64,16.06 19.53,13.95 19.53,11.43 19.76,11.21 v3(19.76,10.13)
  vias: v1(20.85,10.59)
SLEEVE_HPMIC1: length 22.7
  BOTTOM w1.016: HPMIC1.3 5.53,1.74 10.75,1.74 11.94,2.93 11.94,9.84 12.75,10.65 17.1,10.65 v3(18.09,9.65)
  vias: v1(17.95,11.58)
SLP_LAN#: length 1.3
  TOP w0.127: v2(127.16,75.05) 127.16,74.47 TP1704.1
  BOTTOM w0.127: CPU1.AW15 127.12,75.01 v2(127.16,75.05)
SM_DRAMRST#: length 30
  TOP w0.127: v2(146.77,69.31) v1(147.64,68.43) 148.26,67.81 D502.2 148.31,67.39 R505.2 R504.1
  L3 w0.127: v2(128.03,76.55) 127.76,76.28 127.76,76.28 127.62,76.14 127.62,74.86 130.4,72.08 130.4,71.36 132.39,69.37 134.45,69.37 134.63,69.55 139.62,69.55 141.37,67.81 145.26,67.81 v2(146.77,69.31)
  BOTTOM w0.127: CPU1.AT13 128.35,76.22 v2(128.03,76.55)
SM_INTRUDER#: length 33.4
  TOP w0.102: R1730.2 152.55,67.44 151.7,68.29 v1(151.25,68.29) 150.64,68.29 v2(150.16,68.77)
  L3 w0.102: v2(127.11,77.2) 126.71,76.81 126.71,74.57 132.15,69.13 134.55,69.13 134.73,69.31 139.52,69.31 141.27,67.56 145.57,67.56 146.77,68.77 v2(150.16,68.77)
  BOTTOM w0.102: CPU1.AP16 126.79,77.52 127.12,77.19 127.12,77.2 v2(127.11,77.2)
SM_PGCNTL: length 110.2
  TOP w0.127: v2(96.97,72.95) 96.97,73.79 96.53,74.22 95.99,74.22 95.04,73.27 94.12,73.27 93.55,72.7 v2(91.79,72.7) ; v2(46.97,28.45) 47.97,27.44 PR5109.2
  L3 w0.127: v2(46.97,28.45) 46.97,28.79 49.57,31.4 50.38,31.4 52.36,33.38 52.36,55.46 47.95,59.88 44.95,59.88 v2(44.56,60.27)
  L4 w0.127: v2(72.54,70.92) 62.07,60.44 49.64,60.44 49.02,61.07 45.37,61.07 v2(44.56,60.27)
  BOTTOM w0.127: v2(96.97,72.95) 97.18,73.16 97.18,74.19 CPU1.AW67 ; v2(72.54,70.92) v1(72.54,69.7) 72.54,69.01 76.51,65.04 83.94,65.04 86.83,67.93 89.59,67.93 91.35,69.69 91.35,72.22 91.79,72.65 v2(91.79,72.7)
SM_RCOMP_0: length 0.6
  BOTTOM w0.305: CPU1.AR18 126.06,77.2 v2(126.2,77.2)
  vias: v1(125.62,77.17)
SM_RCOMP_1: length 0.6
  BOTTOM w0.305: CPU1.AT18 125.41,76.55 v2(125.28,76.55)
  vias: v1(124.69,76.05)
SM_RCOMP_2: length 0.6
  BOTTOM w0.305: v2(125.28,75.9) 125.41,75.9 CPU1.AU18
  vias: v1(125.24,74.51)
SMBC_THERM_NV: length 29.5
  L4 w0.127: v2(217.76,146.55) 217.76,146.55 217.21,146.55 210.82,140.17 210.78,140.17 210.28,139.67 209.4,139.67 208.34,138.61 201.91,138.61 v2(201.45,138.16)
  BOTTOM w0.14: GPU1.D9 201.06,138.55 v2(201.45,138.16) ; v2(217.76,146.55) 217.76,146.81 218.28,147.32 Q7601.1 218.54,148.05 218.85,148.36 218.85,151 218.66,151.18 217.92,151.18 217.71,151.39 217.71,152.07 217.53,152.25 RN7601.2 217.13,152.58 v1(217.9,153.35)
SMBCLK1: length 212.1
  TOP w0.14: RN4302.3 157.6,170.98 158.68,169.89 D4306.3 160.9,168.18 160.84,168.11 EC4309.1 160.84,165.78 160.47,165.4 v1(158.72,165.4) 157.03,165.4 v2(155.91,164.29) ; v2(185.66,74.14) 185.67,74.13 185.74,74.13 187.35,72.53 187.35,72.17 188.1,71.41 KBC24.9
  L3 w0.127: v2(182.84,98.15) 182.84,98.16 182.83,98.17 179.53,98.17 176.89,100.8 175.07,100.8 174.09,101.78 173.67,102.2 172.82,102.2 171.86,101.24 166.98,101.24 166.72,100.98 160.06,100.98 v2(159.55,101.49)
  L4 w0.127: v2(99.03,164.74) 99.09,164.79 99.09,165.35 101.12,167.38 104.78,167.38 106.73,169.32 106.73,169.8 107.83,170.91 108.7,170.91 109.18,171.39 114.57,171.39 114.86,171.1 115.69,170.27 118.3,170.27 119.06,169.51 119.43,169.51 119.66,169.74 121.06,169.74 122.26,170.94 124.84,170.94 126.16,169.62 128.63,169.62 129.45,170.44 134.74,170.44 134.9,170.6 148.77,170.6 152.85,166.52 153.68,166.52 v2(155.91,164.29) 156.41,163.79 156.41,161.05 158.99,158.48 158.99,155.86 157.7,154.57 157.7,152.46 155.4,150.17 155.4,148.89 155.9,148.4 155.9,146.17 156.22,145.85 157.11,144.97 157.19,144.88 157.19,141.14 157.19,135.58 158.08,134.69 158.08,130.77 159.47,129.38 159.47,127.92 159.47,127.92 159.47,126.63 159.47,126.63 159.47,120.32 159.64,120.14 159.64,119.76 160.48,118.92 160.48,108.88 160.15,108.56 160.15,108.09 159.86,107.8 159.66,107.59 159.66,104.7 159.66,104.06 159.55,103.94 v2(159.55,101.49) ; v2(185.66,74.14) 185.52,74.27 185.52,74.87 185.22,75.17 185.22,81.55 185.01,81.76 185.01,83.63 181.64,87.01 181.64,92.22 182.65,93.23 182.65,97.97 v2(182.84,98.15)
  BOTTOM w0.14: PG4410.2 99.03,161.94 v2(99.03,164.74) 99.15,164.86 PR4412.2 ; RN2402.3 185.07,71.06 185.31,71.3 185.31,73.79 v2(185.66,74.14)
SMBCLK2: length 38.3
  TOP w0.14: v2(187.49,72.98) 187.52,73.01 188.02,73.01 188.43,72.61 KBC24.12
  L3 w0.127: v2(160.01,75.21) 161.72,75.21 162.15,75.65 165.93,75.65 165.93,75.65 168.45,75.65 169.67,76.87 170.46,76.87 171.67,75.66 174.72,75.66 175.5,76.44 178.45,76.44 179.03,75.86 180.57,75.86 180.71,75.72 181.17,75.72 182.26,74.63 186.01,74.63 187.49,73.15 v2(187.49,72.98)
  BOTTOM w0.14: RN2603.4 187.99,73.78 187.49,73.28 v2(187.49,72.98) 187.23,72.72 v1(187.23,72.1) ; Q2604.3 161.35,75.76 160.89,76.22 160.05,76.22 R2483.1 159.82,75.4 v2(160.01,75.21)
SMBD_THERM_NV: length 29.4
  TOP w0.14: v1(201.05,137.73) 201.42,137.36 v2(201.42,137.29)
  L4 w0.127: v2(216.46,147.31) 218.03,147.31 218.38,146.95 218.38,146.2 217.71,145.52 216.91,145.52 211.19,139.8 211.17,139.8 210.54,139.16 209.61,139.16 208.53,138.08 202.75,138.08 202.42,137.75 201.87,137.75 v2(201.42,137.29)
  BOTTOM w0.14: v2(201.42,137.29) 201.42,137.32 201.05,137.68 GPU1.D8 ; RN7601.1 217.13,151 216.97,150.84 Q7601.4 216.97,149.36 216.28,148.66 216.28,147.49 v2(216.46,147.31)
SMBDA1: length 207.1
  TOP w0.14: v2(155.88,165.1) 156.01,165.1 v1(156.43,165.52) 156.9,165.99 EC4310.1 156.9,168.5 156.84,168.56 D4305.3 156.84,170.84 157.1,171.1 RN4302.2 ; KBC24.8 188.38,71.01 188.23,71.16 188.01,71.16 185.77,73.4 v2(185.77,73.43)
  L3 w0.127: v2(182.75,98.92) 182.5,98.68 179.74,98.68 177.1,101.31 175.28,101.31 173.88,102.71 172.79,102.71 171.7,101.62 166.82,101.62 166.56,101.36 161.29,101.36 v2(160.71,101.94)
  L4 w0.127: v2(98.32,164.72) 98.32,165.3 100.91,167.88 104.57,167.88 106.22,169.53 106.22,170.01 107.62,171.42 108.49,171.42 108.97,171.9 114.78,171.9 115.37,171.31 115.9,170.78 120.03,170.78 120.41,170.4 121,170.4 122.05,171.45 125.05,171.45 126.37,170.12 128.42,170.12 129.24,170.95 134.53,170.95 134.69,171.11 148.98,171.11 152.94,167.15 153.83,167.15 v2(155.88,165.1) 156.92,164.05 156.92,161.26 159.49,158.69 159.49,155.65 158.2,154.36 158.2,150.17 156.41,148.37 156.41,146.38 157.7,145.09 157.7,140.93 157.7,135.79 158.59,134.9 158.59,130.98 159.98,129.59 159.98,123.31 159.97,123.31 159.97,120.35 160.02,120.3 160.02,119.95 160.86,119.11 160.86,108.99 161.4,108.45 161.4,103.82 160.71,103.13 v2(160.71,101.94) ; v2(182.75,98.92) 182.14,98.31 182.14,93.3 181.26,92.42 181.26,86.46 184.1,83.62 184.1,82.13 184.84,81.4 184.84,75.01 185.14,74.71 185.14,74.03 185.74,73.43 v2(185.77,73.43)
  BOTTOM w0.14: RN2402.4 185.72,70.89 185.76,70.92 185.76,72.45 185.77,72.47 v2(185.77,73.43) ; PR4411.2 98.26,164.78 v2(98.32,164.72) 98.47,164.57 98.47,161.46 99.45,160.48 PG4409.2
SMBDA2: length 33.8
  TOP w0.14: KBC24.11 187.92,72.21 v2(187.78,72.36)
  L3 w0.127: v2(187.78,72.36) 188,72.58 188,73.36 186.22,75.14 182.47,75.14 181.38,76.23 180.92,76.23 180.78,76.37 179.24,76.37 178.66,76.95 175.29,76.95 174.38,76.04 171.83,76.04 170.53,77.34 169.6,77.34 168.29,76.03 166.57,76.03 v2(166.03,76.57)
  BOTTOM w0.14: RN2603.3 188.64,73.44 188.09,72.89 188.09,72.68 v2(187.78,72.36) ; v2(166.03,76.57) v1(165.45,76.57) 164.78,77.24 R2482.1 163.85,77.24 163.51,76.9 Q2604.6
SML0_SMBCLK: length 26.3
  TOP w0.14: v2(130.75,86.58) 131.23,86.1 131.77,86.1 131.81,86.15 133.18,86.15 135.64,88.6 139.19,88.6 139.8,89.21 144.04,89.21 144.26,88.99 v1(144.8,88.99) 145.45,88.99 146.16,88.28 v2(146.16,88.06)
  L4 w0.127: v2(141.84,84.96) 141.86,84.99 143.39,84.99 146.16,87.75 v2(146.16,88.06)
  BOTTOM w0.14: v2(141.84,84.96) 141.84,84.96 141.84,84.86 142.14,84.56 RN1807.5 ; CPU1.R9 130.75,86.82 v2(130.75,86.58)
SML0_SMBDATA: length 9.9
  BOTTOM w0.089: CPU1.W2 135.32,84.68 135.87,84.68 136.11,84.44 136.47,84.44
  BOTTOM w0.14: 136.47,84.44 136.62,84.44 136.91,84.74 140.37,84.74 v1(140.67,85.04) 141.07,85.44 142.07,85.44 142.53,84.97 142.97,84.97 142.98,84.98 143.25,84.98 143.48,85.21 RN1807.6
SML1_SMBCLK: length 172.2
  TOP w0.14: v2(160.68,77.9) 159.99,77.21 Q2601.3 ; v2(186.35,93.34) 186.18,93.34 185.96,93.57 183.03,93.57 183.03,93.56 177.09,93.56 176.73,93.21 176.32,93.21 175.94,93.59 168.02,93.59 v2(167.53,93.1) ; v2(183.99,115.21) 185.61,115.21 190.41,120.01 196.33,120.01 196.85,119.48 199.42,119.48 201.02,121.08 201.02,124.55 201.46,124.99 202.28,124.99 203.02,124.26 v1(206.8,124.26) 207.33,124.26 208.39,125.31 208.39,125.66 212.46,129.74 213.95,129.74 216.89,132.68 216.89,138.2 213.88,141.21 213.88,144.02 215.87,146 216.74,146 217.22,146.48 217.22,147.93 v2(218.28,148.99)
  L3 w0.127: v2(168.58,86.12) 168.32,86.38 166.56,86.38 165.79,87.16 159.38,87.16 158.88,87.66 158.21,87.66 157.9,87.66 156.66,86.41 156.22,86.41 155.09,85.28 151.77,85.28 151.34,85.71 147.34,85.71 146.88,86.17 146.43,86.17 145.81,85.55 143.19,85.55 v2(143.08,85.44)
  L4 w0.127: v2(183.99,115.21) 184.36,114.84 184.38,114.84 184.74,114.47 184.74,100.75 186.75,98.75 186.75,93.74 v2(186.35,93.34)
  BOTTOM w0.089: CPU1.W3 134.42,84.95 134.69,85.16 134.86,85.16 134.97,85.2 135.17,85.2 135.24,85.17 135.53,85.17 135.65,85.22 136.44,85.22 136.62,85.04 137.01,85.04
  BOTTOM w0.14: Q7601.6 v2(218.28,148.99) ; 137.01,85.04 140.07,85.04 140.75,85.72 142.11,85.72 142.51,85.31 142.95,85.31 v2(143.08,85.44) 143.34,85.71 RN1807.7 ; v2(167.53,93.1) 167.97,92.66 167.97,89.15 168.35,88.77 168.35,88.32 168.4,88.27 168.4,87.81 168.58,87.63 v2(168.58,86.12) 168.58,85.69 168.57,85.68 168.57,84.92 168.7,84.79 168.7,84.28 168.45,84.03 168.45,82.81 168.5,82.76 168.5,82.2 167.82,81.52 167.82,80.55 167.33,80.07 167.33,78.19 166.35,77.2 165.7,77.2 165.07,77.83 163.9,77.83 163.83,77.9 v2(160.68,77.9) 160.4,77.9 R2483.2 160.24,76.9 Q2604.4
SML1_SMBDATA: length 173.6
  TOP w0.14: v2(159.76,73.74) 159.79,73.77 159.79,74.32 158.9,75.2 158.42,75.2 158.11,75.52 Q2601.6 ; v2(170.44,91.93) 171.01,91.36 178.11,91.36 179.75,93 183.26,93 183.26,93.01 185.64,93.01 186.05,92.6 v2(186.47,92.6) ; v2(183.41,115.76) 185.38,115.76 189.43,119.81 189.43,119.82 189.8,120.19 190.18,120.57 196.56,120.57 197.08,120.04 199.19,120.04 200.46,121.31 200.46,124.78 201.23,125.55 202.51,125.55 203.25,124.81 207.09,124.81 207.94,125.66 207.94,125.82 v1(208.89,126.78) 212.3,130.18 213.61,130.18 216.33,132.91 216.33,137.97 213.32,140.98 213.32,144.25 215.64,146.56 v2(216.45,146.56)
  L3 w0.127: v2(169.08,86.75) 168.94,86.89 166.77,86.89 166.12,87.54 159.54,87.54 159.04,88.04 158.51,88.04 157.75,88.04 156.5,86.79 156.06,86.79 154.93,85.66 151.93,85.66 151.5,86.09 147.5,86.09 147.04,86.55 146.27,86.55 145.66,85.93 142.67,85.93 v2(142.58,85.84)
  L4 w0.127: v2(183.41,115.76) 183.46,115.71 184.22,115.71 185.25,114.68 185.25,100.96 187.26,98.96 187.26,93.38 v2(186.47,92.6)
  BOTTOM w0.089: 136.96,85.29 136.63,85.29 136.51,85.41 135.65,85.41 135.6,85.39 135.48,85.35 135.28,85.35 135.21,85.38 134.93,85.38 134.83,85.35 134.35,85.35 CPU1.V3
  BOTTOM w0.14: v2(159.76,73.74) 159.78,73.72 159.79,73.72 159.82,73.69 162.25,73.69 162.65,74.09 Q2604.1 163.27,75.02 R2482.2 164.25,76.01 166.11,76.01 166.67,76.57 166.67,76.92 167.76,78.01 167.76,79.89 168.3,80.42 168.3,81.36 168.93,82 168.93,82.94 168.88,82.99 168.88,83.85 169.13,84.1 169.13,84.97 169.08,85.02 v2(169.08,86.75) 169.11,86.78 169.11,87.7 168.83,87.99 168.83,88.45 168.78,88.5 168.78,90.12 168.4,90.5 168.4,90.99 168.68,91.27 169.1,91.27 169.76,91.93 v2(170.44,91.93) ; RN1807.8 143.4,86.36 142.88,85.84 v2(142.58,85.84) 142.42,86 140.6,86 139.89,85.29 136.96,85.29 ; Q7601.3 216.97,147.17 216.45,146.65 v2(216.45,146.56)
SP_PLLVDD: length 1.1
  BOTTOM w0.305: v2(193.21,135.62) 193.21,135.63 GPU1.N6 ; v2(193.99,135.6) 194.39,136 GPU1.M6
  vias: v1(193.07,134.4)
SPI0_MOSI_XDP: length 3.5
  BOTTOM w0.14: TP9905.1 144.02,64.33 143.08,65.27 143.08,65.8 142.98,65.89 R1826.1
SPI1_CLK_ROM_R: length 8
  BOTTOM w0.14: SPI252.6 147.63,45.05 147.54,45.13 147.54,45.63 147.38,45.79 147.16,45.79 147,45.63 147,43.87 146.84,43.71 146.61,43.71 146.45,43.87 146.45,45.46 146.31,45.6 EC2505.1 R2511.1
SPI1_HOLD_ROM_R: length 9.7
  BOTTOM w0.14: SKT26.7 151.68,46.32 152.07,46.71 R2509.1 152.54,51.65 152.73,51.85 RN2502.2
SPI1_SI_ROM_R: length 8.2
  BOTTOM w0.14: R2512.1 EC2506.1 146.5,43.2 147.15,43.2 147.35,43 147.35,42.33 147.48,42.2 149.63,42.2 149.82,42.39 149.82,42.67 149.63,42.86 148.99,42.86 148.79,43.06 SPI252.5
SPI1_SO_ROM_R: length 10.3
  BOTTOM w0.14: SPI252.2 157.33,46.32 157.71,46.69 157.71,48.39 157.4,48.69 157.4,51.4 156.77,52.03 156.77,52.55 v1(156.78,52.55) 156.78,52.59 156.46,52.9 EC2504.1 156.16,53.75 R2513.2
SPI1_WP_ROM_R: length 12
  BOTTOM w0.14: R2514.2 152.13,54.31 v1(152.13,53.69) 152.13,53.45 152.94,52.64 152.94,52.63 153.15,52.42 153.79,52.42 153.97,52.24 RN2502.1 153.97,46.09 155.01,45.05 SKT26.3
SPI_CLK_CPU: length 14.2
  BOTTOM w0.089: 136.59,74.18 136.09,74.68 135.56,74.68 135.27,74.97 CPU1.AV2
  BOTTOM w0.14: R1806.2 144.17,67.46 141.47,67.46 139.49,69.45 139.49,69.85 138.22,71.12 138.22,72.54 136.59,74.18
SPI_CLK_ROM: length 226.1
  TOP w0.14: v2(145.81,52.13) 145.81,52.39 146.01,52.59 146.64,52.59 146.84,52.39 146.84,52.18 147.02,52 147.28,52 147.46,52.18 147.46,52.76 147.66,52.95 148.22,52.95 148.34,53.08 148.34,53.12 148.48,53.26 148.72,53.26 148.86,53.4 148.86,53.67 148.72,53.81 148.48,53.81 148.34,53.95 148.34,54.96 148.18,55.12 147.96,55.12 147.8,54.96 147.8,53.7 147.64,53.54 147.41,53.54 147.25,53.7 147.25,54.64 147.09,54.8 141.59,54.8 141.46,54.67 141.46,54.37 141.59,54.24 146.55,54.24 146.68,54.11 146.68,53.81 146.55,53.68 140.41,53.68 140.28,53.81 R2505.2 ; R2485.1 192.16,81.72 192.61,81.72 v2(192.71,81.63) ; v2(167.28,18.2) 166.79,17.71 165.75,17.71 165.41,17.37 v1(155.11,17.37) v2(151.11,17.37)
  L3 w0.127: v2(187.92,53.44) 187.92,52.68 184.56,49.33 178.06,49.33 177.64,49.75 176.68,49.75 176.48,49.55 175.04,49.55 174.28,50.3 168.64,50.3 168.29,50.65 166.11,50.65 165.74,50.28 160.95,50.28 159.24,51.98 150.53,51.98 150.32,51.77 147.15,51.77 146.79,52.13 v2(145.81,52.13)
  L4 w0.127: v2(144.24,60.99) 144.24,60.77 144.69,60.32 144.69,59.08 145.84,57.94 145.84,53.43 146.15,53.12 146.15,52.75 145.81,52.4 v2(145.81,52.13) 145.81,51.44 147.51,49.74 147.51,43.96 148.91,42.56 148.91,27.51 148.06,26.66 148.06,17.96 148.21,17.81 148.42,17.81 148.57,17.96 148.57,22.65 148.72,22.8 148.93,22.8 149.08,22.65 149.08,16.93 149.28,16.73 150.47,16.73 v2(151.11,17.37)
  BOTTOM w0.14: v2(144.24,60.99) 144.29,60.99 144.92,61.61 144.92,65.59 144.63,65.87 R1806.1 ; v2(187.92,53.44) 187.92,54.53 187.98,54.59 187.98,59.33 189.13,60.48 189.13,60.7 191.06,62.63 191.06,67.4 191.07,67.4 191.07,67.98 190.97,68.08 190.97,72.88 191.3,73.22 191.3,79.87 191.61,80.17 191.61,81.2 192.04,81.63 v2(192.71,81.63) ; v2(145.81,52.13) 145.81,52.14 146.45,52.14 146.81,51.78 147.07,51.78 147.24,51.62 147.24,51.38 147.07,51.21 146.63,51.21 146.27,50.86 146.27,50.19 146.13,50.05 145.63,50.05 145.49,49.91 145.49,49.63 145.63,49.49 146.08,49.49 146.24,49.32 146.24,49.09 146.08,48.93 145.63,48.93 145.49,48.79 145.49,48.51 145.63,48.37 146.11,48.37 146.31,48.17 146.31,47.9 146.11,47.71 144.87,47.71 144.74,47.58 144.74,47.27 144.87,47.15 146.68,47.15 146.83,47.3 146.83,50.61 146.96,50.74 147.26,50.74 147.39,50.61 147.39,48.74 147.52,48.61 147.82,48.61 147.95,48.74 147.95,50.62 148.08,50.75 148.38,50.75 148.51,50.62 148.51,48.29 148.38,48.16 147.66,48.16 147.53,48.03 147.53,46.34 147.4,46.21 145.83,46.21 145.69,46.35 145.69,46.55 145.55,46.69 145.27,46.69 145.13,46.55 145.13,46.35 144.99,46.21 144.71,46.21 144.57,46.35 144.57,46.55 144.43,46.69 144.15,46.69 144.01,46.55 144.01,46.35 143.87,46.21 143.34,46.21 143.22,46.08 143.22,44.64 143.34,44.52 144.49,44.52 144.73,44.76 R2511.2 ; v2(167.28,18.2) 167.28,18.38 166.64,19.02 R9107.1
SPI_CLK_ROM_R: length 12.8
  TOP w0.14: v1(134.3,54.86) 134.58,54.58 v2(135.24,54.58) 135.97,54.58 136.11,54.72 136.11,55.37 136.27,55.53 136.5,55.53 136.67,55.37 136.67,54.31 136.79,54.18 137.1,54.18 137.23,54.31 137.23,55.37 137.39,55.54 137.62,55.54 137.79,55.37 137.79,54.61 137.91,54.48 139.34,54.48 139.47,54.61 EC2503.1 139.86,55.35 139.87,55.36 R2505.1
  BOTTOM w0.14: v2(135.24,54.58) 135.46,54.36 SPI25.6
SPI_CLK_ROM_TPM: length 3.8
  BOTTOM w0.14: v1(167.57,19.7) 167.57,19.85 166.64,20.78 R9107.2 166.64,20.98 166.96,21.29 166.96,22.33 166.86,22.43 U9101.19
SPI_CS2#_R: length 121.2
  TOP w0.14: v2(165.22,19.11) 164.48,18.36 v1(154.35,18.36) 151.41,18.36 v2(151.13,18.65)
  L4 w0.127: v2(151.13,18.65) 151.02,18.75 151.02,21.9 149.67,23.25 149.67,23.93 149.55,24.05 149.07,24.05 148.94,24.18 148.94,24.43 149.07,24.56 149.55,24.56 149.67,24.69 149.67,24.94 149.55,25.07 149.07,25.07 148.94,25.2 148.94,25.45 149.07,25.58 149.55,25.58 149.67,25.7 149.67,25.96 149.55,26.08 149.07,26.08 148.94,26.21 148.94,26.47 149.07,26.59 149.55,26.59 149.67,26.72 149.67,42.88 149.29,43.26 149.29,49.13 149.11,49.31 148.93,49.31 148.78,49.16 148.78,46.3 148.64,46.16 148.42,46.16 148.28,46.3 148.28,50.14 147.07,51.35 147.07,51.66 147.07,51.67 147.07,55.2 147.2,55.32 147.2,56.3 146.71,56.78 v2(146.71,57.34) ; v2(165.22,19.11) 165.22,20.45 165.65,20.88 168.27,20.88 168.85,21.47 168.85,26.19 v2(169.58,26.92)
  BOTTOM w0.14: R1816.1 140.94,74.2 141.25,73.89 143.89,73.89 145.92,71.86 145.92,69.51 148,67.43 148,64.23 146.83,63.06 146.83,62.57 146.71,62.45 v2(146.71,57.34) ; v2(165.22,19.11) 165.22,20.18 R9103.1 165.87,20.79 166.54,21.47 166.54,22.16 166.36,22.34 U9101.20 ; Q9102.G 157.1,29.11 157.57,28.64 157.57,27.94 157.02,27.39 157.02,23.59 R9115.2 157.36,22.88 157.14,22.66 156.43,22.66 153.56,19.79 151.79,19.79 151.12,19.13 151.12,18.65 v2(151.13,18.65) ; R9116.2 170.02,27.36 v2(169.58,26.92)
SPI_CS_CPU_N0: length 17.3
  BOTTOM w0.089: 137.08,75.04 136.9,75.22 134.9,75.22 134.46,75.66 CPU1.AU3
  BOTTOM w0.14: 137.08,75.04 137.72,74.4 137.72,73.78 138.69,72.81 138.69,71.22 139.96,69.95 139.96,69.59 141.64,67.91 144.51,67.91 v1(145.59,66.83) 145.59,66.02 R1812.2
SPI_CS_CPU_N1: length 5
  BOTTOM w0.089: 137.34,75.32 137.26,75.4 135.33,75.4 CPU1.AU2
  BOTTOM w0.14: 137.34,75.32 137.98,74.68 137.98,74.26 R1828.2
SPI_CS_ROM_N0: length 174.6
  TOP w0.14: v2(193.04,78.29) 193.01,78.29 193.01,78.28 192.24,79.06 R2490.1
  L3 w0.127: v2(188.85,53.71) 188.85,53.11 189.05,52.9 189.37,52.9 189.57,53.11 189.57,54.42 189.45,54.54 188.28,54.54 187.4,53.67 187.4,52.7 184.41,49.71 178.72,49.71 177.7,50.72 177.12,50.72 176.32,49.93 175.19,49.93 174.44,50.68 168.79,50.68 168.39,51.09 166.02,51.09 165.9,51.2 165.52,51.2 165.4,51.07 165.4,50.81 165.27,50.68 165.02,50.68 164.89,50.81 164.89,51.07 164.76,51.2 164.51,51.2 164.38,51.07 164.38,50.81 164.25,50.68 164,50.68 163.87,50.81 163.87,51.07 163.75,51.2 163.49,51.2 163.37,51.07 163.37,50.81 163.24,50.68 162.98,50.68 162.86,50.81 162.86,51.07 162.73,51.2 160.8,51.2 159.64,52.37 150.31,52.37 150.16,52.51 150.16,52.72 150.31,52.87 152.22,52.87 152.35,53 152.35,53.25 152.22,53.38 149.96,53.38 149.53,52.95 149.13,52.95 148.87,53.21 148.87,53.21 147.64,54.43 147.64,54.61 148.15,55.12 148.15,55.3 147.98,55.48 147.8,55.48 147.28,54.97 147.1,54.97 146.93,55.15 146.93,55.33 147.59,56 147.59,56.2 147.43,56.36 147.23,56.36 146.57,55.69 146.39,55.69 146.3,55.78 146.09,55.78 145.94,55.63 145.94,55.42 148.08,53.28 148.08,53.07 147.93,52.92 147.72,52.92 146.26,54.37 146.05,54.37 145.9,54.22 145.9,54.01 147.01,52.91 147.01,52.73 146.83,52.55 146.65,52.55 146.28,52.92 144.96,52.92 144.38,53.5 144.38,56.23 144.25,56.36 143.22,56.36 143.09,56.49 143.09,56.74 143.22,56.87 144.25,56.87 144.38,56.99 144.38,57.3 144.53,57.45 144.74,57.45 144.88,57.3 144.88,53.67 145.03,53.52 145.24,53.52 145.39,53.67 145.39,56.4 145.52,56.52 146.38,56.52 146.5,56.65 146.5,56.9 146.38,57.03 145.52,57.03 145.39,57.16 v2(145.39,57.75)
  BOTTOM w0.14: v2(193.04,78.29) 192.97,78.22 192.97,74.93 193.5,74.4 193.5,73.19 193.19,72.87 193.19,71.94 192.81,71.56 192.76,71.56 v1(192.65,71.45) 192.61,71.45 192.23,71.07 192.23,68.6 192.32,68.5 192.32,66.87 192.32,61.26 190.01,58.95 190.01,54.87 v2(188.85,53.71) ; SPI25.1 144.97,56.9 145.46,56.41 146.43,56.41 146.83,56.01 R2501.1 147.05,56.6 146.77,56.88 146.51,56.88 145.65,57.75 v2(145.39,57.75) 144.85,57.75 144.71,57.89 144.71,58.38 144.57,58.52 144.3,58.52 144.16,58.38 144.16,57.89 144.02,57.75 143.75,57.75 143.61,57.89 143.61,58.38 143.47,58.52 143.21,58.52 143.07,58.38 143.07,57.89 142.93,57.75 142.13,57.75 141.92,57.55 141.92,55.85 141.8,55.73 141.3,55.73 141.17,55.85 141.17,56.8 141.03,56.94 140.52,56.94 140.38,57.08 140.38,57.34 140.52,57.48 141.03,57.48 141.17,57.62 141.17,59.34 141.3,59.47 141.56,59.47 141.69,59.59 141.69,60.54 141.81,60.66 142.12,60.66 142.25,60.54 142.25,59.59 142.37,59.47 142.62,59.47 142.78,59.31 144.72,59.31 144.85,59.44 144.85,59.74 144.72,59.87 144.17,59.87 144.05,60 144.05,60.3 144.17,60.43 144.61,60.43 144.75,60.57 144.75,60.84 144.87,60.97 145.18,60.97 145.31,60.84 145.31,58.65 145.46,58.49 146.15,58.49 146.29,58.63 146.29,58.91 146.15,59.05 146,59.05 145.86,59.19 145.86,59.47 146,59.61 146.15,59.61 146.29,59.75 146.29,60.03 146.15,60.17 146,60.17 145.86,60.31 145.86,60.59 146,60.73 146.17,60.73 146.29,60.85 146.29,61.16 146.17,61.29 146,61.29 145.86,61.43 145.86,61.73 145.73,61.87 145.47,61.87 145.34,61.99 145.34,62.3 145.47,62.43 145.73,62.43 145.86,62.57 145.86,63.12 145.99,63.25 146.42,63.25 146.92,63.74 146.92,67.9 145.35,69.46 145.17,69.46 144.74,69.03 144.74,68.85 146.25,67.35 146.25,63.84 146.12,63.71 145.66,63.71 145.47,63.9 R1812.1
SPI_CS_ROM_N1: length 67.5
  L4 w0.127: v2(149.75,54.94) 149.75,56.72 149.35,57.12 148.13,57.12 147.92,57.32 147.92,58.01 147.47,58.46 147.47,62.02 147.25,62.24 146.17,62.24 145.88,62.53 145.88,63.36 144.79,64.45 144.79,65.08 144.66,65.21 144.14,65.21 144.02,65.33 144.02,65.61 144.14,65.74 144.66,65.74 144.79,65.87 144.79,66.15 144.66,66.27 142.81,66.27 142.67,66.41 142.67,66.67 142.81,66.81 144.66,66.81 144.79,66.94 144.79,67.21 144.66,67.34 140.26,67.34 140.11,67.5 140.11,67.72 140.26,67.87 140.57,67.87 140.7,68 140.7,68.6 140.82,68.72 141.1,68.72 141.23,68.6 141.23,68 141.36,67.87 144.66,67.87 144.79,68 144.79,68.28 144.66,68.41 144.31,68.41 144.15,68.56 144.15,68.79 144.31,68.94 144.66,68.94 144.79,69.07 144.79,69.42 145.1,69.73 145.1,70.15 v2(145.47,70.51)
  BOTTOM w0.14: v2(145.47,70.51) 145.47,71.72 143.72,73.47 141.48,73.47 141.37,73.36 R1828.1 ; SKT26.1 156.06,47.9 156.06,49.3 155.92,49.44 155.64,49.44 155.5,49.3 155.5,48.46 155.36,48.32 155.08,48.32 154.94,48.46 154.94,49.86 155.08,50 155.92,50 156.06,50.14 R2515.1 156.06,52.07 155.81,52.31 155.81,52.74 154.86,53.69 154.86,54.47 v1(154.69,54.65) 153.76,55.58 153.76,56.07 153.59,56.24 150.09,56.24 149.96,56.11 149.96,55.81 150.09,55.68 152.58,55.68 152.7,55.55 152.7,55.25 152.58,55.12 149.93,55.12 v2(149.75,54.94)
SPI_HOLD_CPU: length 9.3
  BOTTOM w0.089: 136.06,75.88 135.91,75.88 135.85,75.94 134.04,75.94 CPU1.AU4
  BOTTOM w0.14: v1(141.18,76.48) R1811.2 140.78,75.09 140.74,75.05 R1835.2 140.14,75.05 R1836.1 138.46,75.05 137.63,75.88 136.06,75.88
SPI_HOLD_ROM: length 54.4
  TOP w0.14: R2503.2 147.27,55.87 149.52,55.87 150.55,54.84 v2(150.55,53.96) ; v1(148.43,70.02) 148.22,70.23 v2(147.84,70.23)
  L4 w0.127: v2(150.55,53.96) 150.86,54.27 150.86,56.69 148.62,58.93 148.62,63.32 146.69,65.24 146.69,67.6 148,68.91 148,69.94 147.84,70.1 v2(147.84,70.23)
  BOTTOM w0.14: v2(150.55,53.96) 150.65,53.96 150.71,53.9 151.46,53.9 151.71,53.65 151.71,52.9 R2509.2 ; R1811.1 142.07,74.48 142.24,74.31 144.06,74.31 144.24,74.13 144.44,74.13 145,74.7 145.19,74.7 145.38,74.5 145.38,74.31 144.82,73.75 144.82,73.55 145.01,73.36 145.21,73.36 145.61,73.77 145.87,73.77 146,73.64 146.55,73.64 146.68,73.76 146.68,74.94 147.3,75.56 150.01,75.56 150.18,75.4 150.18,74.72 150.01,74.55 149.29,74.55 148.95,74.89 147.81,74.89 147.68,74.76 147.68,74.46 147.84,74.3 148.85,74.3 148.98,74.17 148.98,73.83 148.85,73.71 147.73,73.71 147.61,73.58 147.61,73.32 147.48,73.19 145.78,73.19 145.66,73.06 145.66,72.76 145.78,72.63 147.18,72.63 147.3,72.5 147.3,71.8 146.91,71.4 146.91,70.9 147.14,70.67 147.41,70.67 v2(147.84,70.23)
SPI_HOLD_ROM_R: length 29.7
  TOP w0.14: v2(141.66,55.27) v1(143.68,55.27) 145.78,55.27 R2503.1 148.07,57.56 v2(148.38,57.56)
  L4 w0.127: v2(148.38,57.56) 148.38,58.09 147.85,58.61 147.85,63 145.93,64.93 145.93,68.15 146.26,68.48 146.26,69.51 v2(146.97,70.23)
  BOTTOM w0.14: v2(141.66,55.27) 139.33,55.27 138.98,55.63 SKT25.7 ; RN2501.2 148.49,70.01 148.26,69.78 147.67,69.78 147.64,69.81 147.39,69.81 v2(146.97,70.23)
SPI_IRQ#: length 2.2
  BOTTOM w0.102: R9104.1 167.51,21.63 v1(167.44,21.7) 167.36,21.78 167.36,22.57 U9101.18
SPI_SI_CPU: length 14.2
  BOTTOM w0.089: 136.17,74.18 135.85,74.5 135.41,74.5 135.24,74.67 134.39,74.67 CPU1.AV3
  BOTTOM w0.14: 136.17,74.18 137.73,72.62 137.73,71.11 139.03,69.81 139.03,69.47 139.67,68.84 139.67,68.67 139.84,68.49 139.84,68.47 R1824.2 R1825.1 142.97,66.98 R1826.2 142.99,66.99 R1808.2
SPI_SI_ROM: length 217
  TOP w0.14: R2486.1 v2(192.77,79.91) ; v2(151.1,18.01) 151.16,17.94 v1(157.02,17.94) 164.97,17.94 165.23,18.2 v2(166.42,18.2) ; R2506.2 142.49,53.14 142.63,53 142.63,52.25 142.76,52.13 143.07,52.13 143.19,52.25 143.19,53 143.33,53.14 144.52,53.14 145.34,52.32 145.34,52.14 145.12,51.92 144.94,51.92 144.17,52.7 143.99,52.7 143.77,52.48 143.77,52.3 144.71,51.36 145.61,51.36 145.92,51.05 151.53,51.05 151.66,51.18 151.66,51.58 151.53,51.71 151.35,51.71 151.21,51.85 151.21,53.38 151.08,53.5 150.77,53.5 150.65,53.38 150.65,51.85 150.51,51.71 150.23,51.71 150.09,51.85 150.09,52.97 149.96,53.1 149.66,53.1 149.53,52.97 149.53,51.85 149.39,51.71 149.11,51.71 148.97,51.85 148.97,52.03 148.83,52.17 148.55,52.17 148.41,52.03 148.41,51.85 148.13,51.57 v2(146.31,51.57)
  L3 w0.127: v2(146.31,51.57) 146.34,51.54 146.84,51.54 146.99,51.39 150.48,51.39 150.52,51.44 159.25,51.44 160.79,49.89 164.56,49.89 164.93,49.53 171.94,49.53 172.19,49.78 174.26,49.78 175.19,48.85 184.64,48.85 v2(188.41,52.62)
  L4 w0.127: v2(144.47,61.8) 144.71,61.8 144.93,61.58 144.93,60.61 145.07,60.48 145.07,59.24 146.27,58.04 146.27,56.19 146.5,55.96 146.69,55.96 146.81,55.83 146.81,55.48 146.69,55.35 146.36,55.35 146.24,55.23 146.24,54.93 146.36,54.81 146.56,54.81 146.69,54.68 146.69,54.39 146.56,54.26 146.36,54.26 146.24,54.13 146.24,53.84 146.36,53.71 146.56,53.71 146.69,53.59 146.69,51.95 v2(146.31,51.57) 147.89,49.98 147.89,44.18 148.04,44.03 148.25,44.03 148.4,44.18 148.4,45.63 148.55,45.78 148.76,45.78 148.91,45.63 148.91,43.1 149.29,42.72 149.29,27.36 148.44,26.5 148.44,23.82 149.46,22.81 149.46,17.33 149.6,17.18 149.82,17.18 149.96,17.33 149.96,21.89 150.11,22.04 150.32,22.04 150.47,21.89 150.47,18.22 150.69,18.01 v2(151.1,18.01)
  BOTTOM w0.14: R2512.2 144.2,43.03 142.32,44.91 142.32,45.11 142.79,45.58 142.79,45.76 142.58,45.98 142.4,45.98 141.92,45.5 141.74,45.5 141.53,45.72 141.53,45.9 142.22,46.59 142.22,46.77 142,46.99 141.1,46.99 140.92,47.17 140.92,47.43 141.1,47.61 142.52,47.61 142.65,47.49 142.65,46.79 142.77,46.67 143.52,46.67 143.76,46.9 143.76,48 143.88,48.13 144.93,48.13 145.06,48.26 145.06,49.77 144.89,49.94 144.89,51.91 144.76,52.04 144.46,52.04 144.33,51.91 144.33,50.31 144.2,50.18 143.89,50.18 143.76,50.31 143.76,52.24 143.98,52.46 145.18,52.46 145.31,52.33 145.31,50.6 145.43,50.47 145.73,50.47 145.85,50.6 145.85,51.45 145.98,51.57 v2(146.31,51.57) ; v2(166.42,18.2) 166.41,18.19 R9105.1 ; v2(192.77,79.91) 192.14,79.28 192.14,72.87 191.81,72.54 191.81,68.43 191.9,68.33 191.9,67.05 191.9,61.43 189.43,58.96 189.43,55.33 188.37,54.27 188.37,52.67 v2(188.41,52.62) ; v2(144.47,61.8) 144.47,65.43 R1808.1
SPI_SI_ROM_R: length 12.7
  TOP w0.14: R2506.1 140.54,53.14 140.52,53.15 EC2501.1 140.11,52.77 140,52.66 138.64,52.66 138.51,52.79 138.51,53.51 138.35,53.68 138.12,53.68 137.95,53.51 137.95,52.8 137.83,52.67 137.52,52.67 137.39,52.8 137.39,53.61 137.27,53.74 136.96,53.74 136.83,53.61 136.83,52.79 136.71,52.66 136.37,52.66 136.25,52.79 136.25,53.7 v1(136.04,53.9) v2(135.28,53.9)
  BOTTOM w0.14: SPI25.5 136.1,53.09 v2(135.28,53.9)
SPI_SI_ROM_TPM: length 5.5
  BOTTOM w0.14: U9101.21 165.86,21.91 v1(166.08,21.7) 165.83,21.45 165.7,21.45 165.57,21.31 164.7,20.44 164.7,18.33 R9105.2
SPI_SO_CPU: length 10.9
  BOTTOM w0.089: 136.44,72.98 136.15,73.27 135.32,73.27 135.21,73.38 135.03,73.38 134.8,73.62 134.8,74.05 CPU1.AW3
  BOTTOM w0.14: v1(136.65,66.1) 136.65,66.78 R1807.2 137.86,67.99 137.86,68.73 137.99,68.86 137.99,69.93 136.75,71.17 136.75,72.68 136.44,72.98
SPI_SO_ROM: length 217.7
  TOP w0.14: R2487.1 v2(192.76,80.74) ; v2(151.71,18.97) 151.85,18.83 v1(156.05,18.83) 162.02,18.83 v2(162.38,19.19)
  L3 w0.127: v2(188.43,55.23) 188.42,55.23 187.02,53.83 187.02,52.86 186.55,52.39 183.79,52.39 183.63,52.23 183.63,52.01 183.79,51.86 185.43,51.86 185.59,51.7 185.59,51.48 185.43,51.32 183.53,51.32 183.38,51.17 183.38,50.95 183.53,50.79 184.32,50.79 184.48,50.63 184.48,50.41 184.32,50.26 182.87,50.26 182.75,50.38 182.75,51.87 182.62,51.99 182.34,51.99 182.21,51.87 182.21,50.38 182.09,50.26 181.42,50.26 181.29,50.38 181.29,51.31 181.14,51.46 180.92,51.46 180.76,51.31 180.76,50.38 180.63,50.26 180.35,50.26 180.23,50.38 180.23,50.95 180.1,51.07 179.82,51.07 179.69,50.95 179.69,50.38 179.57,50.26 178.71,50.26 177.86,51.11 176.96,51.11 176.16,50.31 175.35,50.31 174.6,51.06 168.95,51.06 168.01,52 165.94,52 165.29,52.65 163.75,52.65 163.63,52.52 163.63,52.24 163.75,52.12 164.93,52.12 165.09,51.96 165.09,51.74 164.93,51.58 162.26,51.58 161.98,51.86 161.98,52.07 160.18,53.87 160,53.87 159.81,53.67 159.81,53.49 161.27,52.03 161.27,51.81 161.11,51.65 160.89,51.65 159.2,53.34 158.41,53.34 157.89,52.82 152.9,52.82 152.74,52.98 152.74,53.2 152.9,53.36 157.63,53.36 157.79,53.51 157.79,53.73 157.63,53.89 151.14,53.89 150.99,54.05 150.99,54.27 151.14,54.42 153.48,54.42 153.61,54.55 153.61,54.83 153.48,54.96 150.47,54.96 150.01,54.5 149.57,54.5 149.31,54.76 149.31,54.94 148.85,55.4 v2(148.63,55.4)
  L4 w0.127: v2(151.71,18.97) 151.47,19.22 151.47,22.01 150.05,23.43 150.05,43.04 149.67,43.42 149.67,49.28 147.45,51.51 147.45,54.22 v2(148.63,55.4) 147.16,56.87 147.16,57.69 145.45,59.4 145.45,61.65 144.78,62.32 144.29,62.32 143.6,61.63 141.71,61.63 141.35,61.99 141.35,63.54 140.71,64.18 140.71,65.31 140.86,65.47 140.86,65.79 140.22,66.43 140.22,66.74 139.72,67.24 139.72,70.5 139.57,70.65 139.36,70.65 139.21,70.5 139.21,69.32 139.06,69.17 138.85,69.17 138.71,69.32 138.71,71.92 138.56,72.07 138.35,72.07 138.2,71.92 138.2,69.32 138.05,69.17 137.84,69.17 137.69,69.32 137.69,73.45 137.54,73.59 135.96,73.59 135.81,73.45 135.81,73.24 135.96,73.09 136.98,73.09 137.18,72.88 137.18,68.08 v2(136.86,67.76)
  BOTTOM w0.14: R9106.1 162.38,20.12 v2(162.38,19.19) ; R2507.1 148.4,55.17 v2(148.63,55.4) 149.89,56.66 153.76,56.66 154.18,56.24 154.18,56.09 R2513.1 ; v2(136.86,67.76) 136.27,67.76 136.06,67.54 R1807.1 ; v2(188.43,55.23) 188.95,55.74 188.95,59.7 189.57,60.33 189.57,60.54 191.48,62.46 191.48,67.22 191.48,68.16 191.39,68.25 191.39,72.71 191.72,73.05 191.72,79.69 192.76,80.73 v2(192.76,80.74)
SPI_SO_ROM_R: length 7.9
  BOTTOM w0.14: R2507.2 147.3,54.92 147.3,54.57 EC2502.1 146.6,54.32 146.42,54.49 146.42,55.83 146.26,55.99 145.95,55.99 145.83,55.87 145.83,54.61 145.73,54.51 145.37,54.51 145.27,54.61 145.27,55.54 145.18,55.63 SPI25.2
SPI_SO_ROM_TPM: length 3.3
  BOTTOM w0.14: R9106.2 162.39,21.52 v1(162.39,22.22) 162.39,22.25 163.02,22.88 U9101.24
SPI_WP_CPU: length 10.2
  BOTTOM w0.089: 136.12,73.77 136.02,73.87 135.63,73.87 CPU1.AW2
  BOTTOM w0.114: 136.12,73.77 137.26,72.62 137.26,71.1 138.44,69.93 138.44,69.62 138.78,69.28 138.78,68.36 R1834.2
  BOTTOM w0.14: R1809.2 R1827.2 138.71,67.45 138.71,67.69 R1834.2
SPI_WP_ROM: length 45.3
  TOP w0.14: v1(150.08,54.38) 149.76,54.06 v2(149.61,54.06)
  L4 w0.127: v2(140.67,66.69) 141.09,66.69 141.32,66.47 141.52,66.47 141.9,66.86 142.08,66.86 142.29,66.65 142.29,66.47 141.9,66.08 141.9,65.9 142.13,65.67 142.13,65.51 142.16,65.48 142.16,64.95 141.77,64.56 141.63,64.56 141.46,64.72 141.28,64.72 141.09,64.52 141.09,64.34 141.61,63.82 141.83,63.82 143.09,65.08 143.27,65.08 143.47,64.89 143.47,64.71 141.96,63.19 141.96,62.97 142.11,62.82 142.33,62.82 144.01,64.49 144.21,64.49 144.39,64.31 144.39,64.11 142.99,62.71 142.99,62.51 143.16,62.34 143.36,62.34 144.75,63.72 144.97,63.72 145.13,63.57 145.13,63.32 144.8,63 144.8,62.84 145.83,61.81 145.83,59.58 145.98,59.43 146.19,59.43 146.34,59.58 146.34,61.72 146.49,61.86 146.71,61.86 146.85,61.72 146.85,58.54 147.54,57.85 147.54,57.03 148.49,56.08 149.24,56.08 149.37,55.95 149.37,55.24 149.09,54.96 148.76,54.96 147.83,54.03 147.83,53.26 148.01,53.07 148.33,53.07 149.32,54.06 v2(149.61,54.06)
  BOTTOM w0.14: R1809.1 140.27,66.29 v2(140.67,66.69) ; R2514.1 150.15,54.6 v2(149.61,54.06) 149.39,53.84 149.11,53.84 148.76,53.49 R2508.1
SPI_WP_ROM_R: length 32.8
  L4 w0.127: v2(147.99,52.47) 148.32,52.14 148.85,52.14 150.11,53.4 150.11,54.45 150.42,54.76 150.42,56.59 148.24,58.77 148.24,63.16 146.31,65.09 146.31,67.8 146.88,68.37 146.88,68.78 v2(147.45,69.36)
  BOTTOM w0.14: SPI25.3 144.29,54.09 146.21,54.09 146.4,53.89 146.4,53.62 146.21,53.43 145.49,53.43 145.32,53.26 145.32,52.95 145.5,52.78 146.65,52.78 146.84,52.58 146.84,52.42 147,52.26 147.3,52.26 147.43,52.38 147.43,53.38 R2508.2 147.99,53.04 v2(147.99,52.47) ; RN2501.1 v1(148.1,69.36) v2(147.45,69.36)
SPKR: length 194.4
  TOP w0.254: R2006.2 141.48,64.68 141.12,65.05 141.12,65.65 140.58,66.18 140.46,66.18 140.07,66.57 140.07,66.99 v2(138.38,68.68) 137.26,69.8 137.26,72.24 136.67,72.83 136.67,72.83 136.15,73.36 134.69,73.36 v1(134.4,73.65) v2(133.75,74.3) ; RN2701.2 38.65,20.15 v2(38.84,19.97)
  L3 w0.254: v2(38.84,19.97) 40.49,19.97 41.38,19.08 43.4,19.08 44.38,18.1 44.38,17.66 45.23,16.81 45.23,15.17 47.71,12.69 49.18,12.69 49.55,12.32 58.35,12.32 59.36,11.31 70.01,11.31 70.43,11.31 73.02,8.73 90.7,8.73 93.46,5.97 137.62,5.97 146.8,15.15 146.8,15.71 v2(146.73,15.77)
  L4 w0.254: v2(138.38,68.68) 138.38,67.56 139.82,66.12 139.82,64.44 140.9,63.36 140.9,61.78 141.5,61.19 143.19,61.19 144.25,60.13 144.25,58.36 144.85,57.75 144.85,51.72 147.07,49.5 147.07,43.74 147.57,43.24 147.57,40.48 146.73,39.64 146.73,17.5 147.57,16.66 147.57,16.1 147.24,15.77 v2(146.73,15.77)
  BOTTOM w0.254: CPU1.AW5 133.74,74.3 v2(133.75,74.3)
SRTC_RST#: length 24.2
  TOP w0.127: v2(133.58,62.41) 133.47,62.29 v1(133.47,61.51) 133.47,61 133.82,60.65 C1902.1 134.15,60.65 134.52,61.02 EC1806.1 135.03,60.9 RN1901.4
  L4 w0.127: v2(126.2,77.85) 126.2,77.77 126.7,77.27 126.7,74.18 127.69,73.19 128.59,73.19 130.68,71.1 130.68,70.62 131.03,70.26 131.03,66.68 133.39,64.33 133.39,62.6 v2(133.58,62.41)
  BOTTOM w0.127: CPU1.AN18 125.87,78.17 v2(126.2,77.85)
STRAP0: length 10
  BOTTOM w0.127: R7625.2 208.22,127.57 R7646.2 208.19,127.52 R7621.1 207.21,127.52 v1(206.48,128.25) 204.96,129.77 203.87,129.77 202.85,130.8 201.96,130.8 201.05,131.72 GPU1.D1
STRAP1: length 8.8
  BOTTOM w0.127: R7635.2 204.39,128.71 R7647.1 R7622.1 205.2,129.08 204.74,129.54 203.78,129.54 202.75,130.57 201.86,130.57 200.67,131.77 200.67,132.23 201.05,132.61 GPU1.D2
STRAP2: length 12.5
  TOP w0.127: R7606.2 203.12,131.88 R7637.1 203.39,130.59 v1(204.9,130.59) 205.48,130.59 v2(205.73,130.84)
  BOTTOM w0.127: v2(205.73,130.84) 203.69,130.84 202.98,131.55 202.5,131.55 202.23,131.81 202.23,133.02 202.1,133.15 201.73,133.15 201.44,133.44 201.44,133.68 201.13,133.99 200.58,133.99 GPU1.E4
STRAP3: length 9.3
  BOTTOM w0.127: GPU1.E3 200.39,133.57 200.63,133.33 200.63,132.62 200.4,132.39 200.4,131.65 201.74,130.32 202.33,130.32 202.72,129.93 R7609.1 202.7,128.69 R7650.1 201.02,128.69 R7615.2 201,127.92 v1(200.84,127.76)
STRAP4: length 10.9
  BOTTOM w0.127: GPU1.D3 201.05,133.35 201.43,132.97 201.43,131.66 201.86,131.23 202.95,131.23 204.06,130.13 R7654.1 207.62,130.13 R7632.1 208,130.1 208.14,129.96 v1(208.58,129.96) 208.59,129.96 R7634.2
STRAP_REF0_GND_N9: length 2.5
  TOP w0.127: v1(199.85,134.89) R7607.2 199.14,136.25 v2(198.93,136.46)
  BOTTOM w0.127: v2(198.93,136.46) 199.33,136.07 GPU1.F6
SUS_CLK: length 94.5
  TOP w0.14: v2(180.15,60.15) 179.64,60.66 R2428.2 ; v2(146.74,42.74) 146.74,42.95 145.87,43.82 v1(145.87,44.2) 143.91,46.16 142.01,46.16 139.74,48.42 135.2,48.42 130.06,53.55 130.06,58.52 130.69,59.15 130.72,59.15 131.34,59.78 131.34,62.61 130.26,63.69 129.14,63.69 R1813.2
  L3 w0.127: v2(180.15,60.15) 179.76,60.15 178.65,59.04 178.28,59.04 178.13,59.2 173.99,59.2 173.81,59.37 173.36,59.37 171.93,60.8 165.66,60.8 164.44,62.02 162.24,62.02 160.29,60.08 155.93,60.08 153.49,57.64 150.06,57.64 147.73,59.97 143.71,59.97 v2(143.61,59.87)
  L4 w0.127: v2(143.61,59.87) 143.61,58.1 144.22,57.49 144.22,51.37 146.43,49.16 146.43,43.3 146.74,42.99 v2(146.74,42.74)
SUS_STAT#/LPCPD#: length 11.3
  BOTTOM w0.089: 129.56,71.55 129.44,71.67 129.44,72.18 129.33,72.29 129.33,72.63 129.59,72.89 CPU1.BA11
  BOTTOM w0.114: 130.49,69.51 129.71,70.29 129.71,71.41 129.56,71.55
  BOTTOM w0.127: 130.49,69.51 v1(130.51,69.49) 130.84,69.16 130.84,68.39 131.98,67.25 132.67,67.25 134.2,65.72 134.2,65.72 135.03,64.89 R1814.2
SUSACK#: length 34.2
  TOP w0.127: v2(186.86,79.58) 186.86,79.65 186.65,79.85 186.65,80.88 186.95,81.17 187.02,81.17 187.28,81.42 KBC24.34
  L3 w0.127: v2(187.72,69.93) 187.57,69.78 185.83,69.78 185.72,69.89 183.36,69.89 183.24,69.77 181.16,69.77 180.84,70.09 176.41,70.09 175.58,69.26 175.58,69.08 175.17,68.67 174.51,68.67 174.49,68.69 173.09,68.69 172.01,69.77 v2(169.78,69.77)
  L4 w0.127: v2(187.72,69.93) 187.72,70.76 186.82,71.66 186.82,74.45 186.44,74.83 186.44,75.25 186.38,75.3 186.38,79.1 v2(186.86,79.58)
  BOTTOM w0.127: v2(187.72,69.93) v1(187.72,69.34) ; RN1702.2 169.62,69.61 v2(169.78,69.77)
SUSACK#_R: length 45.5
  L3 w0.127: v2(159.56,70.64) 159.53,70.67 159.1,70.67 157.45,72.31 155.97,72.31 154.7,71.05 154.26,71.05 153.71,70.49 153.45,70.49 152.89,71.05 150.6,71.05 150.27,71.38 149.69,71.96 148.9,71.96 148.76,72.1 146.93,72.1 146.56,71.73 146.19,71.73 144.05,73.87 138.08,73.87 137.64,73.43 131.94,73.43 130.32,75.05 130.32,77.38 v2(129.85,77.85)
  BOTTOM w0.127: RN1702.3 166.14,69.61 R1708.2 165.74,70.01 v1(164.14,70.01) 164.12,70.03 161.34,70.03 160.9,70.46 159.74,70.46 v2(159.56,70.64) ; CPU1.AP11 129.53,77.52 v2(129.85,77.85)
SUSCLK_R: length 10.1
  TOP w0.14: R1813.1 128.11,64.79 EC1803.2 v1(128.11,66.27) 128.11,66.83 v2(127.73,67.2)
  BOTTOM w0.089: CPU1.BA17 126.23,72.85 126.23,71.99 126.2,71.95
  BOTTOM w0.14: 126.2,71.95 126.2,71.16 126.67,70.69 126.67,68.66 127.63,67.69 127.63,67.3 v2(127.73,67.2)
SYS_PEX_RST_MON#: length 62.4
  TOP w0.127: v2(195.22,123.65) 195.69,123.65 196.84,122.5 196.84,121.74 197.76,120.82 198.68,120.82 199.68,121.82 199.68,125.14 201.07,126.54 206.82,126.54 207.04,126.76 207.83,126.76 v1(213.06,131.99) 213.39,132.32 213.39,133.16 213.76,133.53 213.76,134.23 214.54,135.01 214.54,138.42 213.99,138.97 209.32,138.97 208.86,139.43 R7629.2
  BOTTOM w0.127: v2(195.22,123.65) 193.86,122.3 188.03,122.3 186.31,124.01 185.31,124.01 184.39,124.93 D7301.2 183.3,124.93 182.53,124.17 R7313.1 182.07,124.19 R7306.1 R7304.2 180.33,123.78 179.35,122.8 177.21,122.8 176.87,123.14 U7301.4
SYS_PEX_RST_MON_GPU#: length 10
  TOP w0.127: v2(205.27,139.62) 205.28,139.62 v1(205.74,139.16) 206.31,138.59 R7643.1 R7629.1
  L4 w0.127: v2(199.84,139.78) 200.27,139.35 205,139.35 v2(205.27,139.62)
  BOTTOM w0.127: v2(199.84,139.78) 199.84,138.94 200.23,138.55 GPU1.E9
SYS_PWROK: length 78.9
  TOP w0.127: v2(172.44,71.38) 172.8,71.01 KBC24.89
  L3 w0.127: v2(141.39,97.74) 146.31,97.74 147.08,96.97 150.11,96.97 151.32,98.19 152.72,98.19 153.22,98.69 161.64,98.69 162.26,98.06 163.56,98.06 163.57,98.07 163.94,98.07 163.95,98.06 174.48,98.06 174.87,98.45 v2(175.03,98.45)
  L4 w0.127: v2(172.44,71.38) 172.44,74.32 172.67,74.56 172.67,75.48 171.13,77.02 171.13,80.22 171.15,80.25 171.15,82.32 171.68,82.85 171.68,84.2 172.45,84.96 172.45,86.73 172.5,86.78 172.5,88.51 173.04,89.05 173.04,91.01 172.55,91.5 172.55,95.98 v2(175.03,98.45)
  BOTTOM w0.127: v2(175.03,98.45) v1(175.73,98.45) ; v2(141.39,97.74) 141.39,96.95 EC1702.1 R1717.1 139.78,97.42 138.56,97.42 138.26,97.13 137.65,97.13 137.05,96.52 134.26,96.52 133.14,95.41 133.14,94.94 133.15,94.94 133.15,94.56 132.87,94.28 CPU1.B6
T_CRIT#: length 4.8
  BOTTOM w0.102: R2604.2 159.53,96.26 v1(159.5,96.23) 158.9,95.63 R2601.1 158.49,94.87 158,95.36 THM26.4
TESTMODE: length 50.2
  TOP w0.102: v2(169.09,145.69) 168.51,145.11 166.71,145.11 164.9,146.93 162.22,146.93 158.19,150.96 148.31,150.96 147.41,150.06 v1(146.07,150.06) 144.31,150.06 v2(143.23,148.99)
  BOTTOM w0.102: GPU1.AD9 184.05,138.95 183.49,138.95 183.27,139.18 183.27,139.49 182.91,139.84 178.66,139.84 173.46,145.05 169.73,145.05 v2(169.09,145.69) ; v2(143.23,148.99) 142.89,148.99 142.29,149.59 142.29,150.3 R7302.1
THERM_SYS_SHDN#: length 5.6
  BOTTOM w0.102: R2602.1 160.64,98.97 v1(160.98,98.63) 161.23,98.39 Q2602.S 161.23,96.58 159.79,95.14 R2601.2
THM_SML1_CLK: length 41.4
  TOP w0.14: Q2601.4 158.11,77.51 157.76,77.86 157.76,78.97 158.44,79.65 159.61,79.65 159.77,79.49 RN2602.4 160.64,79.03 v1(160.99,79.38) 161.19,79.59 v2(164.38,79.59)
  L3 w0.127: v2(151.6,97.04) 152.45,97.04 153.04,97.63 160.02,97.63 160.23,97.85 160.23,97.85 v2(160.29,97.85)
  L4 w0.127: v2(164.38,79.59) 164.13,79.83 164.13,82.77 163.98,82.92 163.98,82.97 162.61,84.35 162.61,84.36 162.61,85.82 162.61,86.24 160.01,88.83 160.01,90.99 160.69,91.67 160.69,92.65 160.69,92.65 160.69,96.94 160.69,96.94 160.69,97.31 160.69,97.31 160.69,97.45 v2(160.29,97.85)
  BOTTOM w0.14: C2608.1 150.86,97.04 v2(151.6,97.04) 151.86,97.31 THM26.8
THM_SML1_DATA: length 43.3
  TOP w0.14: v2(164.38,78.95) 164.19,79.14 162.44,79.14 v1(162.06,78.76) 161.77,78.48 160.2,78.48 160.04,78.32 159.27,78.32 159.12,78.46 RN2602.3 158.62,79.03 158.32,78.74 158.32,78.09 158.84,77.57 158.84,76.14 159.14,75.84 Q2601.1
  L3 w0.127: v2(151.52,96.31) 151.87,96.66 152.6,96.66 153.19,97.25 160.03,97.25 160.12,97.16 160.21,97.16 v2(160.25,97.12)
  L4 w0.127: v2(160.25,97.12) 160.18,97.06 160.18,92.48 160.18,92.48 160.18,91.7 159.5,91.02 159.5,88.62 162.1,86.03 162.1,84.14 163.38,82.85 163.38,82.52 163.55,82.35 163.55,79.69 164.29,78.95 v2(164.38,78.95)
  BOTTOM w0.14: C2609.1 151.47,96.26 v2(151.52,96.31) 151.66,96.31 152.01,96.66 THM26.7
TOUCH_PANEL_INTR#: length 271.3
  TOP w0.127: v2(86.04,151.61) 85.68,151.61 85.28,152.01 85.28,152.94 85.17,153.05 R5537.2 ; v2(185.8,85.48) 186.2,85.09 R2429.1
  L3 w0.127: v2(87.51,172.7) 88.09,172.7 90.66,175.27 102.39,175.27 102.63,175.03 105.35,175.03 105.56,175.24 109.21,175.24 110.38,174.08 113.99,174.08 114.87,173.19 115.24,173.19 115.69,173.65 118.99,173.65 119.7,172.94 120.07,172.94 120.7,173.58 123.78,173.58 124.44,172.92 125.73,172.92 126.85,171.8 128.76,171.8 129.52,172.56 135.4,172.56 136.19,173.35 148.65,173.35 152.48,169.51 154.82,169.51 159.52,164.81 162.29,164.81 v2(162.68,164.42) ; v2(135.35,100.72) 135.72,100.72 136.04,101.04 137.53,101.04 139.13,102.64 146.86,102.64 147.26,102.24 150.28,102.24 151.4,103.36 154.3,103.36 156.04,105.1 157.66,105.1 158.16,105.6 163.9,105.6 v2(164.45,106.15) 164.84,106.54 165.9,106.54 166.63,105.82 176.08,105.82 179.19,102.7 182.49,102.7 185.23,99.95 186.63,99.95 188.49,98.09 188.49,96.74 191.57,93.66 192.53,93.66 196.54,89.65 196.54,87.55 195.56,86.56 195.56,85.51 193.58,83.54 190.31,83.54 188.37,85.48 v2(185.8,85.48)
  L4 w0.127: v2(86.04,151.61) 86.09,151.65 86.09,161.07 86.73,161.71 86.73,165.73 87.51,166.52 v2(87.51,172.7) ; v2(162.68,164.42) 162.68,162.79 162.37,162.48 162.37,160.9 162.66,160.6 162.66,158.73 165.09,156.31 165.09,152.12 165.09,152.12 165.09,151.7 160.85,147.46 160.85,139.62 160.85,139.27 163.31,136.81 163.31,136.21 165.18,134.34 165.18,134.34 165.59,133.93 165.59,130.58 164.91,129.91 164.91,128.04 164.91,128.03 164.91,127.32 165.29,126.93 165.29,121.03 165.83,120.49 165.83,118.7 164.21,117.08 164.21,108.67 164.45,108.44 164.45,106.85 164.45,106.84 164.45,106.42 v2(164.45,106.15)
  BOTTOM w0.127: v2(162.68,164.42) v1(162.68,163.79) ; v2(135.35,100.72) 135.35,100.4 136.12,99.62 136.12,97.64 135.62,97.13 133.97,97.13 132.19,95.36 CPU1.A7 ; v2(185.8,85.48) 185.16,84.84 D2402.A
TOUCHPAD_INTR#: length 8.4
  BOTTOM w0.102: CPU1.BA5 133.12,72.96 133.42,72.65 133.42,72.64 133.45,72.61 133.45,72.16 133.88,71.74 133.88,71.68 134.31,71.25 135,71.25 135.55,70.69 135.58,70.69 135.78,70.49 135.78,70.41 136.34,69.86 136.76,69.86 137.1,69.51 137.1,68.88 R2045.2 136.39,68.17 v1(135.58,68.17)
TP1_AY4: length 2.8
  TOP w0.102: TP610.1 134.75,71.65 v2(134.49,71.91)
  BOTTOM w0.089: CPU1.AY4 134.07,73.33 134.07,73.04 134.28,72.83 134.28,72.17 134.49,71.96 v2(134.49,71.91)
TP2_BB3: length 5
  BOTTOM w0.102: TP611.1 137.64,69.75 136.3,71.09 135.72,71.09 135,71.81 135,72.01 134.87,72.14 134.72,72.29 134.72,72.34 CPU1.BB3
TP4_BB5: length 1.8
  TOP w0.102: v2(133.58,71.42) 133.58,71.64 TP609.1
  BOTTOM w0.102: v2(133.58,71.42) 133.57,71.42 133.19,71.81 CPU1.BB5
TP5_AU5: length 6.7
  TOP w0.102: v2(136.29,71.54) 136.29,71.5 TP607.1
  BOTTOM w0.089: v2(136.29,71.54) 136.2,71.63 135.94,71.63 135.91,71.61 135.61,71.61 135.35,71.86 135.35,71.92 134.98,72.28 134.94,72.33 134.94,72.54 134.77,72.71 134.77,73.16 134.52,73.41 134.29,73.41 134.09,73.6 134.09,74.06 134.13,74.1 134.13,74.46 133.96,74.63 133.95,74.63 133.75,74.83 133.75,74.87 CPU1.AU5
TP6_AT5: length 1.3
  TOP w0.102: v2(132.6,75.9) 132.89,76.18 TP608.1
  BOTTOM w0.102: CPU1.AT5 132.92,76.22 v2(132.6,75.9)
TP_EN#: length 271.9
  TOP w0.127: v2(43.25,78.52) 43.31,78.58 R6516.1 ; v2(178.97,85.21) 180.01,84.17 180.01,84.1 180.92,83.19 181.02,83.19 181.28,82.93 KBC24.49
  L3 w0.127: v2(180.45,25.98) 180.18,26.25 177.92,26.25 177.37,25.7 175.52,25.7 174.98,26.25 171.98,26.25 171.77,26.45 169.04,26.45 167.93,27.56 163.85,27.56 163.02,28.39 161.23,28.39 159.92,27.07 153.29,27.07 152.7,26.48 149.23,26.48 145.49,22.74 142.92,22.74 140.37,20.19 140.25,20.07 140.25,18.81 138.43,16.99 136.65,16.99 135.78,16.99 129.87,11.09 96.26,11.09 91.53,15.82 78.43,15.82 74.6,19.64 74.6,22.31 74.6,22.31 74.6,23.19 73.94,23.85 73.94,24.04 66.66,31.32 65.74,31.32 65.49,31.57 64.22,31.57 63.07,32.72 63.07,34.58 61.6,36.05 61.6,39.07 62.67,40.14 62.67,67.85 55.35,75.18 55.35,76.79 56.25,77.69 56.25,78.57 55.99,78.83 55.1,78.83 54.78,78.52 v2(43.25,78.52)
  L4 w0.127: v2(178.97,85.21) 179.74,84.44 179.74,82 180.64,81.1 180.64,78.5 180.17,78.03 180.17,77.2 181.25,76.12 181.25,73.3 181.58,72.97 181.58,72.71 182.07,72.22 182.07,72.21 182.48,71.8 182.48,71.12 182.6,71 182.6,69.18 182.71,69.07 182.71,65.81 182.52,65.61 182.52,63.73 182.47,63.68 182.47,63.2 182.52,63.14 182.52,59.93 183.18,59.28 183.18,57.05 183.16,57.04 183.16,56.5 182.88,56.21 182.88,55.09 181.93,54.14 181.93,52.88 182.53,52.28 182.53,43.13 182.33,42.93 182.33,42.33 182.51,42.15 182.51,35.79 182.72,35.58 182.72,28.98 180.45,26.72 v2(180.45,25.98)
  BOTTOM w0.127: v2(178.97,85.21) 178.54,84.79 R2409.1 v1(178.35,83.84)
TP_LOCK#: length 227.5
  TOP w0.127: v2(55.8,78.39) 55.8,78.27 55.81,78.26 R6509.2 56.34,77.63 56.93,78.23 AFTP6242.1 59.06,78.77 TPAD1.3 ; v2(171.38,58.98) 171.3,58.98 171.15,59.14 v1(170.84,59.14) 169.5,60.48 D2405.A
  L3 w0.127: v2(55.8,78.39) 55.8,77.61 55.09,76.9 55.09,75.07 61.95,68.21 61.95,39.78 61.35,39.17 61.35,35.94 62.81,34.47 62.81,32.62 64.12,31.31 65.39,31.31 65.64,31.07 66.56,31.07 73.68,23.94 73.68,23.75 74.35,23.08 74.35,22.42 74.35,22.42 74.35,19.54 78.32,15.56 91.42,15.56 96.15,10.83 129.98,10.83 135.88,16.74 136.54,16.74 136.54,16.74 138.54,16.74 140.55,18.75 140.55,19.93 143.1,22.48 145.64,22.48 149.38,26.22 152.8,26.22 153.4,26.82 165.47,26.82 165.83,27.18 167.95,27.18 168.93,26.2 171.67,26.2 172.23,25.63 v2(174.95,25.63)
  L4 w0.127: v2(171.38,58.98) 171.38,57.85 171.19,57.67 171.19,50.29 171.75,49.73 171.75,48.2 172.99,46.96 172.99,44.99 172.99,44.99 172.99,44.36 173.29,44.06 173.29,43.4 172.56,42.68 171.95,42.68 171.69,42.42 171.69,42.05 171.95,41.79 172.58,41.79 172.83,41.55 173.29,41.09 173.29,32.41 173.98,31.72 173.98,29.1 174.71,28.36 174.71,25.87 v2(174.95,25.63)
TP_ON#_GATE: length 5.6
  TOP w0.127: v1(42.46,78.29) 43.02,77.73 Q6505.G C6503.1 R6516.2 44.98,78.36 Q6504.G
TP_RESET: length 9.7
  TOP w0.102: R5538.1 81.11,152.43 C5540.1 81.87,153.8 81.87,154.61 v1(81.72,154.76) 81.45,155.03 80.02,155.03 78.73,156.31 78.73,158.63 78.55,158.82 LCD1.38
TP_RS: length 12.6
  TOP w0.102: R5537.1 84.69,152.16 C5541.1 v1(82.72,152.16) 82.27,152.16 82.08,152.35 82.08,154.93 81.78,155.23 80.15,155.23 79,156.39 79,159 78.68,159.32 LCD1.37
TP_VDD: length 29.8
  TOP w0.381: 54.15,69.56 54.15,68.97 53.88,68.7 48.4,68.7 47.21,69.89 47.21,70.91 v1(47.23,70.92) 47.23,71.94 47.9,72.61 R6522.1 R6517.2 47.9,76.54 ; Q6504.D 50.5,77.37 50.67,77.2 53.81,77.2 54.24,77.63 R6509.1 R6514.2 ; TPAD1.8 59.01,73.77 AFTP6239.1 57.4,72.16 C6504.1 R6513.1 56.04,72.1 55.28,71.34
TPAN_VDD: length 6.8
  TOP w0.305: LCD1.40 77.1,157.82 77.1,157.82
  TOP w0.508: v2(71.78,156.64) 72.96,157.82 77.1,157.82
  vias: v1(67.86,158.4)
TPAN_VDD_F:
  vias: v1(70.25,163.48)
TPCLK_C: length 6.3
  TOP w0.14: RN6503.4 55.92,79.73 56.31,80.12 58.43,80.12 AFTP6238.1 59.08,80.77 TPAD1.1
TPDATA_C: length 6.1
  TOP w0.14: TPAD1.2 58.87,79.77 58.66,79.56 57.05,79.56 AFTP6236.1 56.57,79.08 RN6503.3
TPM_GPIO0: length 3.6
  BOTTOM w0.127: R9119.1 161.39,27.25 v1(162.25,26.4) 162.97,25.68 U9101.29
TPM_GPIO2: length 20.3
  BOTTOM w0.127: U9101.3 165.36,29.02 165.04,29.34 165.04,30.31 R9118.1 164.56,31.35 163.98,31.93 160.57,31.93 160.33,31.69 160.33,30.03 R9117.2 158.72,29.65 158.28,30.09 Q9102.D 157.85,29.17 158.21,28.81 158.21,26.68 Q9101.D 157.86,26.33 R9120.1 157.86,23.93 158.49,23.3 v1(158.69,23.3)
