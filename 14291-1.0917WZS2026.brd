# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDP_TCLK: length 11.1
  BOTTOM w0.089: 101.24,97.05 101.24,95.42 101.07,95.25 101.07,94.96 101.12,94.86 101.12,94.64 CPU1.B61
  BOTTOM w0.114: 101.82,98.96 101.82,98.64 101.24,98.05 101.24,97.05
  BOTTOM w0.14: 101.82,98.96 101.82,100.09 v1(101.65,100.27) 101.42,100.49 101.42,102.35 R406.1 100.33,103.44 100.33,104 100.08,104.25 R9930.1
XDP_TDI: length 13.3
  BOTTOM w0.089: 102.13,97.11 102.13,96.75 102,96.62 102,94.51 102.18,94.32 102.18,93.98 102.15,93.96 102.15,93.96 102,93.8 102,93.8 101.89,93.7 CPU1.D60
  BOTTOM w0.114: 102.13,97.11 102.45,97.44 102.57,97.44 102.9,97.77 102.9,98.8 102.86,98.84 102.86,99.55
  BOTTOM w0.14: 102.86,99.55 102.86,100.69 103.47,101.31 TP9914.1 103.32,101.66 103.32,103.29 R422.1 104.24,104.21 104.24,105.02 R9928.2
XDP_TDO_CPU: length 11.7
  BOTTOM w0.089: 101.53,97.17 101.45,97.09 101.45,95.2 CPU1.A61
  BOTTOM w0.114: 102.03,100.75 102.13,100.65 102.13,98.61 101.53,98.02 101.53,97.17
  BOTTOM w0.14: R9935.1 101.8,105.65 101.38,105.23 v1(101.38,104.84) 101.38,104.66 101.5,104.54 101.5,103.63 101.98,103.15 R423.1 101.98,102.72 101.85,102.59 101.85,100.92 102.03,100.75
XDP_TMS: length 12
  L4 w0.127: v2(104.08,102.29) 102.61,102.29 v2(102.58,102.26)
  BOTTOM w0.089: CPU1.C60 101.89,94.28 101.82,94.35 101.82,96.72 101.93,96.82 101.93,97.19 102.4,97.67
  BOTTOM w0.114: 102.4,97.67 102.56,97.82 102.56,98.43 102.44,98.55 102.44,99.94
  BOTTOM w0.14: R9927.2 104.23,102.15 v2(104.08,102.29) ; R421.1 102.79,102.47 v2(102.58,102.26) 102.24,101.92 TP9911.1 102.44,101.33 102.44,99.94
XDP_TRST#: length 10.2
  TOP w0.14: v2(102.11,98.03) 102.36,97.77 TP9910.1 102.36,97.08 v2(102.53,96.91)
  BOTTOM w0.089: v2(102.53,96.91) 102.53,96.74 102.18,96.38 102.18,94.71 CPU1.B59 ; v2(102.11,98.03) 101.72,97.65 101.72,97.09 101.64,97.01 101.64,94.39 101.56,94.27 101.56,94.02 CPU1.C61
  BOTTOM w0.114: R402.1 103.42,97.98 102.53,97.09 v2(102.53,96.91)
XTAL1: length 17.1
  TOP w0.14: KBC24.123 185.68,65.75 185.67,65.74 185.67,65.72 185.89,65.5 185.89,61.9 v1(184.91,60.92) 184.46,60.47 182.25,60.47 181.68,61.05 181.68,61.19 179.49,63.37 C2425.2 177.05,63.37 176.72,63.7 X2401.1
XTAL2: length 15.4
  TOP w0.14: KBC24.125 186.48,65.57 186.65,65.4 v1(186.65,63.28) 186.65,61.74 186.48,61.57 186.48,61.22 185.48,60.23 185.14,59.89 184.72,59.89 184.03,59.2 183.3,59.2 182.61,59.89 181.37,59.89 179.72,61.55 R2428.1 179.26,61.69 R2458.2
XTAL24_IN: length 12
  BOTTOM w0.14: CPU1.E37 115.07,92.36 115.39,92.67 115.59,92.67 115.88,92.97 115.88,93.97 116.01,94.1 116.33,94.1 116.48,94.25 116.48,95.24 117.65,96.41 117.65,97.07 v1(118.02,97.44) 118.59,98.01 118.59,99.83 119.45,100.69 R1802.1 119.45,101.9 R1810.1
XTAL24_IN_R: length 4.8
  BOTTOM w0.14: X1801.1 120.11,105.85 120.42,105.53 120.42,103.46 120.35,103.39 C1801.2 120.35,101.91 R1810.2
XTAL24_OUT: length 14.9
  BOTTOM w0.114: 116.86,93.78 116.96,93.88 arc(117.04,94) 117.06,94.13 117.06,94.27
  BOTTOM w0.14: X1801.3 121.22,103.75 C1802.2 121.22,101.97 R1802.2 119,99.75 v1(119,98.17) 119,97.85 117.88,96.73 117.88,96.28 116.93,95.33 116.93,94.4 117.06,94.27 ; 116.86,93.78 116.64,93.78 116.45,93.59 116.45,93.33 116.51,93.27 116.51,93 116.33,92.82 116.14,92.82 CPU1.E35
XTAL_KBC_2: length 4.5
  TOP w0.14: v1(179.48,62.57) 178.57,62.57 R2458.1 178.51,62.52 C2424.2 176.12,60.96 X2401.2
ZVM#: length 1.7
  TOP w0.102: TP616.1 104.01,76.91 v2(104.3,77.2)
  BOTTOM w0.102: CPU1.AR56 103.97,76.87 v2(104.3,77.2)

## Copper pours and planes (outline as drawn)
3V3_AON_S0 on TOP: 208.27,134.73 207.61,135.39 207.61,138 207.39,138.23 207.39,138.87 207.44,138.92 208.78,138.92 209.14,138.56 209.14,136.89 210.05,135.97 211.86,135.97 212.08,135.74 212.08,135.13 211.68,134.73 ; 1 cut-out
3V3_AON_S0 on TOP: 198.78,138.79 198.6,138.97 198.6,139.96 198.27,140.29 197.94,140.29 197.81,140.42 197.81,141.3 199.13,141.3 199.46,140.97 199.46,138.99 199.26,138.79
3V3_AON_S0 on TOP: 180.06,127.64 179.93,127.77 179.93,128.33 182.24,130.64 182.24,132.47 185.15,135.37 185.15,136.44 187.35,138.64 188.16,138.64 188.41,138.38 188.41,133.89 187.33,132.81 187.33,131 185.08,128.75 185.08,127.97 184.75,127.64 ; 5 cut-outs
3V3_AON_S0 on BOTTOM: 194.37,125.93 194,126.3 194,126.48 193.81,126.67 192.82,126.67 192.79,126.7 192.79,127.03 192.82,127.05 194.05,127.05 194.29,126.81 195.63,126.81 195.85,126.59 195.85,126.17 195.61,125.93 ; 1 cut-out
3V3_AON_S0 on BOTTOM: 219.4,149.38 219.28,149.51 219.28,151.26 219.15,151.39 218.03,151.39 217.96,151.46 217.96,152.45 218,152.49 220.05,152.49 220.26,152.28 220.26,149.55 220.09,149.38
3V3_AON_S0 on BOTTOM: 210.45,133.89 210.37,133.96 210.37,135.22 210.84,135.69 211.76,135.69 211.96,135.49 211.96,134.52 211.33,133.89
3V3_AON_S0 on BOTTOM: 173.05,125.02 171.82,126.25 171.82,130.31 171.98,130.47 171.98,132.09 172,132.12 172.7,132.12 173.33,131.49 173.33,129.39 174.88,127.84 177.15,127.84 177.39,127.6 178.76,127.6 179,127.85 179,128.41 177.65,129.76 177.65,129.78 177,130.43 177,131.66 177.05,131.7 177.56,131.7 178.7,130.56 179.64,130.56 180.58,131.5 183.68,131.5 185.4,129.78 187.1,129.78 188.11,128.77 188.11,128.31 188.07,128.27 187.59,128.27 186.75,129.11 185.66,129.11 183.41,126.86 181.32,126.86 180.06,125.61 177.98,125.61 177.39,125.02 ; 2 cut-outs
3V3_AON_S0 on BOTTOM: 198.97,138.7 198.82,138.86 198.16,138.86 197.9,139.11 197.9,141.09 198.03,141.21 198.79,141.21 199.3,140.71 199.3,139.44 199.31,139.43 199.31,138.86 199.15,138.7
3V3_AON_S0 on BOTTOM: 201.31,126.06 201,126.37 200.49,126.37 199.66,127.2 199.66,128.96 199.8,129.1 200.38,129.1 200.51,128.96 200.51,127.41 200.63,127.29 201.56,127.29 202.13,126.72 202.71,126.72 203.24,127.25 203.24,128.14 203.31,128.22 203.87,128.22 203.94,128.14 203.94,127.62 204.29,127.27 206.35,127.27 206.56,127.06 208.47,127.06 208.68,127.27 208.68,128.66 209.47,129.45 209.81,129.45 209.99,129.63 209.99,130.26 209.85,130.39 208.07,130.39 207.83,130.63 207.83,131.15 207.9,131.23 208.96,131.23 209.23,131.49 209.23,131.85 209.43,132.05 210.57,132.05 210.72,131.91 210.72,128.49 209.87,127.65 209.87,127.31 208.89,126.34 203.67,126.34 203.39,126.06 ; 4 cut-outs
3V3_AON_S0 on L3: 197.96,141.02 198.97,141.02 199.36,140.64 199.36,139.7 202.2,136.87 211.98,136.87 218.89,143.78 218.89,150.73 219.36,151.2 220.03,151.2 220.3,150.93 220.3,135.11 216.06,130.87 207.34,130.87 203.96,134.24 199.83,134.24 197.45,136.62 197.45,140.51
3V5V_CT1 on TOP: 37.99,27.33 37.8,27.51 37.8,28.74 38.07,29.01 38.07,29.21 38.15,29.29 38.15,30.21 38.17,30.23 38.32,30.23 38.34,30.22 38.34,29.28 38.4,29.21 38.4,28.96 38.45,28.91 38.45,27.48 38.3,27.33
3V5V_CT2 on TOP: 36.95,27.26 36.77,27.44 36.77,27.97 37.23,28.43 37.23,29.06 37.35,29.18 37.35,30.19 37.38,30.23 37.51,30.23 37.54,30.21 37.54,29.29 37.64,29.19 37.64,27.44 37.46,27.26
5V_HDD_S0 on TOP: 179.62,30.93 179.44,31.12 179.44,32.75 179.64,32.95 181.74,32.95 181.97,33.18 185.11,33.18 185.35,32.94 185.35,31.45 184.84,30.93
5V_HDD_S0 on BOTTOM: 186.33,29.87 186.15,30.05 179.48,30.05 179.2,30.32 179.2,32.87 179.39,33.06 182.55,33.06 182.99,32.61 183.59,32.61 183.61,32.6 185.15,32.6 185.66,32.09 187.53,32.09 187.95,31.67 189.25,31.67 189.3,31.62 189.3,29.89 189.28,29.87 ; 2 cut-outs
5V_HDMI_R_S0 on BOTTOM: 20.27,71.05 19.83,71.49 19.83,73.61 20.11,73.89 22.25,73.89 22.37,73.77 22.37,71.7 21.72,71.05 ; 2 cut-outs
5V_HDMI_S0 on BOTTOM: 16.54,71.05 16.19,71.39 16.19,72.51 16.37,72.69 17.69,72.69 18,73 18,73.82 18.08,73.89 19.12,73.89 19.17,73.84 19.17,71.3 18.92,71.05 ; 2 cut-outs
5V_HDMI_S0 on L3: 10.49,70.31 8.55,70.31 8.33,70.54 8.33,71.89 10.21,73.77 18.79,73.77 18.94,73.61 18.94,71.07 18.89,71.02 11.2,71.02
5V_S0 on TOP: 74.12,2.01 73.95,2.18 73.95,2.96 74.09,3.1 82.47,3.1 88.31,8.95 88.31,14.11 88.56,14.37 89.29,14.37 89.65,14.01 89.65,8.33 83.32,2.01 ; 2 cut-outs
5V_S0 on TOP: 39.42,25.93 38.8,26.55 38.8,27.36 38.56,27.6 38.56,29.41 38.55,29.41 38.55,30.24 39.36,30.24 40.36,29.24 42.5,29.24 42.73,29.47 43.28,29.47 44.47,30.65 49.46,30.65 50.17,29.94 50.17,29.43 49.91,29.17 48.48,29.17 48.33,29.32 44.75,29.32 44,28.57 44,26.27 43.82,26.09 43.26,26.09 43.1,25.93 ; 4 cut-outs
5V_S0 on TOP: 35.4,7.37 35.4,11.11 37.44,13.14 37.44,14.6 37.57,14.72 38.94,14.72 39.07,14.6 39.07,11.88 36.85,9.66 36.85,7.45 36.78,7.37
5V_S0 on TOP: 23.11,69.63 22.88,69.85 22.88,75.98 21.15,77.7 16.02,77.7 15.69,77.37 15.69,75.19 15.49,74.99 11.93,74.99 11.86,75.06 11.86,76.36 12.16,76.66 14.09,76.66 14.09,78.57 14.75,79.23 24.48,79.23 24.89,78.82 24.89,70.13 24.38,69.63 ; 4 cut-outs
5V_S0 on TOP: 177.95,33.26 177.78,33.42 177.78,35.6 178.02,35.84 181.11,35.84 181.66,35.28 181.66,33.37 181.55,33.26
5V_S0 on BOTTOM: 73.61,0.76 73.61,2.98 75.18,4.56 160.47,4.56 161.31,5.39 188.74,5.39 198.45,15.1 198.45,34.92 198.59,35.06 199.71,35.06 199.94,34.83 199.94,10.07 191.54,1.66 160.08,1.66 159.71,1.86 159.3,1.93 147.32,1.93 146.37,1.65 145.63,0.8 145.5,0.76 ; 2 cut-outs
5V_S0 on BOTTOM: 33.69,11.88 31.07,14.51 31.07,23.82 32.41,25.17 34.56,25.17 34.84,24.89 34.84,23.32 36.06,22.1 36.06,16.54 37.65,14.96 38.61,14.96 38.98,14.58 38.98,12.37 38.5,11.88
5V_S0 on BOTTOM: 23,72.09 22.88,72.21 22.88,73.94 23.03,74.08 46.54,74.08 46.86,74.4 50.91,74.4 51.05,74.26 51.05,72.33 50.94,72.22 50.25,72.22 49.99,72.49 47.43,72.49 47.03,72.09 ; 1 cut-out
5V_S0 on BOTTOM: 177.78,32.25 177.64,32.39 177.64,35.56 177.95,35.86 180.41,35.86 181.07,35.21 181.07,33.5 180.76,33.19 179.35,33.19 179.05,32.89 179.05,32.33 178.97,32.25 ; 2 cut-outs
5V_S0 on L3: 177.79,36.22 177.79,33.07 178.32,32.54 183.78,32.54 185.3,31.02 199.02,31.02 199.76,31.76 199.76,35.09 199.51,35.34 191.89,35.34 191.04,36.19 183.98,36.19 183.37,36.79 178.36,36.79
5V_S0 on L3: 170.71,136.36 170.71,134.82 171.24,134.29 173.87,134.29 174.48,133.69 174.48,129.3 176.78,127 180.46,127 180.73,126.73 180.73,125.82 180.29,125.38 176.95,125.38 175.63,124.06 175.63,123.1 176.7,122.02 182.78,122.02 186.81,117.99 188.01,117.99 190.34,115.67 192.88,115.67 195.92,112.62 195.92,107.96 195.91,107.95 195.91,107.31 196.17,107.06 197.39,107.06 198.02,107.7 198.02,112.94 193.78,117.18 191.61,117.18 186.35,122.44 186.35,125.08 183.05,128.38 178.24,128.38 177.03,129.59 177.03,134.41 174.36,137.07 171.42,137.07
5V_S0 on L3: 35.39,24.45 30.93,24.45 29.02,26.37 19.07,26.37 18.67,26.78 18.67,28.27 19.35,28.96 30.74,28.96 30.97,28.72 30.97,27.99 31.59,27.37 41.7,27.37 42.49,27.37 42.65,27.21 42.65,24.95 41.77,24.07 35.77,24.07
5V_S0 on L4: 11.68,73.89 11.68,76.46 11.86,76.64 13.66,76.64 13.81,76.48 13.81,73.92 13.71,73.82 11.76,73.82
5V_S0 on L4: 73.3,0.76 73.17,0.8 73.08,0.9 72.43,1.65 71.48,1.93 64.49,1.93 64.32,2 64.25,2.17 64.25,4.17 63.73,5.42 62.49,5.93 43.28,5.93 42.26,6.95 41.11,6.95 33.34,14.72 33.34,19.39 32.56,20.17 32.56,26.4 31.74,27.21 29.21,27.21 28.66,27.76 28.66,28.65 28.92,28.9 30.04,28.9 30.41,28.53 32.96,28.53 34.03,27.47 35.53,27.47 36.14,26.85 36.14,18.24 36.63,17.76 36.63,15.91 36.78,15.75 37.51,15.75 38.57,14.7 39.63,14.7 40.09,14.24 40.09,12.78 44.76,8.11 46.34,8.11 47.2,7.26 65.34,7.26 68.37,4.23 71.88,4.23 71.89,4.22 72.37,4.22 72.41,4.17 74.41,4.17 76.44,2.14 144.79,2.14 145.94,3.29 162.06,3.29 165.17,6.4 191.7,6.4 198.69,13.39 198.69,34.89 198.84,35.04 199.9,35.04 200.1,34.84 200.1,12.02 192.41,4.34 165.85,4.34 163.45,1.93 147.32,1.93 146.37,1.65 145.63,0.8 145.5,0.76
5V_S5 on TOP: 38.6,31.55 38.55,31.6 38.55,32.69 38.6,32.75 38.6,33.88 38.6,33.93 38.6,33.93 38.6,34 38.25,34.35 27.88,34.35 27.83,34.4 27.1,34.4 26.03,33.33 23.37,33.33 23.05,33.64 23.05,34.27 23.22,34.43 23.22,35.63 23.24,35.63 23.38,35.77 23.9,35.77 24.45,36.33 25.25,36.33 26.11,37.19 26.11,37.67 25.69,38.1 25.69,39.31 25.34,39.66 24.08,39.66 23.87,39.87 23.87,41.23 23.96,41.32 26.89,41.32 29.35,38.86 42.45,38.86 43.82,37.49 43.82,33.67 42.61,32.47 42.18,32.47 41.98,32.26 41.98,31.83 41.7,31.55 ; 4 cut-outs
5V_S5 on BOTTOM: 187.1,36.77 186.59,37.28 186.59,39.06 186.72,39.19 188.21,39.19 189.18,40.16 193.5,40.16 194.08,39.57 194.08,37.14 193.71,36.77 ; 2 cut-outs
5V_S5 on BOTTOM: 38.34,31.12 37.51,31.96 37.51,33.43 37.7,33.62 37.7,38.47 38.67,39.45 46.46,39.45 47.24,38.67 47.24,34.83 46.83,34.42 44.57,34.42 42.97,32.82 42.97,31.24 42.86,31.12
5V_S5 on L3: 194.59,41.17 194.59,52.22 193.68,53.14 193.68,58.39 197.27,61.99 197.27,73.84 198.19,74.76 198.19,90.75 191.56,97.38 191.56,97.88 179.17,110.28 169.57,110.28 168.09,111.76 165.88,111.76 158.69,118.95 158.69,121 155.07,124.62 155.07,127.56 155.32,127.8 157.6,127.8 164.9,120.5 164.9,120.49 165.39,120 165.39,118.41 165.87,117.93 169.03,117.93 171.14,115.82 179.06,115.82 200.14,94.73 200.14,37.19 199.57,36.63 193.11,36.63 192.37,37.37 192.37,38.95
5V_S5 on L3: 100.26,136.21 102.44,138.39 105.52,138.39 106.72,137.19 115.62,137.19 116.04,136.78 116.04,133.45 113.7,131.12 113.7,130.49 113.81,130.38 114.51,130.38 117.49,133.35 117.49,137.73 117.14,138.08 107.63,138.08 105.74,139.97 101.96,139.97 99.5,137.51 96.9,137.51 95.31,135.92 95.31,135.18 95.62,134.87 96.18,134.87 97.52,136.21
5V_S5 on L4: 40.22,12.83 40.22,14.34 39.73,14.83 38.72,14.83 37.19,16.37 37.19,17.12 36.62,17.68 36.62,17.96 36.27,18.32 36.27,27.11 36.88,27.72 36.88,33.91 37.76,34.8 43.15,34.8 44.29,33.67 44.29,30.22 43.7,29.64 43.7,24.78 43.08,24.16 43.08,18.61 49.42,12.28 58.22,12.28 59.19,11.31 75.86,11.31 79.92,7.24 158.52,7.24 166.27,14.99 188.27,14.99 191.97,18.69 191.97,38.79 192.61,39.43 198.12,39.43 198.55,39 198.55,13.39 191.68,6.52 165.35,6.52 162.22,3.38 145.93,3.38 144.79,2.25 76.52,2.25 74.41,4.35 68.42,4.35 65.39,7.38 47.25,7.38 46.39,8.24 44.81,8.24
+3V_1D5V_AVDD on TOP: 24.12,8.21 24.03,8.3 24.03,8.74 24.47,9.18 24.47,11.11 24.62,11.26 26.01,11.26 26.12,11.15 26.12,10.05 25.42,9.35 25.42,8.26 25.37,8.21 ; 3 cut-outs
+3V_AVDD on TOP: 32.02,11.44 31.63,11.83 31.25,11.83 29.9,13.18 29.9,13.76 29.91,13.78 30.79,13.78 30.89,13.69 30.89,13.39 31.05,13.23 31.05,12.94 31.48,12.51 32.01,12.51 32.46,12.06 32.86,12.06 32.98,11.94 32.98,11.51 32.91,11.44 ; 1 cut-out
+5V_KB_BL on TOP: 193.93,93.15 193.85,93.23 193.85,93.6 193.94,93.69 194.56,93.69 194.95,94.09 195.15,94.09 195.34,93.89 195.34,93.72 194.78,93.15
+5V_PVDD on TOP: 29.23,7.35 29.16,7.42 29.16,7.93 29.02,8.06 28.42,8.06 28.1,8.38 28.01,8.38 27.76,8.63 25.93,8.63 25.82,8.74 25.82,9.42 26.25,9.85 26.25,11.58 26.55,11.88 26.65,11.88 26.74,11.79 26.74,11.73 26.61,11.6 26.61,11.11 28.14,9.58 28.14,9.2 28.49,8.84 28.72,8.84 28.77,8.89 30.55,8.89 30.78,9.12 30.78,9.66 29.74,10.7 29.74,10.95 28.65,12.03 28.65,13.3 28.67,13.32 28.83,13.32 28.85,13.3 28.85,12.57 28.85,12.57 28.85,12.31 28.97,12.2 29.08,12.2 29.33,11.94 29.76,11.94 30.44,11.26 30.44,10.85 31.34,9.96 31.34,9.28 32.06,8.56 32.36,8.56 33.11,9.31 33.11,9.95 33.2,10.04 33.75,10.04 33.98,10.27 33.98,10.88 34.08,10.98 34.92,10.98 35.02,10.88 35.02,7.55 34.82,7.35 ; 4 cut-outs
+V1.00A_SIP on BOTTOM: 164.89,90.83 164.76,90.96 164.76,91.93 164.51,92.18 160.84,92.18 160.58,92.44 160.58,94.24 160.67,94.33 162.25,94.33 162.25,94.32 163.33,94.32 163.5,94.15 163.5,93.41 163.69,93.22 164.61,93.22 165.09,93.7 165.61,93.7 165.85,93.45 165.85,90.91 165.78,90.83 ; 3 cut-outs
+V1.00A_SIP on BOTTOM: 149.63,112.5 148.71,113.42 148.71,116.11 148.99,116.39 150.98,116.39 151.3,116.71 152.17,116.71 152.27,116.62 152.27,115.23 153.55,113.95 153.55,113.38 152.67,112.5 ; 2 cut-outs
+V1.00A_SIP on BOTTOM: 135.8,103.05 135.19,103.66 135.19,105.99 135.79,106.58 146.27,106.58 146.8,106.05 146.8,104.36 146.73,104.3 146.03,104.3 145.96,104.36 145.96,105.03 145.96,105.03 145.96,105.12 145.63,105.45 143.56,105.45 143.4,105.61 140.47,105.61 139.85,104.99 139.85,103.94 139.22,103.94 139.19,103.92 139.19,104.79 138.94,105.05 136.94,105.05 136.63,104.74 136.63,103.3 136.37,103.05 ; 4 cut-outs
+V1.00A_SIP on L3: 123.73,84.31 123.73,84.07 123.91,83.89 124.18,83.89 126.82,86.52 126.82,89.16 128.2,90.54 128.2,92.88 129,93.68 129.32,93.68 131.5,95.86 131.5,97.82 133.17,99.48 133.17,101.21 133.8,101.85 134.47,101.85 134.73,102.11 135.68,102.11 136.3,102.73 136.3,103.48 136.17,103.61 135.79,103.61 135.71,103.53 135.71,103.25 135.38,102.92 134.65,102.92 134.3,102.57 133.56,102.57 132.47,101.47 132.47,99.74 130.76,98.04 130.76,96.31 129.88,95.43 129.41,95.43 127.5,93.53 127.5,90.85 126.14,89.48 126.14,86.73
+V1.00A_SIP on L3: 144.79,106.17 144.79,105.5 144.92,105.36 146.4,105.36 153.56,112.53 153.56,113.61 153.19,113.98 152.6,113.98
+V1.00U_CPU on TOP: 123.03,89 121.73,90.3 121.14,90.3 121.04,90.4 121.04,91.05 121.18,91.19 123.57,91.19 123.87,91.49 123.87,93.41 123.99,93.54 125.78,93.54 125.89,93.42 125.89,90.13 125.3,89.54 123.91,89.54 123.38,89 ; 2 cut-outs
+V1.00U_CPU on BOTTOM: 164.77,111 164.63,111.14 164.63,112.92 164.73,113.03 168.21,113.03 168.31,112.93 168.31,111.14 168.17,111
+V1.00U_CPU_LS on BOTTOM: 163.18,113.95 163.07,114.06 163.07,116.47 163.14,116.54 166.41,116.54 166.53,116.42 166.53,114.09 166.39,113.95
+V1.8A on BOTTOM: 165.3,94.92 164.95,95.27 164.95,99.51 165.14,99.7 167,99.7 167.13,99.57 167.13,98.54 166.44,97.84 166.44,95.22 166.14,94.92 ; 1 cut-out
+V1.8A_SIP on BOTTOM: 156.03,84.2 155.6,84.63 155.6,87.06 154.61,88.05 154.61,89.72 155.14,90.25 156.46,90.25 156.58,90.13 156.58,85.73 156.58,85.73 156.58,85.32 156.99,84.91 156.99,84.37 156.81,84.2 ; 2 cut-outs
+V3.3A_SIP on BOTTOM: 161.25,78.27 161.08,78.44 161.08,79.73 162.63,81.28 162.63,82.25 162.47,82.41 159.97,82.41 159.89,82.49 159.89,88.62 160.13,88.85 160.95,88.85 161.09,88.99 161.09,89.9 161.28,90.1 162.51,90.1 162.62,89.98 162.62,87.63 162.5,87.51 161.86,87.51 161.03,86.67 161.03,86.32 161.26,86.09 162.48,86.09 162.6,85.97 162.6,83.84 162.86,83.59 164.53,83.59 165.09,83.03 165.09,81.3 165.81,80.58 165.81,79.8 165.45,79.44 163.13,79.44 161.96,78.27 ; 15 cut-outs
+VCCAMPHYPLL_1P0_L on BOTTOM: 142.76,96.76 142.67,96.85 142.67,98 142.88,98.21 142.88,99.08 143.06,99.26 145.31,99.26 145.48,99.09 147.04,99.09 147.16,98.96 147.16,97.24 146.9,96.97 146.15,96.97 146.14,96.96 145.26,96.96 145.06,96.76 143.55,96.76 143.55,96.76 ; 5 cut-outs
+VCCF135_1P0 on L4: 123.01,90.24 123.01,89.16 122.73,88.87 122.34,88.87 122.14,89.08 121.35,89.08 120.97,89.46 120.97,91.44 118.64,93.77 118.64,97.52 121.67,100.56 123.93,100.56 126.19,102.81 126.19,104.4 127.18,105.39 128.8,105.39 130.6,107.19 139.58,107.19 139.89,106.89 146.29,106.89 147.3,105.88 147.3,105.26 147.17,105.13 144.76,105.13 143.59,106.31 139.18,106.31 138.93,106.56 130.72,106.56 128.94,104.78 127.41,104.78 126.72,104.09 126.72,102.58 124.12,99.99 121.91,99.99 119.17,97.25 119.17,94.51 121.69,91.99 121.69,91.56
+VCCGT on TOP: 86.08,79.95 85.71,80.32 85.71,94.62 91.32,100.23 91.33,100.23 92.5,101.4 96.13,101.4 96.57,101.83 96.57,106.63 96.58,106.65 96.58,108.04 96.61,108.07 96.61,114.91 101.87,120.17 115.01,120.17 115.69,119.49 115.69,110.71 108.19,103.2 108.19,96.69 108.58,96.3 108.58,92.61 109.31,91.89 109.31,90.59 110.65,89.25 110.65,88.43 110.59,88.37 107.04,88.37 106.85,88.17 106.85,81.59 106.59,81.33 105.93,81.33 105.83,81.43 105.83,81.82 105.72,81.93 102,81.93 100.01,79.95 ; 39 cut-outs
+VCCGT on BOTTOM: 93.13,83.06 92.86,83.33 92.86,83.73 89.08,83.73 88.59,84.22 88.59,84.57 88.6,84.59 88.6,85.73 90.14,87.27 92.62,87.27 94.25,88.9 94.68,88.9 94.74,88.95 94.74,89.33 94.98,89.58 101.14,89.58 101.36,89.36 101.71,89.36 101.86,89.51 101.86,89.69 101.31,90.24 101.31,90.72 101.37,90.79 101.8,90.79 101.92,90.67 102.18,90.67 102.31,90.81 110.68,90.81 110.84,90.65 110.84,90.54 110.41,90.11 110.41,83.65 110.06,83.3 99.89,83.3 99.74,83.15 96.01,83.15 95.95,83.21 93.63,83.21 93.48,83.06
+VCCGT on BOTTOM: 88.6,87.53 88.5,87.63 87.42,87.63 87.38,87.68 87.38,88.11 87.53,88.26 88.75,88.26 89.06,87.94 89.06,87.67 88.92,87.53
+VCCGT on BOTTOM: 103.28,106.41 101.64,108.05 101.64,114.94 106.5,119.79 109.77,119.79 109.78,119.81 115.47,119.81 115.8,119.47 115.8,107.78 114.44,106.42 109.33,106.42 109.32,106.41 108.54,106.41 108.53,106.41 ; 10 cut-outs
+VCCGT on L3: 100.51,82.09 105.97,82.09 106.59,82.71 106.59,89.27 106.4,89.45 105.85,89.45 104.87,90.43 104.87,94.64 105.82,95.59 105.82,95.6 107.05,96.84 107.05,106.42 111.12,110.49 113,110.49 113.66,111.15 113.66,119.38 113.1,119.93 102.96,119.93 97.32,114.29 97.32,101.73 85.63,90.04 85.63,89.17 85.59,89.17 85.59,83.84 86.81,82.63 99.97,82.63
+VCCGT on L4: 101.13,84.14 102.9,84.14 103.71,83.34 103.71,82.41 103.44,82.14 102.11,82.14 100.95,83.29 100.95,83.97
+VCCGT on L4: 101.2,89.67 101.71,90.18 106.39,90.18 106.93,89.64 106.93,88.3 106.53,87.9 101.86,87.9 101.68,88.08 96.08,88.08 95.58,88.58 95.58,89.1 96.14,89.67
+VCCIO on TOP: 118.56,78.23 118.32,78.46 118.32,78.76 117.44,79.64 117.44,80.89 117.62,81.07 118.97,81.07 119.11,80.93 119.11,79.63 119.38,79.37 119.57,79.37 119.66,79.29 119.66,78.9 118.98,78.23 ; 2 cut-outs
+VCCIO on TOP: 111.81,79.69 111.73,79.77 111.73,80.38 111.75,80.4 111.75,80.9 111.91,81.06 112.75,81.06 112.82,80.98 112.82,80.54 112.77,80.49 112.77,79.79 112.66,79.69 ; 1 cut-out
+VCCIO on BOTTOM: 118.68,78.29 118.09,78.89 118.09,79.4 117.72,79.76 117.72,80.13 117.16,80.7 112.96,80.7 112.77,80.5 112.27,80.5 112.25,80.53 112.25,81 112.38,81.14 119.24,81.14 119.6,80.78 119.6,79.99 119.62,79.97 119.62,78.82 119.08,78.29
+VCCIO on BOTTOM: 151.25,120.04 151.12,120.17 151.12,122.46 158.87,122.46 159.04,122.62 159.04,125.54 159.1,125.61 161.3,125.61 161.4,125.5 161.4,124.53 161.26,124.39 160.99,124.39 160.87,124.26 160.87,123.34 160.72,123.19 160.72,120.68 160.09,120.04 ; 5 cut-outs
+VCCIO on L3: 129.18,115.2 130.46,116.48 139.56,116.48 146.31,123.23 153.3,123.23 154.09,122.45 154.09,120.71 153.73,120.35 152.7,120.35 149.19,116.84 149.19,114.83 144.41,110.04 139.36,110.04 137.86,108.54 133.16,108.54 129.96,105.35 129.96,103.86 129.14,103.04 129.14,102.32 124.3,97.47 124.3,95.42 121.08,92.2 121.08,90.84 120.69,90.45 120.69,81.21 119.61,80.13 119.61,80.1 119.18,79.66 117.87,79.66 117.72,79.81 117.72,80.92 119.23,82.43 119.23,92.61 120.11,93.49 120.11,97.27 121.46,98.63 121.46,100.11 129.18,107.82
+VCCIO on L4: 119.86,87.57 119.86,87.15 119.74,87.03 116.55,87.03 116.13,87.44 111.2,87.44 110.3,88.34 110.3,89.94 110.41,90.06 110.72,90.06 110.87,89.9 110.87,88.57 111.48,87.96 116.28,87.96 116.56,87.68 119.76,87.68
+VCCMPHYGTAON_1P0_LS_SIP on BOTTOM: 126.79,86.87 126.72,86.94 126.72,87.41 126.45,87.68 126.21,87.68 126.02,87.87 126.02,88.16 126.16,88.3 127.79,88.3 128.31,87.78 128.31,87.44 127.74,86.87
+VCCMPHYGTAON_1P0_LS_SIP on BOTTOM: 147.85,97.85 147.54,98.15 147.54,102.87 147.37,103.05 147.37,103.97 147.52,104.12 150.43,104.12 153.1,106.78 153.1,107.48 154.47,108.85 155.16,108.85 155.17,108.85 157.88,108.85 157.94,108.8 157.94,106.58 153.3,101.94 152.79,101.94 151.44,100.59 151.44,98.11 151.18,97.85 ; 4 cut-outs
+VCCMPHYGTAON_1P0_LS_SIP on L3: 128.38,87.79 128.38,87.38 128.22,87.22 127.14,87.22 126.93,87.44 126.93,89.06 127.75,89.88 128.85,89.88 129.32,90.35 129.81,90.35 129.83,90.33 129.83,89.85 129.35,89.37 128.34,89.37 128.11,89.14 127.91,89.14 127.67,88.89 127.67,88.33 128.04,87.97 128.2,87.97
+VCCPRIM_1P0 on TOP: 131.57,84.51 131.38,84.7 130.82,84.7 130.58,84.94 130.58,85.47 130.23,85.82 127.32,85.82 126.44,84.94 124.38,84.94 124.15,85.18 123.38,85.18 123.19,85.36 122.56,85.36 122.12,84.93 121.11,84.93 121.05,84.99 121.05,85.44 121.23,85.61 121.74,85.61 121.87,85.74 123.26,85.74 123.66,86.14 123.66,86.84 123.78,86.97 124.2,86.97 124.28,86.89 124.28,85.69 124.47,85.5 125.35,85.5 126.18,86.33 130.53,86.33 131.64,85.23 131.68,85.23 131.69,85.22 133.44,85.22 133.56,85.11 133.56,84.73 133.34,84.51
+VCCPRIM_CORE on TOP: 139.72,110.14 139.56,110.3 139.56,111.59 139.62,111.66 140.96,111.66 142.68,113.37 142.68,116.61 146.14,120.07 153.69,120.07 153.94,119.81 153.94,118.78 153.72,118.56 146.56,118.56 144.28,116.27 144.28,112.77 141.65,110.14 ; 1 cut-out
+VCCPRIM_CORE on TOP: 123.85,82.16 123.75,82.26 123.75,82.71 123.55,82.91 122.4,82.91 122.14,83.16 122.14,83.32 121.98,83.49 120.74,83.49 120.67,83.56 120.67,84.37 121.08,84.78 122.1,84.78 122.62,85.29 123.18,85.29 123.65,84.82 123.65,84.02 124.61,83.06 124.61,82.32 124.45,82.16 ; 1 cut-out
+VCCPRIM_CORE on BOTTOM: 152.89,115.05 152.52,115.42 152.52,118.59 152.04,119.07 152.04,119.86 152.21,120.03 156.35,120.03 156.71,119.66 156.71,118.77 156.59,118.65 156.08,118.65 155.7,118.27 155.7,115.38 155.37,115.05 ; 1 cut-out
+VCCPRIM_CORE on L3: 152.9,119.99 153.82,119.99 154.15,119.66 154.15,118.44 152.93,117.23 152.65,117.23 152.09,117.78 152.09,119.18
+VCCPRIM_CORE on L3: 121.29,92.11 124.51,95.34 124.51,96.54 124.69,96.71 125.85,96.71 125.96,96.6 125.96,94.98 123.01,92.02 123.01,90.05 122.65,89.69 122.65,87.16 122.16,86.67 122.16,84.19 121.99,84.02 121.18,84.02 120.93,84.27 120.93,89.53 120.91,89.55 120.91,90.09 121.29,90.46
+VCCSA on TOP: 120.05,87.9 119.41,88.54 119.08,88.54 118.73,88.89 118.73,91.63 130.38,103.28 130.38,106.87 134.61,111.1 134.61,115.35 134.74,115.47 138.93,115.47 139.06,115.35 139.06,110.72 133.08,104.74 133.08,103.16 123.24,93.32 121.79,93.32 120.96,92.48 120.96,90.41 121.19,90.17 121.2,90.17 121.2,88.09 121,87.9 ; 9 cut-outs
+VCCSA on TOP: 119.66,79.51 119.23,79.95 119.23,82.05 119.27,82.09 120.35,82.09 120.46,81.98 120.46,80.9 120.98,80.38 120.98,79.6 120.9,79.51
+VCCSA on BOTTOM: 120.91,79.3 120.54,79.67 120.54,80.12 119,81.66 119,86.68 117.85,87.82 117.85,88.97 118.26,89.38 118.26,90.23 118.39,90.36 118.98,90.36 119.12,90.51 119.12,91.15 119.22,91.25 119.22,91.25 119.57,91.6 119.89,91.6 120.24,91.26 120.36,91.26 120.55,91.06 120.89,91.06 121.08,91.25 121.26,91.25 121.47,91.05 121.79,91.05 121.97,91.24 122.2,91.24 122.47,90.97 122.56,90.97 122.71,90.81 122.71,90.15 122.14,89.58 122.14,88.64 120.85,87.35 120.85,84.21 121.22,83.84 121.22,81.58 122.61,80.19 122.61,79.68 122.25,79.32 122.12,79.32 122.1,79.3
+VCCSA on BOTTOM: 134.65,110.82 134.3,111.16 134.3,115.56 133.95,115.91 133.95,116.36 139.24,116.36 139.33,116.27 139.33,115.63 139.23,115.54 139.23,112.17 137.88,110.82 ; 11 cut-outs
+VCCSA on L2VCC: 120.25,79.85 120.07,80.03 120.07,87.42 118.68,88.82 118.68,91.18 130.87,103.37 130.87,116.04 138.22,116.04 139,115.27 139,106.79 130.96,98.76 129.48,98.76 128.49,97.77 128.49,96.29 125.52,93.31 125.52,90.13 122.61,87.23 122.61,80.64 121.82,79.85
+VCCSRAM_1P0 on BOTTOM: 165.05,85.59 164.68,85.96 164.68,86.86 164.29,87.26 164.29,88.3 164.48,88.49 164.88,88.49 165.53,87.84 167,87.84 167.67,87.17 167.67,85.66 167.61,85.59 ; 2 cut-outs
+VCCSRAM_1P0 on L3: 132.98,86.24 127.04,86.24 124.21,83.41 123.51,83.41 122.97,82.87 122.97,82.35 123.36,81.97 124.51,81.97 124.73,82.18 124.73,82.76 127.74,85.77 133.7,85.77 134.04,85.43 136.05,85.43 136.3,85.18 140.17,85.18 141.26,86.27 145.61,86.27 146.08,86.75 147.14,86.75 147.9,85.98 155,85.98 155.97,86.95 156.4,86.95 157.59,88.15 159.04,88.15 159.49,87.7 165.08,87.7 165.12,87.74 165.12,88.42 165.02,88.51 160,88.51 159.5,89.02 157.32,89.02 156.35,88.06 154.16,88.06 153.26,87.16 147.93,87.16 147.35,87.75 145.66,87.75 145.08,87.16 140.55,87.16 139.47,86.08 136.98,86.08 136.47,86.59 133.33,86.59
GND on TOP: 40.43,29.37 39.94,29.85 39.94,31.16 40.12,31.34 41.78,31.34 42.13,31.69 42.13,32.21 42.25,32.33 42.77,32.33 44.02,33.57 48.68,33.57 48.95,33.31 48.95,31.28 48.41,30.74 44.36,30.74 43.24,29.62 42.65,29.62 42.39,29.37 ; 3 cut-outs
GND on TOP: 86.4,35.73 86.23,35.91 86.23,36.38 86.32,36.46 86.75,36.46 86.9,36.32 87.53,36.32 87.66,36.2 87.66,35.92 87.47,35.73
GND on TOP: 138.34,55.05 138.03,55.36 138.03,55.4 137.56,55.88 133.76,55.88 133.51,56.13 133.51,60.05 133.6,60.14 134.05,60.14 134.21,59.98 134.21,56.74 134.37,56.58 136.77,56.58 136.92,56.73 136.92,58.9 136.54,59.28 136.54,59.94 136.63,60.03 138.78,60.03 139.51,59.31 140.51,59.31 140.7,59.12 140.7,58.71 140.59,58.6 138.38,58.6 138.2,58.42 138.2,57.94 137.71,57.45 137.71,56.65 137.79,56.58 138.25,56.58 138.36,56.47 138.36,55.85 138.56,55.65 138.83,55.65 138.91,55.57 138.91,55.13 138.83,55.05 ; 3 cut-outs
GND on TOP: 13.4,35.1 13.3,35.21 13.3,36.86 13.43,36.99 13.96,36.99 13.96,36.98 14.29,36.98 15.34,38.03 18.81,38.03 19.1,37.75 19.1,36.66 19.07,36.66 18.85,36.43 16.88,36.43 16.68,36.23 16.68,35.17 16.61,35.1 ; 3 cut-outs
GND on TOP: 84.63,144.69 84.08,145.23 82.67,145.23 82.26,145.64 82.26,148.03 82.78,148.56 87.97,148.56 90.17,150.75 94.2,150.75 94.51,150.45 94.51,148.59 95.22,147.88 98.75,147.88 99.08,147.55 99.08,146.18 99.03,146.13 98.57,146.13 98.5,146.21 98.5,146.61 98.29,146.82 97.68,146.82 97.47,146.6 93.78,146.6 93.43,146.25 93.43,137.28 96.11,134.6 97.05,134.6 97.43,134.22 97.43,132.67 97.35,132.59 96.54,132.59 95.22,133.91 86.18,133.91 84.63,135.46
GND on TOP: 94.95,101.6 94.47,102.09 94.47,113.75 95.27,114.55 95.27,114.92 95.52,115.18 96.11,115.18 96.3,114.98 96.3,101.79 96.11,101.6 ; 9 cut-outs
GND on TOP: 116.12,171.35 115.49,171.98 114.76,171.98 114.2,172.54 114.2,172.56 113.94,172.82 113.94,175.13 114.57,175.75 115.86,175.75 115.98,175.63 115.98,174.69 116.6,174.07 116.9,174.07 116.91,174.09 117.21,174.09 117.3,173.99 117.3,172.72 116.97,172.4 116.97,171.56 116.77,171.35 ; 1 cut-out
GND on TOP: 115.44,120.63 115.12,120.94 115.12,123.96 116.93,125.76 116.93,132.44 118.25,133.77 118.25,134.76 119.42,135.93 121.57,135.93 121.6,135.89 121.6,130.65 121.87,130.38 126.56,130.38 126.6,130.34 126.6,127.81 126.48,127.69 120.92,127.69 120.16,126.93 120.16,123.18 117.61,120.63 ; 2 cut-outs
GND on TOP: 82.65,152.74 82.29,153.11 82.29,154.96 82.52,155.2 82.97,155.2 83.47,155.7 84.35,155.7 84.52,155.53 84.52,155.07 84.31,154.85 84.31,153.67 84.15,153.51 84.15,152.87 84.02,152.74 ; 1 cut-out
GND on TOP: 202.21,159.13 201.33,160.01 201.33,161.01 201.46,161.13 202.55,161.13 203.04,160.64 203.04,159.24 202.93,159.13 ; 2 cut-outs
GND on TOP: 176.62,131.47 175.21,132.88 175.21,133.84 175.31,133.95 176.88,133.95 178.44,135.5 181.83,135.5 182.18,135.16 182.18,131.67 181.98,131.47
GND on TOP: 182.65,118.75 182.44,118.95 182.44,120.58 182.67,120.81 185.41,120.81 185.59,120.63 185.59,118.9 185.44,118.75
GND on TOP: 33.29,10.24 33.12,10.42 33.12,12.96 34.36,12.96 34.56,12.76 34.56,12.37 33.9,11.71 33.9,10.39 33.75,10.24 ; 1 cut-out
GND on TOP: 38.53,24.03 36.99,25.57 36.43,25.57 36.34,25.66 36.34,26.9 36.62,27.18 38.33,27.18 38.52,26.99 38.52,26.55 39.27,25.8 44.1,25.8 44.31,25.58 44.31,24.2 44.14,24.03 ; 6 cut-outs
GND on TOP: 193.85,120.91 193.64,121.11 193.64,121.92 194.28,122.56 196.06,122.56 196.24,122.38 196.24,121.09 196.06,120.91
GND on TOP: outline of 612 points within 0.76,0.76 221.04,181.21 ; 71 cut-outs
GND on TOP: 105.89,29.26 105.89,29.26 105.54,29.61 103.16,29.61 103.12,29.65 103.07,29.65 103.07,30.71 102.68,31.1 102.68,31.65 102.72,31.69 103.09,31.69 103.52,32.12 103.52,38.14 103.74,38.37 123.08,38.37 123.63,38.92 126.77,38.92 128.5,37.19 128.5,35 129.01,34.48 129.01,33.01 127.4,31.4 123.97,31.4 122.68,30.11 121.04,30.11 120.19,29.26 ; 20 cut-outs
GND on TOP: 179.87,137.33 179.76,137.44 178.1,137.44 177.77,137.77 177.77,138.38 177.97,138.59 180.49,138.59 180.5,138.58 180.96,138.58 181.5,138.04 181.5,137.53 181.3,137.33
GND on TOP: 212.59,99.6 209.88,102.31 209.88,104.93 209.67,105.14 209.67,110.52 209.93,110.77 213.08,110.77 213.23,110.62 213.23,107.32 213.18,107.27 212.11,107.27 211.93,107.09 211.93,105.06 212.34,104.65 215.01,104.65 215.13,104.53 215.13,100.49 214.24,99.6
GND on TOP: 184,125.16 183.35,125.82 180.36,125.82 179.99,126.19 179.99,127.27 180.13,127.41 184.97,127.41 185.76,128.2 187.45,128.2 187.56,128.31 188.94,128.31 189.56,128.93 192.48,128.93 192.83,128.58 195.78,128.58 195.98,128.38 195.98,126.95 195.85,126.83 193.81,126.83 193.49,127.14 190.34,127.14 189.18,125.98 186.65,125.98 185.83,125.16 ; 5 cut-outs
GND on TOP: 156.81,35.61 156.73,35.68 156.73,36.46 156.12,37.07 156.12,37.6 156.25,37.72 157.47,37.72 158.2,36.99 158.2,35.86 157.95,35.61 ; 1 cut-out
GND on TOP: 194.61,132.44 194.48,132.57 194.48,135.72 193.77,136.43 193.77,137.27 193.87,137.37 195.14,137.37 195.4,137.11 195.93,137.11 196.11,136.94 196.11,136.61 195.19,135.69 195.19,135.36 195.4,135.16 195.7,135.16 195.91,134.95 195.91,132.77 195.57,132.44 ; 4 cut-outs
GND on TOP: 77.71,57.21 75.72,59.2 75.72,82.65 84.55,91.48 84.55,93.54 84.67,93.66 85.27,93.66 85.38,93.56 85.38,80.17 85.92,79.63 99.63,79.63 101.83,81.83 105.59,81.83 105.68,81.74 105.68,81.38 105.87,81.19 106.72,81.19 106.99,81.46 106.99,88.03 107.2,88.24 110.41,88.24 110.76,87.89 110.76,85.32 109.92,84.47 109.92,81.38 110.2,81.1 111.37,81.1 111.48,80.99 111.48,79.79 111.87,79.41 111.87,77.96 110.83,76.92 110.56,76.92 110.36,76.72 110.36,74.7 108.08,72.42 108.05,72.42 104.4,68.76 100.15,68.76 100,68.91 97.69,68.91 97.43,69.17 97.43,73.77 96.62,74.58 92.84,74.58 90.97,72.71 90.97,69.38 89.33,67.74 88.42,67.74 85.49,64.81 85.49,58.11 84.58,57.21 ; 35 cut-outs
GND on TOP: 61.19,40.39 60.79,40.79 60.79,43.52 61.01,43.74 64.77,43.74 64.92,43.58 64.92,40.51 64.8,40.39
GND on TOP: 206.61,160.83 206.45,160.99 206.45,161.79 206.53,161.87 207.51,161.87 208.1,161.28 208.1,161.03 207.89,160.83
GND on TOP: 131.44,130.2 131.31,130.33 131.31,133.76 131.57,134.01 134.74,134.01 134.87,133.89 134.87,132.74 134.61,132.49 133.47,132.49 133.09,132.11 133.09,130.33 132.96,130.2 ; 1 cut-out
GND on TOP: 31.95,28.96 31.57,29.34 31.57,31.62 31.52,31.68 31.52,32.57 31.57,32.62 32.28,32.62 32.47,32.43 32.47,31.71 32.75,31.44 34.36,31.44 34.42,31.37 39.19,31.37 39.28,31.28 39.28,30.53 39.23,30.48 36.59,30.48 36.36,30.71 34.39,30.71 34.13,30.46 34.13,28.96 ; 1 cut-out
GND on TOP: 103.72,120.66 103.3,121.09 103.3,134.58 104.38,135.66 107.47,135.66 107.75,135.38 107.75,130.09 108.08,129.75 113.09,129.75 113.27,129.58 113.27,127.43 112.85,127.01 107.79,127.01 107.01,126.23 107.01,121.17 106.5,120.66 ; 2 cut-outs
GND on TOP: 73.25,155.7 73.04,155.91 73.04,157.2 73.18,157.34 75.87,157.34 75.93,157.27 75.93,155.77 75.86,155.7
GND on TOP: 196.85,83.88 196.57,84.16 196.57,85.03 197.38,85.84 197.38,85.89 197.54,86.05 199.56,86.05 199.7,85.91 199.7,83.98 199.59,83.88
GND on TOP: 140.68,82.87 140.6,82.95 140.6,85.65 140.67,85.72 141.24,85.72 141.35,85.61 141.35,85.26 141.35,85.26 141.35,83.89 141.55,83.7 143.52,83.7 143.62,83.6 143.62,82.98 143.52,82.87 ; 1 cut-out
GND on TOP: 116.77,81.12 116.58,81.31 116.58,81.75 116.71,81.87 117.28,81.87 117.43,82.01 117.43,84.32 116.99,84.75 116.99,86.58 117.21,86.8 118.05,86.8 118.06,86.81 118.13,86.81 118.43,87.11 118.43,88.27 118.5,88.34 119.08,88.34 119.24,88.17 119.24,87.65 119.41,87.48 120.96,87.48 121.04,87.39 121.04,86.49 120.83,86.27 120.83,84.81 120.39,84.38 120.39,83.56 120.61,83.34 121.03,83.34 121.22,83.15 121.22,81.84 121.1,81.71 120.72,81.71 120.64,81.79 120.64,82.09 120.42,82.31 119.11,82.31 118.98,82.18 118.98,81.42 118.91,81.36 117.61,81.36 117.37,81.12 ; 13 cut-outs
GND on TOP: 165.84,163.73 165.69,163.89 165.69,168.48 164.29,169.87 164.29,176.18 167.29,179.17 169.88,179.17 169.89,179.18 186.03,179.18 186.19,179.03 186.19,176.71 186.05,176.58 183.05,176.58 182.68,176.21 181.97,176.21 181.97,176.21 181.14,176.21 180.65,176.7 170.79,176.7 170.77,176.68 169.18,176.68 167.53,175.04 167.53,163.86 167.41,163.73 ; 23 cut-outs
GND on TOP: 52.08,16.41 51.96,16.54 51.96,17.39 51.38,17.97 51.38,20.93 52.19,21.75 53.33,21.75 53.97,22.38 58.29,22.38 58.67,22 58.67,19.84 58.54,19.71 57.53,19.71 57.14,19.33 57.14,16.54 57.02,16.41 ; 6 cut-outs
GND on TOP: 190.34,76.08 190.17,76.25 190.17,76.52 190.36,76.71 192.1,76.71 192.2,76.61 192.2,76.14 192.14,76.08
GND on TOP: 19.89,69.42 19.64,69.66 19.64,70.37 18.99,71.02 18.99,71.66 18.55,72.11 17.2,72.11 17.1,72.2 17.1,74.12 17.78,74.8 17.78,77.23 17.98,77.43 20.99,77.43 22.66,75.76 22.66,69.86 22.22,69.42 ; 2 cut-outs
GND on TOP: 159.95,34.9 159.92,34.93 159.89,34.93 159.56,35.27 159.56,35.82 159.74,36.01 160.99,36.01 161.42,36.44 161.42,37.7 161.21,37.9 159.86,37.9 159.09,38.68 159.09,40.26 159.26,40.42 162.97,40.42 163.23,40.16 163.23,38.63 163.43,38.43 167.66,38.43 167.86,38.23 167.86,37.54 167.25,36.93 165.54,36.93 163.52,34.9 ; 6 cut-outs
GND on TOP: 124.49,86.39 124.39,86.49 124.39,87.07 124.22,87.25 123.61,87.25 123.49,87.37 123.49,87.76 123.61,87.89 124.76,87.89 125.2,88.32 128.55,88.32 129,87.87 129,87.15 128.86,87.01 127.84,87.01 127.22,86.39 ; 1 cut-out
GND on TOP: 128.98,58.7 128.79,58.89 128.79,61.32 128.83,61.36 129.77,61.36 129.9,61.22 129.9,58.91 129.69,58.7
GND on TOP: 167.39,57.27 166.54,58.12 166.54,58.16 166.1,58.59 164.09,58.59 163.94,58.45 163.34,58.45 163.28,58.5 163.28,59.13 163.98,59.83 169.76,59.83 170.57,59.02 170.57,57.6 170.24,57.27 ; 1 cut-out
GND on TOP: 34.31,45.23 34.18,45.36 34.18,47.27 34.06,47.39 32.79,47.39 32.66,47.52 32.66,50.19 32.79,50.31 34.31,50.31 34.82,49.81 37.23,49.81 38.25,48.79 38.25,46.25 38.12,46.12 37.36,46.12 36.47,45.23 ; 2 cut-outs
GND on TOP: 130.79,108.73 130.66,108.87 130.66,119.93 130.78,120.05 132.07,120.05 132.33,119.79 132.33,109.01 132.05,108.73 ; 8 cut-outs
GND on TOP: 153.26,89.95 152.95,90.26 152.95,91.26 153.02,91.33 153.98,91.33 154.98,90.33 154.98,90.11 154.81,89.95
GND on TOP: 208.13,97.42 208.06,97.48 208.06,99.18 208.16,99.28 209.93,99.28 209.99,99.21 209.99,97.55 209.87,97.42
GND on TOP: 212.76,148.54 212.56,148.75 212.56,153.63 212.56,153.63 212.56,156 212.77,156.21 213.89,156.21 214.42,155.68 214.42,151.16 213.69,150.43 213.69,148.85 213.38,148.54 ; 7 cut-outs
GND on TOP: 204.46,99.85 203.07,101.25 203.07,105.44 203.19,105.57 204.73,105.57 205.48,106.32 205.48,109.68 205.56,109.76 206.42,109.76 206.6,109.94 206.6,110.98 206.78,111.15 208.53,111.15 209.16,110.52 209.16,105.39 208.53,104.76 208.53,102.14 206.24,99.85
GND on TOP: 64.9,5.45 64.73,5.62 64.73,6.31 66.03,7.61 66.14,7.61 66.14,7.61 71.77,7.61 71.93,7.76 71.93,11.74 71.81,11.86 65.95,11.86 65.87,11.94 65.87,13.22 65.94,13.28 72.5,13.28 74.45,11.33 74.45,8.75 71.14,5.45 68.27,5.45 68.27,5.45
GND on TOP: 19.27,32.72 19.05,32.93 19.05,33.68 19.11,33.74 20.28,33.74 20.62,33.4 22.3,33.4 22.34,33.36 22.34,32.72 22.33,32.72
GND on TOP: 107.98,162.4 107.92,162.46 107.92,163.33 108.57,163.98 108.94,163.98 109.31,163.61 109.31,163.29 108.42,162.4
GND on TOP: 196.53,98.17 196.45,98.25 196.45,99.57 196.83,99.95 198.77,99.95 199.08,99.63 199.08,98.48 198.77,98.17
GND on TOP: 116.55,109.76 116.07,110.24 116.07,119.69 116.35,119.97 119.85,119.97 119.88,119.94 119.88,109.88 119.76,109.76 ; 12 cut-outs
GND on TOP: 19.33,38.53 19.25,38.61 19.25,39.83 19.12,39.97 18.59,39.97 18.46,40.1 18.46,40.59 20.92,40.59 21.15,40.37 22.96,40.37 23.13,40.19 23.13,39.96 22.96,39.78 21.58,39.78 21.5,39.7 21.5,39.34 21.42,39.25 21.42,38.63 21.34,38.55 20.13,38.55 20.11,38.57 19.54,38.57 19.5,38.53 ; 2 cut-outs
GND on TOP: 29.59,24.82 29.52,24.88 29.52,25.57 28.78,26.32 25.4,26.32 25.29,26.21 24.64,26.21 24.53,26.32 24.53,27.26 25.54,28.27 28.57,28.27 30.29,26.55 30.29,24.84 30.28,24.82 ; 4 cut-outs
GND on TOP: 132.62,110.77 132.47,110.91 132.47,117.07 132.6,117.2 133.94,117.2 134.12,117.01 134.12,112 134.12,110.87 134.02,110.77 ; 4 cut-outs
GND on TOP: 38.35,10.11 38.15,10.31 38.15,10.82 38.64,11.31 39.82,11.31 40.19,10.94 40.84,10.94 40.99,10.78 40.99,10.24 40.87,10.11 ; 3 cut-outs
GND on TOP: 169.26,66.79 168.74,67.32 168.74,67.97 169.11,68.34 170.42,68.34 170.51,68.25 170.51,67.75 170.91,67.36 170.91,66.86 170.85,66.79 ; 2 cut-outs
GND on TOP: 192.04,130.74 191.92,130.87 191.92,134.88 192.15,135.11 192.65,135.11 192.73,135.03 192.73,130.81 192.65,130.74
GND on TOP: 153.23,38.48 153,38.71 153,39.25 152.67,39.58 152.67,40.59 152.8,40.72 153.36,40.72 153.51,40.57 153.51,40.03 153.64,39.91 155.07,39.91 155.5,39.48 155.5,38.63 155.36,38.48 ; 2 cut-outs
GND on TOP: 196.92,134.4 196.83,134.49 196.83,135.9 196.95,136.02 197.43,136.02 197.92,136.52 198.28,136.52 198.47,136.71 198.47,137.72 198.59,137.83 200.5,137.83 200.83,137.5 200.83,137.14 200.76,137.06 199.77,137.06 199.53,136.82 198.83,136.82 198.57,136.56 198.57,136.16 198.73,136 198.73,135.36 198.47,135.1 198.47,134.7 198.17,134.4 ; 3 cut-outs
GND on TOP: 87.53,52.57 87.29,52.81 87.29,55.3 88.13,56.14 88.85,56.14 88.97,56.02 88.97,53.32 88.22,52.57 ; 2 cut-outs
GND on TOP: 42.57,45.23 42.44,45.36 42.44,46.5 41.93,47.01 40.66,47.01 40.28,46.63 40.28,46.25 40.15,46.12 39.52,46.12 39.26,46.38 39.26,47.65 41.8,50.19 44.85,50.19 44.98,50.06 44.98,47.14 45.11,47.01 45.11,45.49 44.85,45.23 ; 2 cut-outs
GND on TOP: 90.98,157.66 90.98,160.78 91.4,161.2 91.71,161.2 91.98,160.93 93.1,160.93 93.64,161.47 93.64,164.52 93.66,164.54 93.66,166.4 96.17,168.92 99.62,168.92 101.28,167.26 102.3,167.26 102.8,166.76 103.48,166.76 103.53,166.71 103.53,160.71 102.94,160.12 97.58,160.12 96.98,159.52 96.52,159.52 96.23,159.22 93.48,159.22 91.77,157.51 91.13,157.51
GND on TOP: 217.31,150.42 217.27,150.45 217.27,151.8 217.55,152.07 217.55,153.65 217.73,153.83 218.57,153.83 218.79,153.61 218.79,150.93 218.28,150.42 ; 3 cut-outs
GND on TOP: 169.33,125.45 169.01,125.77 169.01,126.78 170.56,128.33 170.56,128.66 170.64,128.75 171.11,128.75 171.18,128.68 171.18,126.39 170.24,125.45 ; 2 cut-outs
GND on TOP: 121.13,91.42 121.05,91.5 121.05,92.46 121.66,93.07 123.59,93.07 123.69,92.97 123.69,91.52 123.6,91.42 ; 2 cut-outs
GND on TOP: 186.49,143.74 185.87,144.36 185.65,144.36 185.43,144.58 185.43,145.13 185.44,145.14 185.44,145.65 185.54,145.75 187.16,145.75 187.17,145.75 187.4,145.75 187.52,145.62 187.52,143.9 187.37,143.74 ; 3 cut-outs
GND on TOP: 25.63,41.6 25.47,41.76 24.46,41.76 24.25,41.97 24.25,44.63 24.76,45.14 26.51,45.14 26.51,41.71 26.4,41.6 ; 1 cut-out
GND on TOP: 139.57,111.91 139.46,112.01 139.46,115.33 139.65,115.52 141.98,115.52 142.24,115.26 142.24,113.28 140.87,111.91 ; 2 cut-outs
GND on TOP: 192.43,71.99 191.86,72.56 191.38,72.56 191.21,72.73 191.21,73.15 191.32,73.26 192.66,73.26 192.89,73.02 192.89,72.09 192.79,71.99
GND on TOP: 138.78,151.76 139.39,151.76 139.66,152.03 140.61,152.03 141.08,152.5 141.08,153.15 141.3,153.37 142.39,153.37 142.73,153.02 142.73,152.45 141.33,151.04 138.68,151.04 138.66,151.06 138.66,151.64
GND on TOP: 40.18,14.41 39.75,14.84 38.52,14.84 38.43,14.93 38.43,15.12 38.4,15.15 38.37,15.15 38.37,15.68 38.45,15.75 39.62,15.75 40.04,15.33 40.65,15.33 40.74,15.24 40.74,14.53 40.61,14.41
GND on TOP: 133.98,61.54 133.85,61.67 133.85,62.08 133.97,62.19 134.79,62.19 135.18,62.58 135.18,62.73 135.3,62.85 135.3,64.2 135.35,64.25 135.76,64.25 135.96,64.06 135.96,63.83 136.54,63.24 136.54,62.99 136.79,62.74 137.33,62.74 137.97,63.37 138.45,63.37 138.67,63.16 138.67,61.97 138.61,61.9 136.26,61.9 136.13,61.78 136.13,61.59 136.08,61.54 ; 3 cut-outs
GND on TOP: 186.93,139.79 186.93,141.58 186.61,141.9 185.8,141.9 185.12,142.59 183.13,142.59 183.04,142.67 183.04,143.21 183.25,143.41 183.25,144.61 183.72,145.08 184.21,145.08 184.26,145.03 184.26,143.75 184.65,143.36 185.6,143.36 186.36,142.61 186.77,142.61 186.83,142.66 186.83,142.94 186.95,143.06 187.69,143.06 187.76,142.99 187.76,139.9 187.65,139.79 ; 4 cut-outs
GND on TOP: 35.34,14.29 35.25,14.38 35.25,14.93 35.03,15.15 34.51,15.15 34.36,15.29 34.36,16.13 34.79,16.57 35.38,16.57 35.63,16.31 35.63,15.85 35.76,15.73 36.1,15.73 36.27,15.56 36.27,14.4 36.15,14.29 ; 1 cut-out
GND on TOP: 203.38,137.33 202.92,137.79 202.92,138.43 203.04,138.56 203.71,138.56 203.89,138.74 204.82,138.74 204.91,138.65 204.91,137.84 204.4,137.33 ; 1 cut-out
GND on TOP: 117.96,18.83 117.65,19.15 117.65,21.52 117.74,21.61 118.25,21.61 118.67,21.19 118.87,21.19 118.87,21.19 119.04,21.01 119.04,19.25 118.63,18.83 ; 3 cut-outs
GND on TOP: 197.12,138.59 197.05,138.66 197.05,139.43 196.92,139.55 195.07,139.55 194.79,139.27 194.79,139.09 194.46,138.76 193.11,138.76 192.97,138.9 192.06,138.9 191.18,139.78 189.89,139.78 189.76,139.91 189.76,140.44 189.89,140.57 190.78,140.57 190.9,140.44 191.5,140.44 191.8,140.14 192.93,140.14 193.15,140.35 193.43,140.35 193.67,140.11 194.79,140.11 195.86,141.17 195.86,141.52 195.71,141.67 195.08,141.67 194.79,141.38 193.75,141.38 193.49,141.64 192.99,141.64 192.69,141.34 191.74,141.34 191.51,141.56 191.25,141.56 190.95,141.86 190.95,142.22 191.12,142.4 196.26,142.4 196.32,142.46 196.32,142.49 196.4,142.57 196.4,143.39 196,143.79 189.32,143.79 189.09,144.03 189.09,144.35 189.26,144.52 196.08,144.52 196.49,144.92 196.49,145.88 196.59,145.98 197.2,145.98 197.34,145.85 197.34,140.21 197.58,139.97 197.58,138.65 197.52,138.59 ; 6 cut-outs
GND on TOP: 183.06,84.68 182.75,84.99 182.75,84.99 182.69,85.05 182.69,86.09 182.9,86.31 183.89,86.31 184.09,86.11 184.09,85.66 184.51,85.24 184.51,84.78 184.41,84.68 ; 2 cut-outs
GND on TOP: 16.08,28.3 15.48,28.9 15.48,31.76 15.54,31.82 18.84,31.82 18.91,31.74 18.91,28.59 18.62,28.3
GND on TOP: 115.06,159.54 114.17,160.43 114.17,161.32 114.55,161.7 116.96,161.7 117.22,161.95 117.22,162.34 117.47,162.59 121.53,162.59 121.66,162.46 121.66,159.92 121.28,159.54 ; 2 cut-outs
GND on BOTTOM: 141.11,83.05 140.63,83.53 140.63,83.94 140.71,84.01 143.18,84.01 143.53,83.67 143.53,83.21 143.43,83.11 143.43,82.4 143.33,82.3 142.93,82.3 142.81,82.41 142.81,82.83 142.59,83.05
GND on BOTTOM: 76.32,65.82 73.76,68.38 73.76,80.99 82.87,90.1 84.17,90.1 86.08,88.19 86.08,77.6 89,74.68 89,73.77 90.9,71.87 90.9,69.91 89.22,68.23 86.54,68.23 84.14,65.82
GND on BOTTOM: 150.96,5.58 150.82,5.71 150.82,7.64 151.08,7.89 151.08,8.15 151.2,8.27 152.6,8.27 152.6,8.27 152.8,8.27 154.18,9.65 154.18,12.87 154.92,13.61 159.48,13.61 159.86,13.23 159.86,6.22 159.22,5.58
GND on BOTTOM: 24.57,29.9 24.57,32.62 24.74,32.79 28.21,32.79 28.47,32.53 28.47,31.43 28.61,31.28 29.34,31.28 29.59,31.04 29.59,30.05 29.44,29.9
GND on BOTTOM: 141.09,133.89 140.84,134.14 140.84,135.67 140.96,135.79 147.44,135.79 147.49,135.74 147.49,133.94 147.26,133.94 147.26,135.2 147.23,135.23 145.64,135.23 145.61,135.21 145.61,133.96 145.54,133.89
GND on BOTTOM: 114.17,159.54 113.91,159.8 113.91,161.95 114.55,162.59 121.66,162.59 121.66,159.92 121.28,159.54 ; 3 cut-outs
GND on BOTTOM: 135.8,61.05 135.44,61.41 135.44,63.09 135.62,63.27 135.63,63.27 135.74,63.38 136.42,63.38 136.57,63.22 136.57,63.02 137.05,62.54 137.05,61.11 136.99,61.05
GND on BOTTOM: 145.79,99.27 145.66,99.39 143.35,99.39 143.23,99.52 143.23,101.07 142.92,101.38 139.9,101.38 139.47,101.81 139.47,103.51 139.52,103.56 140.84,103.56 141.5,102.9 146.07,102.9 146.27,102.7 147.11,102.7 147.14,102.67 147.14,99.34 147.06,99.27 ; 14 cut-outs
GND on BOTTOM: 150.29,28.32 150.18,28.43 150.18,38.74 152,40.56 154.73,40.56 155.16,40.13 155.16,38.42 154.28,37.54 154.28,28.83 153.77,28.32
GND on BOTTOM: 179.96,139.96 179.58,140.34 179.58,145.43 181.44,147.28 182.12,147.28 183.16,148.32 183.16,148.44 184.15,149.43 185.31,149.43 185.66,149.08 185.66,148.26 186.14,147.78 186.17,147.78 186.17,147.37 185.83,147.04 185.83,145.68 186.17,145.35 186.17,142.34 185.89,142.06 185.42,142.06 185.4,142.07 184.74,142.07 184.74,142.08 184.6,141.94 184.6,140.95 184.43,140.79 184.29,140.79 184.15,140.92 183.92,140.92 183.74,140.74 183.74,140.43 183.9,140.27 183.9,140.11 183.76,139.96
GND on BOTTOM: 86.48,95.76 86.24,96 85.66,96 85.52,96.14 85.52,97.1 86.39,97.97 87.02,97.97 87.12,97.87 87.12,95.83 87.05,95.76 ; 1 cut-out
GND on BOTTOM: 110.69,78.02 110.03,78.68 109.93,78.78 109.58,78.78 109.46,78.65 109.24,78.65 108.67,79.23 108.67,79.88 108.49,80.05 107.37,80.05 107.2,79.88 107.2,79.21 107.12,79.13 106.93,79.13 106.83,79.23 106.83,79.9 106.63,80.1 105.66,80.1 105.45,79.9 105.45,79.19 104.91,78.65 104.61,78.65 104.53,78.73 104.53,78.97 104.99,79.44 104.99,79.86 104.81,80.05 103.71,80.05 103.53,79.86 103.53,79.2 103.42,79.09 103.28,79.09 103.16,79.21 103.16,79.85 102.95,80.06 102.77,80.06 102.54,79.83 102.3,79.83 102.18,79.95 101.91,79.95 101.54,79.57 101.35,79.57 101.03,79.89 101.03,82.14 100.55,82.62 100.55,83.08 100.62,83.15 101.46,83.15 101.67,82.94 101.67,81.22 101.69,81.19 111.24,81.19 111.74,80.69 111.74,78.46 111.55,78.26 111.4,78.26 111.16,78.02
GND on BOTTOM: 214.32,100.72 214.19,100.84 214.19,101.15 213.99,101.35 211.83,101.35 211.48,101.71 211.48,103.94 209.67,105.74 209.67,109.25 209.8,109.38 210.18,109.38 210.31,109.5 210.31,109.88 210.69,110.27 210.94,110.27 211.45,110.77 211.83,110.77 211.96,110.65 211.96,109.76 212.21,109.5 213.1,109.5 213.23,109.38 213.23,106.2 213.35,106.07 213.35,105.66 213.9,105.11 214.76,105.11 214.76,105.11 215.03,105.11 215.26,104.88 215.26,100.92 215.06,100.72 ; 2 cut-outs
GND on BOTTOM: 197.99,121.31 197.35,121.95 197.35,125.51 198.11,126.27 201.54,126.27 202.05,125.76 202.05,121.57 201.8,121.31
GND on BOTTOM: 191.09,138.02 190.96,138.14 190.96,138.27 197.31,144.62 197.31,145.13 197.19,145.26 196.68,145.26 189.82,138.4 189.69,138.4 189.44,138.65 189.44,138.78 196.86,146.21 197.33,146.21 197.69,145.85 197.69,140.18 195.53,138.02 195.15,138.02 195.03,138.14 195.03,138.4 197.31,140.68 197.31,140.94 196.93,141.32 196.8,141.32 193.63,138.14 193.25,138.14 193.12,138.27 193.12,138.52 197.44,142.84 197.44,142.97 197.06,143.35 196.8,143.35 191.47,138.02
GND on BOTTOM: 44.53,167.2 44.4,167.33 44.4,170.14 44.59,170.33 48.34,170.33 48.54,170.13 48.54,167.34 48.4,167.2 ; 4 cut-outs
GND on BOTTOM: outline of 200 points within 0.76,0.76 221.04,181.21 ; 48 cut-outs
GND on BOTTOM: 156.14,115.03 156.08,115.09 156.08,118.39 156.2,118.52 156.87,118.52 157.04,118.69 157.04,119.63 157.26,119.85 158.74,119.85 159.53,119.06 159.53,117.91 159.44,117.82 158.36,117.82 157.59,117.05 157.59,115.73 156.89,115.03 ; 3 cut-outs
GND on BOTTOM: 148.51,52.28 148.38,52.4 148.38,53.04 149.04,53.7 151.38,53.7 151.51,53.57 151.51,52.58 151.2,52.28 ; 2 cut-outs
GND on BOTTOM: 124.73,43.78 124.29,44.22 124.29,47.98 126.15,49.84 128.27,49.84 129.94,48.17 129.94,43.86 129.86,43.78
GND on BOTTOM: 140.42,6.52 140.19,6.75 140.19,11.04 140.43,11.28 148.85,11.28 150.43,12.86 152.96,12.86 153.32,12.5 153.32,10.94 152.59,10.21 149.67,10.21 149.48,10.02 149.48,7.68 149.31,7.5 146.58,7.5 145.6,6.52 ; 2 cut-outs
GND on BOTTOM: 116.47,107.94 116.06,108.35 116.06,119.46 116.44,119.83 119.63,119.83 119.88,119.57 119.88,108.27 119.55,107.94 ; 12 cut-outs
