# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQS_DP6: length 61
  TOP w0.127: v2(117.4,36.06) 117.18,36.06 v1(116.89,36.35)
  L3 w0.114: v2(121.16,63.4) 121.25,63.5 121.42,63.5 121.55,63.37 121.55,62.61 123.32,60.84 124.42,60.84 128.16,57.1 128.16,56.55 128.4,56.31 128.78,56.31 128.93,56.16 128.93,55.94 128.78,55.79 128.38,55.79 128.11,55.52 128.11,55.11 128.38,54.84 128.84,54.84 128.99,54.69 128.99,54.47 128.84,54.32 128.38,54.32 128.11,54.04 128.11,53.64 128.38,53.37 128.85,53.37 129.01,53.21 129.01,53 128.85,52.84 128.38,52.84 128.11,52.57 128.11,52.17 128.38,51.89 128.84,51.89 129,51.74 129,51.52 128.84,51.37 128.4,51.37 128.16,51.13 128.16,50.53 129.01,49.67 129.01,45.9 126.72,43.61 126.72,43.27 126.87,43.12 126.87,42.96 126.66,42.75 126.5,42.75 126.35,42.9 126.01,42.9 125.71,42.6 123.3,42.6 117.85,37.16 117.85,36.12 117.68,35.95 117.51,35.95 v2(117.4,36.06)
  BOTTOM w0.089: 120.19,70.11 120.19,70.13 120.17,70.16 120.17,70.63 119.61,71.19 119.61,72.53 119.65,72.68 119.65,72.88 119.59,73.08 119.59,73.41 119.57,73.44 CPU1.AY30
  BOTTOM w0.127: DM1.171 116.65,37.17 116.28,36.8 116.28,36.3 116.81,35.77 117.11,35.77 v2(117.4,36.06) ; v2(121.16,63.4) 121.37,63.62 121.76,63.62 122.05,63.91 122.05,64.48 121.73,64.8 120.61,64.8 120.19,65.21 120.19,70.11
M_A_DQS_DP7: length 62
  TOP w0.127: v2(121.83,32) 121.16,32 v1(120.95,31.79)
  L3 w0.114: v2(123.7,64.76) 123.7,64.69 123.98,64.41 127.93,64.41 134,58.35 134,56.03 133.61,55.64 133.61,42 130,38.39 130,38.23 130.13,38.1 130.13,37.76 129.8,37.42 129.46,37.42 129.33,37.55 127.97,37.55 127.55,37.14 123.89,37.14 123.6,36.85 123.6,34.52 122.81,33.73 122.81,33.31 122.34,32.83 122.34,32.07 122.22,31.95 121.89,31.95 v2(121.83,32)
  BOTTOM w0.089: 122.41,70.35 122.4,70.36 122.36,70.36 122.04,70.68 122.04,72.07 122.04,72.11 121.95,72.37 121.95,72.51 121.98,72.6 122.01,72.68 122.01,72.82 122.02,72.85 121.98,72.97 121.95,73.06 121.93,73.09 121.66,73.43 CPU1.BA26
  BOTTOM w0.127: v2(123.7,64.76) 123.7,64.64 123.56,64.5 123.09,64.5 122.75,64.84 122.75,70.01 122.41,70.35 ; DM1.188 121.75,30.66 121.45,30.97 121.45,31.87 121.57,32 v2(121.83,32)
M_A_RAS#: length 55.7
  TOP w0.216: v2(98.97,32.07) 98.7,32.07 v1(98.44,31.81)
  L3 w0.089: v2(107.91,75.25) 107.91,74.94 106.6,73.64 106.6,72.13 108.8,69.93 108.8,60.64 108.5,60.34
  L3 w0.203: v2(98.97,32.07) 98.89,32.07 98.4,31.58 98.05,31.58 97.89,31.75 97.89,34.28 98.2,34.6 98.2,37.77 99.5,39.06 99.5,43.93 99.88,44.31 101.04,44.31 103.47,46.74 103.47,47.49 102.9,48.06 102.9,48.45 107.85,53.4 107.85,53.42 107.97,53.53 107.97,59.81 108.5,60.34
  BOTTOM w0.216: v2(107.91,75.25) 107.78,75.25 CPU1.AU50 ; DM1.110 98.35,31.66 98.76,32.07 v2(98.97,32.07)
M_A_WE#: length 55.5
  TOP w0.216: v2(99.3,33.99) 98.74,33.99 v1(98.74,33.99)
  L3 w0.203: v2(109.74,75.9) 109.29,75.45 109.29,71.99 109.75,71.53 109.75,70.81 110.71,69.85 110.71,64.55 109.85,63.69 109.85,52.93 106.82,49.89 106.82,47.7 101.85,42.73 101.85,42.54 101.64,42.34 101.33,42.34 101.18,42.19 101.18,41.68 101.33,41.53 101.64,41.53 101.85,41.32 101.85,39.03 100.24,37.42 100.24,36.35 100.26,36.34 100.26,33.72 100.05,33.52 99.6,33.52 99.4,33.72 99.4,33.89 v2(99.3,33.99)
  BOTTOM w0.216: CPU1.AT46 109.41,76.22 v2(109.74,75.9) ; v2(99.3,33.99) 99.03,33.99 98.71,34.31 98.71,36.84 99.25,37.38 DM1.113
M_B_A0: length 76.7
  TOP w0.216: v2(109.25,18.26) 109.25,17.68 v1(109.24,17.67)
  L4 w0.089: 107.76,61.76 108.04,62.04 108.04,63.1 v2(107.6,63.53)
  L4 w0.203: 107.76,61.76 107.76,59.87 104.19,56.3 104.19,54.4 105.82,52.77 105.82,44.55 105.37,44.11 105.37,39.46 105.66,39.17 105.66,38.07 106.11,37.62 106.11,33.87 106.1,33.85 106.1,31.18 107.86,29.42 108.65,29.42 109.51,28.56 109.51,22.19 109.18,21.86 109.18,20.18 109.19,20.17 109.19,19.61 109.39,19.41 109.92,19.41 110.12,19.21 110.12,16.46 110.33,16.25 111.93,16.25 112.14,16.05 112.14,14.08 112.01,13.95 109.43,13.95 109.21,14.16 109.21,18.22 v2(109.25,18.26)
  BOTTOM w0.089: 109.04,65.83 109.04,70.39 109.68,71.03 109.68,71.58 109.68,71.58 109.68,72.54 109.76,72.87 109.76,72.87 CPU1.BA46
  BOTTOM w0.216: 109.04,65.83 109.04,64.97 v2(107.6,63.53) ; DM2.98 109.25,18.25 v2(109.25,18.26)
M_B_A1: length 77.7
  TOP w0.216: v2(108.38,23.43) 108.38,23.81 v1(108.21,23.97)
  L4 w0.089: 106.88,61.95 107.2,62.27 107.2,63.77 v2(107.59,64.17)
  L4 w0.203: 106.88,61.95 106.61,61.68 106.61,60.31 101.45,55.14 101.45,49.17 101.64,48.97 102.06,48.97 102.26,49.17 102.26,54.71 102.46,54.91 102.87,54.91 103.07,54.71 103.07,48.73 102.63,48.29 102.63,41.86 102.83,41.65 103.24,41.65 103.44,41.86 103.44,44 103.64,44.2 104.05,44.2 104.25,44 104.25,39 104.54,38.71 104.54,37.61 105,37.16 105,34.34 104.54,33.88 104.54,33.78 104.51,33.75 104.51,31.01 108.38,27.13 v2(108.38,23.43)
  BOTTOM w0.089: CPU1.AY46 109.55,73.16 109.55,72.75 109.5,72.56 109.5,71.51 109.5,71.51 109.5,71.15 108.86,70.51 108.86,66.06 108.66,65.86
  BOTTOM w0.216: 108.66,65.86 108.66,65.2 107.62,64.17 v2(107.59,64.17) ; v2(108.38,23.43) 108.95,24 DM2.97
M_B_A2: length 77.8
  TOP w0.216: v1(107.44,20.04) 107.62,20.21 v2(107.98,20.21)
  L4 w0.089: v2(107.62,66.07) 106.77,65.22 106.77,63.01 106.57,62.81
  L4 w0.203: v2(107.98,20.21) 107.98,20.21 107.78,20.01 107.47,20.01 107.26,20.21 107.26,26.67 103.39,30.54 103.39,34.21 103.43,34.25 103.43,38.25 102.95,38.72 102.95,39.78 101.48,41.25 101.48,47 98.59,49.89 98.59,53.46 98.79,53.66 99.2,53.66 99.4,53.46 99.4,50.56 99.61,50.35 100.01,50.35 100.21,50.56 100.21,55.49 105.44,60.71 105.44,61.68 106.57,62.81
  BOTTOM w0.089: 108.35,67.35 108.5,67.49 108.5,71.7 108.87,72.07 108.87,72.54 108.84,72.67 108.84,72.88 108.91,73.2 108.91,73.63 CPU1.AY47
  BOTTOM w0.216: DM2.96 108.65,19.49 108.88,19.72 109.87,19.72 110.1,19.95 110.1,20.41 109.87,20.64 108.4,20.64 v2(107.98,20.21) ; v2(107.62,66.07) 107.82,66.07 108.16,66.42 108.16,67.15 108.35,67.35
M_B_A3: length 75.7
  TOP w0.216: v1(109.08,21.93) 108.71,21.93 v2(108.48,22.16)
  L4 w0.203: v2(108.48,22.16) 108.53,22.16 108.94,22.56 108.94,27.37 105.36,30.95 105.35,30.95 105.07,31.24 105.07,33.52 105.1,33.55 105.1,33.65 105.56,34.1 105.56,37.39 105.1,37.84 105.1,38.94 104.81,39.23 104.81,44.34 105.26,44.79 105.26,52.37 105.03,52.6 104.67,52.6 104.45,52.37 104.45,45.32 104.22,45.09 103.86,45.09 103.63,45.32 103.63,56.54 107.2,60.1 107.2,61.81 107.61,62.22 v2(107.61,62.9)
  BOTTOM w0.089: CPU1.BB46 109.94,72.22 109.86,72.14 109.86,70.94 109.29,70.37 109.29,67.13 109.41,67.01 109.41,66.91
  BOTTOM w0.216: DM2.95 108.35,24.23 107.89,23.77 107.89,22.6 108.33,22.16 v2(108.48,22.16) ; 109.41,66.91 109.41,64.69 v2(107.61,62.9)
M_B_A4: length 74.7
  TOP w0.216: v2(107.98,18.89) 107.7,18.89 v1(107.44,18.63)
  L4 w0.089: v2(107.62,65.44) 107,64.82 107,62.66 106.8,62.46
  L4 w0.203: 106.8,62.46 106.03,61.69 106.03,60.52 100.77,55.26 100.77,49.05 102.04,47.79 102.04,41.64 103.51,40.17 103.51,38.95 103.99,38.48 103.99,34.02 103.95,33.98 103.95,31.24 103.95,30.77 107.82,26.9 107.82,26.82 107.82,26.82 107.82,23.67 107.82,23.66 107.82,23.2 107.82,23.2 107.82,21.4 108.62,20.61 108.62,19.94 108.63,19.94 108.63,14.86 108.5,14.73 107.24,14.73 107.11,14.86 107.11,16.25 107.49,16.63 107.49,18.42 107.78,18.71 107.8,18.71 v2(107.98,18.89)
  BOTTOM w0.089: 108.58,66.97 108.68,67.07 108.68,71.63 109.05,72 109.05,72.57 109.01,72.7 109.01,72.86 109.09,73.16 CPU1.BA47
  BOTTOM w0.216: v2(107.62,65.44) 107.79,65.44 108.58,66.22 108.58,66.97 ; v2(107.98,18.89) 107.65,18.89 107.45,18.7 DM2.92
M_B_A5: length 75.9
  TOP w0.216: v2(106.61,22.16) 106.74,22.28 106.97,22.28 v1(107.12,22.42)
  L4 w0.089: v2(107.59,67.98) 107.28,67.98 107.18,68.07 107.18,69.62 107.05,69.75 106.16,69.75 106.03,69.62 106.03,63.61 105.82,63.39 105.1,63.39 104.89,63.19
  L4 w0.203: v2(106.61,22.16) 106.24,22.16 106.11,22.28 106.11,25.18 105.3,25.99 105.3,27.05 101.83,30.53 101.83,33.88 101.88,33.93 101.88,37.45 100.77,38.57 100.77,39.99 100.19,40.56 100.19,41.49 99.92,41.77 98.99,41.77 98.66,42.1 98.66,47.72 98.63,47.74 98.63,47.74 97.26,49.12 97.26,54.12 98.32,55.18 98.32,55.18 104.07,60.93 104.07,62.37 104.89,63.19
  BOTTOM w0.089: 107.12,68.98 107.12,69.36 107.91,70.14 107.91,71.94 108.16,72.19 108.16,72.63 108.37,73.48 CPU1.AY48
  BOTTOM w0.216: 107.12,68.98 107.12,68.37 107.52,67.98 v2(107.59,67.98) ; DM2.91 107.15,24.01 107.32,23.84 107.32,21.97 107.55,21.74 107.61,21.74 107.84,21.52 107.84,21.09 107.48,20.73 107.48,20.19 107.26,19.97 106.95,19.97 106.73,20.19 106.73,20.63 106.5,20.86 106.17,20.86 105.94,21.09 105.94,21.96 106.17,22.18 106.59,22.18 v2(106.61,22.16)
M_B_A6: length 73.7
  TOP w0.216: v2(106.23,18.27) v1(106.23,17.7)
  L4 w0.203: v2(106.23,18.27) 105.9,18.27 105.67,18.04 105.67,17.23 105.88,17.03 106.72,17.03 106.93,17.23 106.93,19.76 106.7,19.98 106.7,20.84 106.22,21.32 106.22,21.39 106.02,21.6 106.01,21.6 105.84,21.76 105.75,21.76 105.55,21.96 105.55,22.52 105.55,22.52 105.55,22.98 105.55,24.95 104.75,25.75 104.75,26.74 101.27,30.21 101.27,34.11 101.32,34.16 101.32,37.1 99.52,38.91 99.52,40.36 98.1,41.78 98.1,47.49 98.07,47.51 98.07,47.51 96.67,48.92 96.67,54.32 98.09,55.74 98.09,55.74 103.51,61.16 103.51,62.47 104.44,63.4 104.49,63.4 104.76,63.67 104.76,68.96 106.01,70.22 107.21,70.22 107.58,69.84 v2(107.58,69.25)
  BOTTOM w0.089: 107.97,69.63 108.09,69.76 108.09,71.87 108.34,72.11 108.34,72.56 108.38,72.75 CPU1.BA48
  BOTTOM w0.216: 107.97,69.63 107.58,69.25 v2(107.58,69.25) ; v2(106.23,18.27) 106.23,18.31 106.43,18.52 106.76,18.52 106.85,18.43 DM2.90
M_B_A7: length 76.5
  TOP w0.216: v1(105.72,19.3) 106.01,19.59 v2(106.22,19.59)
  L4 w0.089: v2(108.81,77.11) 108.62,77.11 108.49,76.97 108.49,74.46 108.6,74.35 108.6,73.46 108.49,73.35
  L4 w0.203: v2(106.22,19.59) 106.04,19.42 105.89,19.42 105.46,18.99 105.17,18.99 104.97,19.19 104.97,19.99 105.18,20.19 105.5,20.19 105.7,20.4 105.7,20.8 105.5,21.01 105.19,21.01 104.88,21.32 104.88,21.79 104.97,21.89 104.97,24.74 103.77,25.94 103.77,26.92 103.5,27.2 102.6,27.2 101.53,28.26 101.53,29.11 100.57,30.07 100.57,34.16 100.34,34.39 100.34,36.49 100.32,36.51 100.32,37.1 100.32,37.11 100.32,37.19 98.96,38.54 98.96,39.55 98.96,40.13 97.52,41.58 97.52,47.28 96.99,47.81 96.26,47.81 95.95,48.12 95.95,54.4 102.95,61.39 102.95,62.82 103.6,63.47 103.6,68.46 105.81,70.68 107.39,70.68 107.68,70.98 107.68,72.55 108.49,73.35
  BOTTOM w0.216: DM2.86 105.65,19.65 105.8,19.79 106.02,19.79 v2(106.22,19.59) ; CPU1.AP48 108.4,77.52 v2(108.81,77.11)
M_B_A8: length 72.3
  TOP w0.216: v1(106.57,24.07) 106.68,23.96 v2(106.68,23.5)
  L4 w0.203: v2(107.61,67.34) 106.61,67.34 106.39,67.12 106.39,63.33 105.53,62.47 105.04,62.47 104.63,62.06 104.63,60.7 99.32,55.39 99.32,55.1 99.63,54.79 99.63,54.5 99.35,54.22 99.04,54.22 98.74,54.52 98.46,54.52 98.03,54.1 98.03,49.14 99.22,47.95 99.22,42.55 99.42,42.35 99.82,42.35 100.03,42.55 100.03,46.61 100.23,46.82 100.64,46.82 100.84,46.61 100.84,40.71 101.35,40.2 101.35,38.84 102.5,37.69 102.5,36.89 102.87,36.52 102.87,34.48 102.83,34.45 102.83,34.3 102.46,33.92 102.46,33.72 102.39,33.65 102.39,30.76 106.68,26.47 v2(106.68,23.5)
  BOTTOM w0.089: CPU1.BB48 108.61,72.1 108.3,71.79 108.3,69.55 108.14,69.39 108.14,69.08
  BOTTOM w0.216: 108.14,69.08 108.14,67.79 107.69,67.34 v2(107.61,67.34) ; DM2.89 106.55,24.26 105.92,23.63 105.92,23.38 106.12,23.17 106.35,23.17 106.67,23.5 v2(106.68,23.5)
M_B_A9: length 74.2
  TOP w0.216: v1(102.88,20.46) 103.16,20.18 v2(103.37,20.18)
  L4 w0.089: 106,73.45 106.38,73.83 106.38,76.5 106.43,76.55 106.43,76.76 106.6,76.92 106.6,77.38 107,77.78 v2(107,77.86)
  L4 w0.203: v2(103.37,20.18) 103.27,20.28 103.21,20.28 102.89,20.6 102.89,21 102.26,21.63 102.26,24.28 98.33,28.21 98.33,30.53 97.9,30.97 97.9,31 97.62,31.28 97.62,33.45 97.16,33.91 97.16,37.14 95.56,38.74 95.56,39.98 93.59,41.95 93.59,42.05 93.58,42.06 93.58,55.26 100.78,62.46 100.78,68.23 106,73.45
  BOTTOM w0.216: DM2.85 105.35,22.06 103.46,20.18 v2(103.37,20.18) ; CPU1.AP50 107.11,77.86 v2(107,77.86)
M_B_A10: length 76.1
  TOP w0.216: v1(112.45,24.07) 112.45,24.07 v2(112.45,23.51)
  L4 w0.203: v2(110.24,65.69) 110.63,65.3 110.63,64.66 110.27,64.3 110.27,58.57 108.65,56.95 108.65,50.15 108.87,49.93 109.26,49.93 109.46,50.13 109.46,56.37 109.66,56.57 110.07,56.57 110.27,56.37 110.27,49.14 109.96,48.83 109.96,39.48 110.17,39.28 111.36,39.28 111.56,39.08 111.56,38.67 111.36,38.47 110.23,38.47 110.02,38.27 110.02,37.78 110.23,37.58 111.39,37.58 111.59,37.38 111.59,36.86 111.39,36.65 110.75,36.65 110.55,36.45 110.55,34 110.71,33.83 110.71,31.03 112.58,29.17 112.58,28.85 112.78,28.64 112.96,28.64 113.11,28.49 113.11,27.98 112.96,27.83 112.78,27.83 112.58,27.63 112.58,25.73 112.78,25.53 112.85,25.53 113.02,25.36 113.02,24.98 112.85,24.81 112.78,24.81 112.58,24.6 112.58,23.64 v2(112.45,23.51)
  BOTTOM w0.089: CPU1.AW46 110.04,74.11 110.15,73.77 110.15,73.35 110.2,73.26 110.2,72.15 110.11,72.07 110.11,72.06 110.11,72.06 110.11,70.85 109.51,70.25 109.51,67.27 109.78,66.99
  BOTTOM w0.216: 109.78,66.99 109.78,66.16 110.24,65.7 v2(110.24,65.69) ; DM2.107 111.95,23.96 112.4,23.51 v2(112.45,23.51)
M_B_A11: length 77.8
  TOP w0.216: v1(104.82,20.67) 104.82,20.58 v2(104.47,20.22)
  L4 w0.089: v2(107.92,78.55) 108.3,78.17 108.3,73.9 107.21,72.81
  L4 w0.203: v2(104.47,20.22) 104.41,20.28 104.41,20.99 104.21,21.19 104.13,21.19 103.93,21.39 103.93,21.8 104.13,22 104.21,22 104.41,22.2 104.41,24.51 100.54,28.38 100.54,29.3 100.01,29.83 100.01,33.92 99.77,34.17 99.77,34.82 99.76,34.83 99.76,36.95 98.3,38.41 98.3,40 96.96,41.34 96.96,47.05 96.75,47.25 96.35,47.25 96.14,47.05 96.14,46.08 95.94,45.88 95.53,45.88 95.33,46.08 95.33,54.56 102.24,61.48 102.24,62.7 103.17,63.62 103.17,68.77 107.21,72.81
  BOTTOM w0.216: v2(107.92,78.55) 108.3,78.17 CPU1.AN48 ; DM2.84 105.05,19.85 105.41,20.22 105.41,20.55 105.19,20.78 104.9,20.78 104.47,20.35 v2(104.47,20.22)
M_B_A12: length 76.4
  TOP w0.216: v1(103.93,22.88) 103.76,22.72 v2(103.37,22.72)
  L4 w0.203: v2(107.02,78.55) 107.27,78.55 107.68,78.14 107.68,77.69 107.43,77.44 107.43,76.72 107.44,76.71 107.44,76.34 107.43,76.33 107.43,75.44 107.44,75.43 107.44,75.06 107.43,75.06 107.43,73.7 106.8,73.07 106.79,73.07 102.54,68.82 101.62,67.9 101.62,66.64 101.83,66.44 102.05,66.44 102.25,66.23 102.25,65.83 102.05,65.62 101.83,65.62 101.62,65.42 101.62,64.87 101.83,64.67 102.04,64.67 102.25,64.47 102.25,63.76 102.04,63.55 101.9,63.55 101.7,63.35 101.7,61.72 94.7,54.73 94.7,44.11 94.93,43.88 95.29,43.88 95.52,44.11 95.52,45.09 95.75,45.31 96.1,45.31 96.33,45.09 96.33,40.99 97.2,40.11 97.2,38.7 98.71,37.19 98.71,33.89 99.44,33.16 99.44,32.91 99.45,32.9 99.45,29.43 99.98,28.9 99.98,28.15 103.86,24.27 103.86,22.87 103.7,22.72 v2(103.37,22.72)
  BOTTOM w0.216: v2(103.37,22.72) 103.67,22.72 103.91,22.47 103.91,22.28 104.14,22.05 104.52,22.05 104.75,22.28 DM2.83 ; v2(107.02,78.55) 107.39,78.17 CPU1.AN50
M_B_A13: length 72.8
  TOP w0.216: v1(114.8,20.67) 115.11,20.98 v2(115.3,20.98)
  L4 w0.089: v2(111.82,65.18) 111.82,65.22 112.02,65.42 112.27,65.42 112.38,65.31 112.38,62.59 112.56,62.42
  L4 w0.203: 112.56,62.42 112.66,62.32 112.66,51.28 113.32,50.62 113.32,48.49 114.31,47.49 114.31,47.21 114.01,46.9 114.01,46.62 114.3,46.33 114.59,46.33 114.91,46.65 115.16,46.65 115.56,46.25 115.56,46.01 115.24,45.69 115.24,45.37 115.57,45.03 115.57,39.31 116.02,38.87 116.02,38.58 114.43,36.99 114.43,30.85 115.98,29.29 115.98,28.59 116.19,28.38 116.79,28.38 116.93,28.24 116.93,27.72 116.79,27.57 116.19,27.57 115.98,27.37 115.98,25.74 115.26,25.01 115.26,24.07 115.26,23.61 114.81,23.17 114.81,21.12 114.95,20.98 115.29,20.98 v2(115.3,20.98)
  BOTTOM w0.089: 111.04,67.64 111.04,67.64 111.04,67.82 111.11,67.9 111.11,70.53 111.22,70.64 111.22,70.92 111.24,70.93 111.24,71.17 111.07,71.34 111.07,71.7 111.4,72.04 111.4,72.56 111.37,72.69 111.37,72.86 111.41,73.03 111.51,73.28 CPU1.BA43
  BOTTOM w0.216: v2(115.3,20.98) 115.02,20.98 114.81,20.78 114.81,19.93 115.03,19.71 116.67,19.71 117.01,19.37 117.32,19.37 117.75,19.8 117.75,20.12 117.17,20.7 116.26,20.7 116.04,20.93 116.04,23.25 115.9,23.38 115.75,23.38 115.55,23.59 DM2.119 ; v2(111.82,65.18) 111.68,65.18 111.04,65.83 111.04,67.64
M_B_A14: length 76.9
  TOP w0.216: v1(103.84,18.77) 103.96,18.89 v2(104.43,18.89)
  L4 w0.089: v2(106.12,78.51) 106.46,78.17 106.46,77.63 106.42,77.59 106.42,77 106.25,76.83 106.25,76.63 106.2,76.58 106.2,74.99 105.41,74.2 105.41,73.37 104.96,72.92
  L4 w0.203: 104.96,72.92 100.35,68.31 100.35,62.82 99.31,61.78 99.31,61.78 93.01,55.48 93.01,41.74 94.48,40.27 94.48,39.01 95.99,37.5 95.99,34.24 97.03,33.2 97.03,31.04 97.78,30.3 97.78,27.98 101.7,24.05 101.7,21.4 102.33,20.77 102.33,20.37 102.93,19.77 102.93,17.77 103.16,17.54 103.49,17.54 103.72,17.77 103.72,18.54 103.95,18.77 104.3,18.77 v2(104.43,18.89)
  BOTTOM w0.216: DM2.80 103.85,18.58 104.17,18.89 v2(104.43,18.89) ; v2(106.12,78.51) 106.2,78.51 CPU1.AN52
M_B_A15: length 74.4
  TOP w0.216: v1(101.5,19.77) 101.62,19.65 v2(102.08,19.65)
  L4 w0.089: 104.69,73.25 105.21,73.78 105.21,74.39 106.01,75.19 106.01,76.11 105.39,76.73 105.39,76.96 105.53,77.1 105.53,78.07 105.61,78.15 105.87,78.15 106.07,77.95 v2(106.07,77.88)
  L4 w0.203: v2(102.08,19.65) 101.94,19.51 101.35,19.51 101.14,19.71 101.14,23.82 97.22,27.75 97.22,30.05 96.07,31.2 96.07,33.13 95.43,33.77 95.43,37.12 93.9,38.65 93.9,40.06 92.44,41.52 92.44,55.7 99.62,62.88 99.65,62.88 99.91,63.14 99.91,68.47 104.69,73.25
  BOTTOM w0.216: DM2.78 103.25,18.62 102.21,19.65 v2(102.08,19.65) ; v2(106.07,77.88) 105.78,78.17 CPU1.AN53
M_B_BS0: length 75.1
  TOP w0.216: v2(112.45,22.19) 112.58,22.19 v1(112.91,22.52)
  L4 w0.203: v2(112.45,22.19) 112.63,22.01 112.93,22.01 113.14,22.22 113.14,23.86 113.58,24.3 113.58,25.71 113.67,25.8 113.67,27.01 113.87,27.21 113.88,27.21 114.22,27.55 114.22,28.48 111.56,31.15 111.56,33.44 111.56,33.44 111.56,33.85 112.15,34.44 112.15,34.46 112.16,34.47 112.16,34.78 111.95,34.98 111.34,34.98 111.14,35.19 111.14,35.59 111.34,35.8 111.95,35.8 112.15,35.99 112.15,36.62 112.15,36.63 112.15,37.61 112.15,37.61 112.15,46.56 111.92,46.79 111.56,46.79 111.34,46.56 111.34,40.05 111.13,39.85 110.73,39.85 110.52,40.05 110.52,48.6 110.83,48.91 110.83,56.87 110.63,57.07 110.38,57.07 110.18,57.27 110.18,57.68 110.38,57.88 110.63,57.88 110.83,58.08 110.83,64.09 110.95,64.21 110.95,67.09 110.41,67.63 v2(110.24,67.63)
  BOTTOM w0.089: CPU1.BB44 110.97,72.14 110.67,71.84 110.67,71.84 110.66,71.83 110.66,69.11 110.68,69.09 110.68,68.43 110.7,68.42
  BOTTOM w0.216: v2(112.45,22.19) 112.57,22.19 113,22.63 113,23.74 112.55,24.19 DM2.109 ; 110.7,68.42 110.7,68.11 110.24,67.65 v2(110.24,67.63)
M_B_BS1: length 74.7
  TOP w0.216: v2(112.88,19.59) 112.43,19.59 v1(112.3,19.47)
  L4 w0.203: v2(110.26,68.94) 111.33,67.87 111.33,63.49 111.54,63.29 111.54,50.42 111.74,50.22 111.99,50.22 112.19,50.01 112.19,49.61 111.99,49.4 111.74,49.4 111.54,49.2 111.54,48.56 112.71,47.39 112.71,39.32 112.91,39.12 113.32,39.12 113.52,39.32 113.52,44.66 113.72,44.87 114.13,44.87 114.33,44.66 114.33,38.54 112.71,36.92 112.71,36.39 112.71,36.39 112.71,35.76 112.58,35.64 112.58,35.14 112.72,35.01 112.72,30.78 114.78,28.71 114.78,27.26 114.23,26.7 114.23,25.56 114.14,25.48 114.14,24.07 113.7,23.63 113.7,20.06 113.24,19.59 v2(112.88,19.59)
  BOTTOM w0.089: CPU1.BA44 110.62,72.76 110.62,72.07 110.47,71.92 110.47,71.91 110.47,71.91 110.47,70.32 110.38,70.23
  BOTTOM w0.216: DM2.108 112.25,19.01 112.83,19.59 v2(112.88,19.59) ; v2(110.26,68.94) 110.26,70.11 110.38,70.23
M_B_BS2: length 75.6
  TOP w0.216: v2(103.37,21.45) 103.75,21.45 v1(103.93,21.63)
  L4 w0.089: 106.43,73.28 106.96,73.8 106.96,74.54 106.56,74.94 106.56,76.43 106.61,76.48 106.61,76.68 106.99,77.06 v2(106.99,77.22)
  L4 w0.203: v2(103.37,21.45) 103.28,21.49 103.19,21.49 102.82,21.86 102.82,23.48 102.89,23.55 102.89,23.55 103.15,23.81 103.15,24.19 98.89,28.45 98.89,30.8 98.18,31.51 98.18,33.63 98.15,33.66 98.15,36.96 96.12,39 96.12,40.21 95.77,40.56 95.77,43.06 95.54,43.29 95.19,43.29 94.96,43.06 94.96,42.24 94.76,42.04 94.35,42.04 94.15,42.24 94.15,55.03 101.15,62.04 101.15,67.99 106.43,73.28
  BOTTOM w0.216: DM2.79 103.55,24.25 102.54,23.24 102.54,22.52 102.31,22.3 102.03,22.3 101.81,22.07 101.81,21.67 102.03,21.45 v2(103.37,21.45) ; v2(106.99,77.22) 106.68,77.52 CPU1.AP52
M_B_CAS#: length 76.1
  TOP w0.216: v1(114.82,22.62) 115.14,22.31 v2(115.3,22.31)
  L4 w0.203: v2(111.82,66.48) 111.96,66.63 112.42,66.63 112.62,66.43 112.62,62.8 113.21,62.21 113.21,51.51 113.88,50.85 113.88,48.72 116.35,46.25 116.35,45.57 116.35,45.57 116.35,45.1 116.35,45.1 116.35,44.76 116.13,44.54 116.13,39.55 116.33,39.34 116.74,39.34 116.94,39.55 116.94,43.71 117.15,43.92 117.54,43.92 117.76,43.69 117.76,42.62 117.96,42.42 118.37,42.42 118.52,42.27 118.52,41.75 118.37,41.61 117.96,41.61 117.76,41.4 117.76,41 117.96,40.79 118.3,40.79 118.5,40.59 118.5,40.18 118.3,39.98 117.96,39.98 117.76,39.78 117.76,39.41 115.03,36.68 115.03,31.04 117.49,28.57 117.49,26.98 117.26,26.75 116.77,26.75 116.54,26.52 116.54,25.42 115.82,24.69 115.82,23.38 115.81,23.38 115.81,22.4 115.61,22.2 115.41,22.2 v2(115.3,22.31)
  BOTTOM w0.089: CPU1.AY43 111.73,74.12 111.84,74.24 111.97,74.24 112.11,74.1 112.11,73.99 111.89,73.77 111.89,73.35 111.85,73.21 111.85,72.99 111.89,72.86 111.89,72.68 111.85,72.6 111.85,71.68 111.86,71.67 111.86,71.31 111.4,70.85 111.4,70.43 111.37,70.4
  BOTTOM w0.216: v2(115.3,22.31) 115.13,22.13 115.09,22.13 114.91,21.95 114.55,21.95 114.32,22.18 114.32,23.94 114.35,23.97 DM2.115 ; 111.37,70.4 111.37,66.95 111.82,66.5 v2(111.82,66.48)
M_B_CKE0: length 73.5
  TOP w0.216: v2(99.97,22.02) v1(99.97,22.58)
  L4 w0.089: v2(104.27,78.49) 104.76,78.49 104.97,78.29 104.97,77.8 104.72,77.54 104.72,74.04 99.76,69.09 99.16,69.09 98.83,68.76 98.83,63.67 98.56,63.41
  L4 w0.203: v2(99.97,22.02) 99.97,23.15 99.83,23.28 99.35,23.28 99.21,23.42 99.21,24.17 96.07,27.32 96.07,29.61 94.18,31.5 94.18,32 93.98,32.2 93.7,32.2 93.51,32.39 93.51,32.82 93.7,33.02 93.98,33.02 94.18,33.22 94.18,36.72 92.09,38.81 92.09,40.19 91.89,40.4 91.52,40.4 91.32,40.6 91.32,55.16 91.32,56.16 98.56,63.41
  BOTTOM w0.216: CPU1.AN56 103.95,78.17 v2(104.27,78.49) ; v2(99.97,22.02) 100.09,21.9 100.76,21.9 101.75,22.89 DM2.73
M_B_CKE1: length 73.8
  TOP w0.216: v2(102.05,18.25) 101.8,18.25 v1(101.52,18.53)
  L4 w0.089: v2(105.14,77.26) 105.14,76.53 105.59,76.08 105.59,75.07 104.95,74.44 104.95,74 99.87,68.91 99.24,68.91 99.01,68.68 99.01,63.06 98.9,62.95
  L4 w0.203: v2(102.05,18.25) 102.05,17.92 101.85,17.72 100.73,17.72 100.53,17.92 100.53,23.65 96.66,27.52 96.66,29.82 95.47,31 95.47,32.77 94.74,33.5 94.74,36.95 92.65,39.04 92.65,40.52 91.88,41.29 91.88,55.39 91.88,55.93 98.9,62.95
  BOTTOM w0.216: v2(105.14,77.26) 104.87,77.52 CPU1.AP55 ; DM2.74 v2(102.05,18.25)
M_B_CLK0: length 77.9
  TOP w0.127: v1(110.96,21.78) 111.3,22.12 v2(111.44,22.12)
  L4 w0.089: 109.72,74.08 109.72,74.1 109.74,74.12 109.74,74.29 109.16,74.87 109.16,76.16 110.04,77.04 110.04,77.5 v2(109.74,77.8)
  L4 w0.114: v2(111.44,22.12) 111.42,22.12 110.72,22.82 110.72,23.88 111.27,24.44 111.27,28.51 109.08,30.7 108.3,30.7 107.89,31.11 107.89,37.14 108.56,37.81 108.56,38.39 108.45,38.5 108.24,38.5 107.93,38.81 107.93,39.17 108.2,39.43 108.45,39.43 108.56,39.54 108.56,39.9 108.2,40.26 107.51,40.26 107.26,40.51 107.26,40.94 107.51,41.19 108.2,41.19 108.31,41.31 108.31,41.55 108.2,41.66 106.93,41.66 106.67,41.92 106.67,42.33 106.93,42.59 108.2,42.59 108.31,42.7 108.31,42.94 108.2,43.06 107.51,43.06 107.26,43.31 107.26,43.74 107.51,43.98 108.2,43.98 108.31,44.1 108.31,44.34 108.2,44.45 107.51,44.45 107.26,44.7 107.26,45.13 107.51,45.38 108.2,45.38 108.31,45.5 108.31,45.74 108.2,45.85 107.51,45.85 107.26,46.1 107.26,46.53 107.51,46.78 108.2,46.78 108.31,46.89 108.31,47.13 108.2,47.25 107.51,47.25 107.26,47.5 107.26,47.93 107.51,48.18 108.2,48.18 108.31,48.29 108.31,48.53 108.2,48.65 107.51,48.65 107.26,48.89 107.26,57.66 108.97,59.37 108.97,70.25 109.72,71 109.72,74.08
  BOTTOM w0.127: v2(111.44,22.12) 111.19,22.37 110.52,22.37 110.14,22.75 110.14,23.84 110.15,23.85 DM2.101 ; v2(109.74,77.8) 110.02,77.52 CPU1.AP45
M_B_CLK1: length 77.5
  TOP w0.127: v2(110.7,19.68) 110.48,19.68 v1(110.21,19.41)
  L4 w0.089: v2(108.84,77.81) 108.89,77.86 109.05,77.86 109.18,77.73 109.18,77.56 109.36,77.38 109.36,77.01 108.71,76.35 108.71,74.7 108.85,74.56 108.85,74.05 108.82,74.03 108.82,74.01
  L4 w0.114: 108.82,74.01 108.82,73.09 108.27,72.53 108.27,59.66 106.01,57.4 106.01,57.03 106.38,56.67 106.38,56.26 106.25,56.14 104.88,56.14 104.71,55.96 104.71,55.39 104.88,55.21 106.31,55.21 106.44,55.08 106.44,54.87 106.31,54.74 105.69,54.74 105.43,54.48 105.43,54.11 105.73,53.81 106.22,53.81 106.33,53.7 106.33,44.27 105.97,43.91 105.97,40.23 106.54,39.66 107.09,39.66 107.22,39.54 107.22,39.32 107.09,39.19 106.4,39.19 106.18,38.97 106.18,38.5 106.4,38.27 107.48,38.27 107.61,38.14 107.61,37.92 107.48,37.8 106.88,37.8 106.63,37.55 106.63,37.22 107.16,36.69 107.16,30.86 108.06,29.95 108.84,29.95 110.57,28.22 110.57,24.73 110.02,24.17 110.02,22.46 110.33,22.15 110.33,21.77 109.69,21.14 109.69,20.38 109.95,20.12 110.29,20.12 110.7,19.7 v2(110.7,19.68)
  BOTTOM w0.127: v2(110.7,19.68) 110.7,19.73 110.97,20 111.25,20 111.45,19.8 111.45,19.05 110.81,18.41 110.81,18.05 110.45,17.69 DM2.102 ; v2(108.84,77.81) 109.16,77.81 109.28,77.7 CPU1.AP46
M_B_CLK#0: length 77.9
  TOP w0.127: v1(110.87,23.03) 111.14,22.76 v2(111.4,22.76)
  L4 w0.089: 109.95,74.08 109.95,74.1 109.92,74.12 109.92,74.36 109.34,74.95 109.34,76.09 110.22,76.97 110.22,78.15 109.91,78.46 v2(109.75,78.46)
  L4 w0.114: v2(111.4,22.76) 111.1,22.76 110.95,22.92 110.95,23.79 111.5,24.34 111.5,28.6 109.17,30.93 108.4,30.93 108.12,31.21 108.12,37.05 108.79,37.72 108.79,38.48 108.54,38.73 108.33,38.73 108.16,38.9 108.16,39.07 108.29,39.2 108.54,39.2 108.79,39.45 108.79,39.99 108.29,40.49 107.61,40.49 107.49,40.61 107.49,40.85 107.61,40.96 108.29,40.96 108.54,41.21 108.54,41.64 108.29,41.89 107.03,41.89 106.9,42.02 106.9,42.23 107.03,42.36 108.29,42.36 108.54,42.61 108.54,43.04 108.29,43.29 107.61,43.29 107.49,43.4 107.49,43.64 107.61,43.76 108.29,43.76 108.54,44 108.54,44.44 108.29,44.68 107.61,44.68 107.49,44.8 107.49,45.04 107.61,45.15 108.29,45.15 108.54,45.4 108.54,45.83 108.29,46.08 107.61,46.08 107.49,46.19 107.49,46.44 107.61,46.55 108.29,46.55 108.54,46.8 108.54,47.23 108.29,47.48 107.61,47.48 107.49,47.59 107.49,47.83 107.61,47.95 108.29,47.95 108.54,48.2 108.54,48.63 108.29,48.87 107.61,48.87 107.49,48.99 107.49,57.57 109.2,59.27 109.2,70.16 109.95,70.9 109.95,74.08
  BOTTOM w0.127: v2(109.75,78.46) 110.03,78.17 CPU1.AN45 ; v2(111.4,22.76) 111.25,22.61 110.62,22.61 110.38,22.85 110.38,23.77 110.75,24.14 DM2.103
M_B_CLK#1: length 77.5
  TOP w0.127: v1(110.21,20.65) 110.51,20.35 v2(110.68,20.35)
  L4 w0.089: 109.05,74.01 109.05,74.03 109.03,74.05 109.03,74.63 108.88,74.77 108.88,76.28 109.54,76.93 109.54,77.45 109.36,77.64 109.36,78.02 v2(108.86,78.52)
  L4 w0.114: 109.05,74.01 109.05,72.99 108.5,72.44 108.5,59.56 106.24,57.31 106.24,57.13 106.61,56.76 106.61,56.17 106.35,55.91 104.98,55.91 104.93,55.86 104.93,55.48 104.98,55.44 106.4,55.44 106.67,55.18 106.67,54.77 106.4,54.51 105.79,54.51 105.66,54.38 105.66,54.2 105.83,54.04 106.31,54.04 106.56,53.79 106.56,44.18 106.2,43.82 106.2,40.33 106.64,39.89 107.19,39.89 107.45,39.63 107.45,39.23 107.19,38.97 106.5,38.97 106.4,38.87 106.4,38.59 106.5,38.5 107.58,38.5 107.84,38.24 107.84,37.83 107.58,37.57 106.97,37.57 106.86,37.46 106.86,37.32 107.39,36.79 107.39,30.96 108.16,30.18 108.93,30.18 110.8,28.31 110.8,24.63 110.25,24.08 110.25,22.55 110.56,22.24 110.56,21.68 109.92,21.04 109.92,20.47 110.05,20.35 v2(110.68,20.35)
  BOTTOM w0.127: v2(108.86,78.52) 109.2,78.17 CPU1.AN46 ; DM2.104 111.05,18.31 111.69,18.95 111.69,19.9 111.35,20.24 110.78,20.24 v2(110.68,20.35)
M_B_CS#0: length 75.4
  TOP w0.216: v1(115.28,17.9) 115.14,18.04 v2(115.14,18.53)
  L4 w0.203: v2(111.82,67.78) 111.82,67.8 112.02,68.01 112.74,68.01 112.94,67.8 112.94,63.02 113.77,62.19 113.77,51.74 114.44,51.08 114.44,48.95 116.91,46.48 116.91,45.33 119.08,43.16 119.08,39.93 116.25,37.1 116.25,30.61 118.07,28.79 118.07,26.05 116.4,24.37 116.4,20.69 115.38,19.67 114.9,19.67 114.44,19.21 114.44,16.23 114.64,16.02 117.55,16.02 117.75,16.23 117.75,16.58 117.55,16.78 115.62,16.78 115.14,17.26 v2(115.14,18.53)
  BOTTOM w0.089: CPU1.BB42 112.29,71.63 112.22,71.56 112.22,70.84 112.04,70.66 112.04,69.58 112.27,69.35 112.27,69.14
  BOTTOM w0.216: v2(111.82,67.78) 111.82,67.8 112.27,68.25 112.27,69.14 ; DM2.114 114.05,17.95 114.63,18.53 v2(115.14,18.53)
M_B_CS#1: length 76.9
  TOP w0.216: v2(117.09,22.56) 117.09,23.12 v1(117.09,23.12)
  L4 w0.203: v2(111.82,69.09) 111.83,69.1 111.83,70.78 112.11,71.06 112.63,71.06 113.24,70.46 113.24,63.19 114.33,62.09 114.33,52.15 117.99,48.48 117.99,48.06 117.78,47.84 117.49,47.84 116.06,49.27 115.77,49.27 115.48,48.98 115.48,48.7 117.47,46.71 117.47,45.57 118.4,44.63 118.69,44.63 118.94,44.88 119.17,44.88 119.52,44.53 119.52,44.3 119.27,44.05 119.27,43.77 119.64,43.39 119.64,39.7 116.81,36.87 116.81,30.84 118.63,29.02 118.63,25.97 118.63,25.97 118.63,25.81 116.95,24.14 116.95,22.7 v2(117.09,22.56)
  BOTTOM w0.089: 111.93,71 112.04,71.11 112.04,71.85 112.03,71.86 112.03,72.56 112.07,72.64 112.07,72.89 112.03,73.01 112.03,73.19 112.08,73.36 CPU1.AY42
  BOTTOM w0.216: 111.93,71 111.8,70.87 111.8,69.12 v2(111.82,69.09) ; v2(117.09,22.56) 116.88,22.56 116.61,22.29 116.61,21.6 116.83,21.38 117.32,21.38 117.73,20.97 118.05,20.97 118.35,21.26 118.35,21.58 117.67,22.26 117.67,23.18 117.3,23.55 116.54,23.55 116.15,23.94 DM2.121
M_B_DIMB_ODT0: length 76.6
  TOP w0.14: v1(116.28,19.74) 116.28,19.26 v2(116.39,19.15)
  L4 w0.127: v2(116.39,19.15) 116.5,19.26 117.78,19.26 118.29,18.75 118.29,14.94 118.49,14.74 119.62,14.74 119.82,14.94 119.82,17.2 119.62,17.4 119.19,17.4 118.99,17.6 118.99,19.43 118.99,19.83 118.99,20.16 118.01,21.14 118.01,23.85 119.55,25.39 119.55,27.11 119.55,29.5 118.3,30.75 118.3,37.06 120.6,39.37 120.6,44.74 118.91,46.43 118.91,49.03 115.47,52.47 115.47,62.01 v2(114.05,63.43)
  BOTTOM w0.102: 112.54,69.24 112.54,69.39 112.22,69.71 112.22,70.59 112.4,70.77 112.4,71.48 112.56,71.64 112.56,72.61 112.29,72.88 CPU1.BA42
  BOTTOM w0.14: v2(116.39,19.15) 116.39,19.1 115.24,17.95 114.85,17.95 114.65,17.75 DM2.116 ; 112.54,69.24 112.54,65.43 114.05,63.92 v2(114.05,63.43)
M_B_DIMB_ODT1: length 76.3
  TOP w0.14: v2(116.48,18.53) 116.48,18.08 v1(116.63,17.93)
  L4 w0.127: v2(116.48,18.53) 116.34,18.53 116.18,18.36 116.18,18.13 116.34,17.97 117.16,17.97 117.16,17.97 117.8,17.97 117.89,17.88 117.89,17.39 117.8,17.3 115.89,17.3 115.66,17.53 115.66,19.22 116.1,19.66 116.73,19.66 116.86,19.78 116.86,20.03 117.01,20.18 117.22,20.18 117.36,20.03 117.36,19.78 117.49,19.66 117.95,19.66 118.16,19.44 118.44,19.44 118.59,19.59 118.59,19.99 117.61,20.98 117.61,21.49 117.61,24.01 119.15,25.55 119.15,27.28 119.15,27.28 119.15,29.34 117.9,30.59 117.9,37.23 120.21,39.54 120.21,44.57 119.05,45.73 118.87,45.73 118.56,45.42 118.35,45.42 118.2,45.57 118.2,45.78 118.51,46.09 118.51,46.75 118.39,46.88 118.05,46.88 117.92,47.01 117.92,47.26 118.05,47.39 118.39,47.39 118.51,47.51 118.51,48.87 114.85,52.53 114.85,62.02 113.54,63.34 113.54,70.68 112.69,71.53 112.69,73.94 v2(112.76,74.01)
  BOTTOM w0.14: v2(112.76,74.01) 112.36,74.41 CPU1.AW42 ; DM2.120 115.85,17.71 116.48,18.34 v2(116.48,18.53)
M_B_DQ0: length 86.6
  TOP w0.14: v1(84.08,21.28) 83.84,21.53 v2(83.57,21.53)
  L4 w0.127: v2(83.57,21.53) 83.38,21.72 83.37,21.72 83.1,21.98 83.1,22.51 82.82,22.79 82.82,23.34 75.84,30.32 75.84,34.46 75.82,34.47 75.82,35.17 75.83,35.17 75.83,36.01 75.81,36.02 75.81,37.62 74.95,38.48 74.95,52.23 75.38,52.67 75.38,60.67 79.36,64.64 79.36,64.86 79.2,65.02 78.98,65.02 78.51,64.55 78.29,64.55 78.13,64.7 78.13,64.93 81.52,68.32 81.52,71.76 86.43,76.67 86.43,76.67 87.88,78.11 92.34,78.11 92.76,78.53 92.76,78.9 96.61,82.75 98.64,82.75 v2(99.31,82.08)
  BOTTOM w0.14: DM2.23 84.35,24.19 84.04,23.87 84.04,21.99 v2(83.57,21.53) ; v2(99.31,82.08) 98.99,81.75 CPU1.AF65
M_B_DQ1: length 85.1
  TOP w0.14: v2(85.23,20.23) 85,20.23 v1(84.7,19.93)
  L4 w0.127: v2(99.96,82.08) 99.54,81.65 97.24,81.65 95.29,79.71 95.29,79.35 93.36,77.43 88.86,77.43 82.99,71.56 82.99,66.48 78.84,62.33 76.61,60.11 76.61,52.22 76.13,51.74 76.13,38.97 77.73,37.37 77.73,30.1 84.41,23.42 84.41,20.46 84.72,20.15 85.15,20.15 v2(85.23,20.23)
  BOTTOM w0.14: v2(85.23,20.23) 84.05,19.05 DM2.22 ; v2(99.96,82.08) 99.64,81.75 CPU1.AF64
M_B_DQ2: length 85.8
  TOP w0.14: v1(88.21,21.51) 87.77,21.94 v2(87.68,21.94)
  L4 w0.127: v2(87.68,21.94) 87.51,21.77 87.12,21.77 86.91,21.97 86.91,23.38 86.59,23.71 86.59,24.22 80.43,30.38 80.43,37.08 79.79,37.73 79.79,38.23 78.28,39.73 78.28,47.57 79.4,48.7 79.4,51.56 78.76,52.2 78.76,58.07 80.67,59.98 80.94,59.98 82.59,61.63 82.59,61.84 82.44,61.99 82.23,61.99 81.23,60.99 81.02,60.99 80.87,61.14 80.87,61.35 86.08,66.56 86.08,66.88 87.19,67.99 88.35,67.99 88.5,67.84 88.5,67.63 88.35,67.48 87.47,67.48 87.34,67.36 87.34,67.1 87.47,66.97 88.65,66.97 90.75,69.07 90.75,70.82 93.67,73.74 93.67,74.07 95.75,76.15 95.75,77.41 97.7,79.37 98.43,79.37 v2(99.31,80.25)
  BOTTOM w0.14: DM2.33 87.35,23.63 87.19,23.47 87.19,22.38 87.63,21.94 v2(87.68,21.94) ; CPU1.AK65 98.99,79.93 v2(99.31,80.25)
M_B_DQ3: length 85.9
  TOP w0.14: v2(87.68,23.21) 87.84,23.21 v1(88.15,22.9)
  L4 w0.127: v2(87.68,23.21) 86.98,23.91 86.98,24.39 81.32,30.05 81.32,31.25 81.33,31.25 81.33,31.62 81.32,31.62 81.32,31.91 81.33,31.91 81.33,32.28 81.32,32.28 81.32,32.57 81.33,32.57 81.33,32.94 81.32,32.94 81.32,33.23 81.33,33.23 81.33,33.6 81.32,33.6 81.32,36.55 81.32,36.89 80.86,37.36 80.72,37.36 80.18,37.89 80.18,38.39 78.85,39.73 78.85,47.58 79.8,48.53 79.8,51.72 79.16,52.36 79.16,57.49 87.06,65.4 87.06,65.61 86.91,65.76 86.7,65.76 83.07,62.13 82.86,62.13 82.71,62.28 82.71,62.49 86.68,66.45 88.55,66.45 91.16,69.07 91.16,70.88 93.89,73.6 93.89,73.85 96.15,76.12 96.15,77.45 97.71,79.01 98.73,79.01 v2(99.96,80.25)
  BOTTOM w0.14: DM2.35 87.95,23.48 v2(87.68,23.21) ; CPU1.AK64 99.64,79.93 v2(99.96,80.25)
M_B_DQ4: length 85.9
  TOP w0.14: v2(83.57,22.8) 83.77,22.8 v1(84.06,22.5)
  L4 w0.127: v2(98.66,82.08) 98.25,82.49 96.81,82.49 93.06,78.75 93.06,78.37 92.58,77.88 88.2,77.88 82.2,71.88 82.2,71.23 82.2,68.35 79.45,65.6 79.45,65.38 79.61,65.23 79.83,65.23 81.6,67 81.82,67 81.98,66.84 81.98,66.62 75.82,60.46 75.82,52.55 75.34,52.07 75.34,38.65 76.21,37.78 76.21,36.18 76.22,36.17 76.22,35.01 76.22,35.01 76.22,34.64 76.24,34.62 76.24,30.49 83.22,23.5 83.22,23.15 v2(83.57,22.8)
  BOTTOM w0.14: v2(98.66,82.08) 98.34,81.75 CPU1.AF66 ; DM2.21 83.75,24.21 83.63,24.09 83.63,22.85 v2(83.57,22.8)
M_B_DQ5: length 85.2
  TOP w0.14: v2(85.24,18.96) 85.04,18.96 v1(84.76,18.67)
  L4 w0.127: v2(98.01,82.08) 97.2,82.08 94.79,79.67 94.79,79.31 93.14,77.65 88.53,77.65 82.59,71.72 82.59,71.39 82.59,71.39 82.59,66.65 78.44,62.49 76.22,60.27 76.22,52.38 75.74,51.9 75.74,38.81 77.33,37.22 77.33,34.1 76.84,33.62 76.84,30.44 84.02,23.26 84.02,18.4 84.22,18.19 84.62,18.19 84.82,18.4 84.82,18.51 85.24,18.92 v2(85.24,18.96)
  BOTTOM w0.14: v2(98.01,82.08) 97.69,81.75 CPU1.AF67 ; DM2.24 84.65,18.37 v2(85.24,18.96)
M_B_DQ6: length 83.9
  TOP w0.14: v2(87.65,18.23) 87.65,17.66 v1(87.65,17.66)
  L4 w0.127: v2(87.65,18.23) 87.82,18.23 88.03,18.03 88.03,17.66 87.82,17.46 86.99,17.46 86.79,17.66 86.79,19.18 86.13,19.84 86.13,23.05 85.8,23.38 85.8,23.44 85.8,23.9 79,30.7 79,37.9 77.49,39.41 77.49,47.9 78.62,49.02 78.62,51.23 77.97,51.87 77.97,58.41 80.09,60.52 80.09,61.71 85.23,66.85 85.23,68.39 84.81,68.81 84.81,71.49 88.26,74.94 93.59,74.94 94.03,75.37 94.03,75.37 95.12,76.47 95.12,77.57 97.81,80.25 v2(98.01,80.25)
  BOTTOM w0.14: v2(87.65,18.23) DM2.34 ; v2(98.01,80.25) 97.69,79.93 CPU1.AK67
M_B_DQ7: length 85
  TOP w0.14: v2(87.65,19.6) 87.84,19.6 v1(88.13,19.89)
  L4 w0.127: v2(87.65,19.6) 86.93,19.6 86.52,20.01 86.52,20.66 86.65,20.79 87.1,20.79 87.23,20.92 87.23,21.17 87.1,21.3 86.65,21.3 86.52,21.43 86.52,23.22 86.19,23.54 86.19,23.61 86.19,24.06 80.04,30.21 80.04,36.92 79.4,37.56 79.4,38.06 77.89,39.57 77.89,47.74 79.01,48.86 79.01,51.39 78.37,52.03 78.37,58.24 80.48,60.36 80.48,61.55 85.62,66.69 85.62,67.79 85.75,67.92 86.38,67.92 86.53,68.07 86.53,68.28 86.38,68.43 85.75,68.43 85.21,68.97 85.21,71.3 88.62,74.71 93.8,74.71 95.49,76.4 95.49,77.54 97.66,79.71 98.12,79.71 v2(98.66,80.25)
  BOTTOM w0.14: DM2.36 88.25,19.37 88.03,19.6 v2(87.65,19.6) ; v2(98.66,80.25) 98.34,79.93 CPU1.AK66
M_B_DQ8: length 89.5
  TOP w0.14: v1(82.94,18.66) 83.24,18.96 v2(83.42,18.96)
  L4 w0.127: v2(83.42,18.96) 83.42,18.93 83,18.51 83,17.75 82.8,17.55 82.51,17.55 82.31,17.75 82.31,18.96 82.66,19.31 82.66,20.45 82.31,20.8 82.31,21.96 82.04,22.23 82.04,23.01 74.53,30.53 74.53,37.45 73.92,38.06 73.92,62.17 76.33,64.58 80.49,68.74 80.49,72.35 85.38,77.23 85.38,78.28 86.31,79.21 90.86,79.21 92.05,80.4 92.05,82.07 v2(91.39,82.73)
  BOTTOM w0.089: CPU1.AF70 95.54,81.93 94.81,82.66 94.22,82.66 93.91,82.96
  BOTTOM w0.14: v2(91.39,82.73) 91.77,83.11 93.77,83.11 93.91,82.96 ; v2(83.42,18.96) 83.42,18.96 83.32,18.96 82.85,18.49 DM2.18
M_B_DQ9: length 91.4
  TOP w0.14: v2(78.66,18.23) 78.57,18.23 v1(78.21,18.59)
  L4 w0.127: v2(90.06,82.69) 89.86,82.49 83.75,82.49 81.6,80.34 81.6,78.24 76.88,73.51 76.88,72.88 72.24,68.24 72.24,66.82 70.57,65.16 70.57,39.97 68.36,37.77 68.36,30.98 77.27,22.07 77.27,21.79 77.7,21.37 77.7,19.19 v2(78.66,18.23)
  BOTTOM w0.089: CPU1.AF68 96.53,82.17 96.53,82.17 96.25,82.17 96.01,82.4 95.67,82.4 94.97,83.1 94.68,83.1 94.5,83.29
  BOTTOM w0.14: DM2.4 78.65,18.22 v2(78.66,18.23) ; v2(90.06,82.69) 90.95,83.58 94.2,83.58 94.5,83.29
M_B_DQ10: length 89
  TOP w0.14: v2(78.72,21.05) 78.32,21.05 v1(78.17,21.19)
  L4 w0.127: v2(78.72,21.05) 78.67,21.09 78.67,22.31 78.22,22.77 77.69,22.77 73.88,26.57 73.88,27.41 70.15,31.15 70.15,37.83 71.44,39.12 71.44,64.75 74.4,67.71 74.4,67.92 74.23,68.08 74.02,68.08 73.53,67.6 73.31,67.6 73.16,67.76 73.16,67.98 77.4,72.21 77.68,72.5 77.68,73.19 82.43,77.95 82.43,79.32 84.72,81.61 86.34,81.61 v2(87.23,80.72)
  BOTTOM w0.14: CPU1.AH71 94.22,80.6 93.87,80.95 93.42,80.95 92.48,80.02 88.54,80.02 88.43,80.14 87.82,80.14 v2(87.23,80.72) ; v2(78.72,21.05) 78.72,21.26 78.63,21.35 78.63,22.33 78.59,22.36 78.59,23.66 78.63,23.7 78.63,23.76 78.95,24.08 DM2.5
M_B_DQ11: length 91.7
  TOP w0.14: v1(79.75,21.77) 79.45,22.07 v2(79.12,22.07)
  L4 w0.127: v2(86.6,80.72) 86.11,81.21 85.3,81.21 82.93,78.83 82.93,77.89 78.07,73.03 78.07,72.33 77.48,71.75 77.48,71.57 77.74,71.31 77.74,71.13 77.54,70.93 77.36,70.93 77.11,71.19 76.93,71.19 74.55,68.81 74.55,68.59 74.7,68.43 74.92,68.43 76.36,69.87 76.58,69.87 76.74,69.71 76.74,69.49 71.86,64.62 71.86,38.99 70.54,37.67 70.54,34.19 71.21,33.52 71.21,30.92 74.86,27.27 74.86,26.26 77.86,23.25 78.42,23.25 79.07,22.6 79.07,22.11 v2(79.12,22.07)
  BOTTOM w0.14: v2(79.12,22.07) 79.03,22.15 79.03,22.5 79,22.53 79,23.49 79.55,24.05 DM2.7 ; v2(86.6,80.72) 86.78,80.54 86.78,80.54 87.59,79.73 92.56,79.73 92.96,80.13 94.29,80.13 94.43,80.27 96.7,80.27 CPU1.AH68
M_B_DQ12: length 88.4
  TOP w0.14: v1(82.95,19.94) 83.25,20.24 v2(83.43,20.24)
  L4 w0.127: v2(92.68,82.65) 92.68,80.57 91.05,78.94 86.55,78.94 85.77,78.16 85.77,77.07 80.89,72.19 80.89,68.58 76.72,64.42 75.59,63.29 75.59,63.07 75.75,62.91 75.97,62.91 77.33,64.27 77.56,64.27 77.71,64.12 77.71,63.9 74.32,60.5 74.32,38.22 74.92,37.61 74.92,34.22 75.44,33.7 75.44,30.16 82.43,23.18 82.43,22.4 82.71,22.12 82.71,20.96 v2(83.43,20.24)
  BOTTOM w0.14: CPU1.AF71 94.56,82.45 93.99,82.45 93.8,82.65 v2(92.68,82.65) ; DM2.16 82.25,19.07 v2(83.43,20.24)
M_B_DQ13: length 90.2
  TOP w0.14: v2(81.59,22.57) 81.76,22.57 v1(82.07,22.25)
  L4 w0.127: v2(81.59,22.57) 81.06,23.09 81.06,23.43 79.58,24.92 78.64,24.92 76.64,26.91 76.64,27.85 74.13,30.36 74.13,37.29 73.53,37.89 73.53,62.34 79.79,68.6 79.79,68.82 79.64,68.98 79.41,68.98 77.67,67.24 77.45,67.24 77.3,67.39 77.3,67.61 80.1,70.42 80.1,72.51 84.82,77.23 84.82,78.28 86.02,79.48 90.66,79.48 91.75,80.57 91.75,81.67 v2(90.73,82.69)
  BOTTOM w0.089: 94.3,83.03 94.47,82.86 94.91,82.86 95.56,82.21 95.92,82.21 96.3,81.83 CPU1.AF69
  BOTTOM w0.14: 94.3,83.03 93.97,83.35 91.4,83.35 v2(90.73,82.69) ; v2(81.59,22.57) 81.95,22.92 DM2.15
M_B_DQ14: length 89.6
  TOP w0.14: v1(78.18,19.9) 78.48,19.59 v2(78.66,19.59)
  L4 w0.127: v2(78.66,19.59) 78.29,19.59 78.16,19.73 78.16,21.46 77.66,21.96 77.66,22.24 71.31,28.59 71.31,28.77 71.52,28.98 71.52,29.2 71.36,29.36 71.14,29.36 70.93,29.15 70.75,29.15 69.47,30.44 69.47,38.17 71.04,39.75 71.04,64.91 72.76,66.63 72.76,68.14 77.27,72.65 77.27,73.35 82.04,78.11 82.04,79.16 82.04,79.48 84.56,82.01 87.48,82.01 v2(88.75,80.74)
  BOTTOM w0.089: CPU1.AH70 95.53,80.81 95.36,80.81 95.14,80.87 94.34,80.87 94.04,81.17 93.22,81.17 93.03,80.99
  BOTTOM w0.14: v2(88.75,80.74) 89.17,80.32 92.36,80.32 93.03,80.99 ; v2(78.66,19.59) 79.25,19 DM2.6
M_B_DQ15: length 90.8
  TOP w0.14: v1(80.74,20.95) 81.04,21.24 v2(81.29,21.24)
  L4 w0.127: v2(81.29,21.24) 80.67,21.86 80.67,23.27 79.41,24.52 78.47,24.52 76.13,26.87 76.13,27.8 73.13,30.79 73.13,33.8 73.69,34.36 73.69,37.18 73.13,37.73 73.13,62.5 74.92,64.29 74.92,64.29 77.25,66.63 77.25,66.81 77.06,67 76.88,67 75.13,65.25 74.9,65.25 74.75,65.41 74.75,65.63 79.55,70.43 79.55,72.61 84.42,77.49 84.42,78.49 85.68,79.74 90.35,79.74 v2(91.35,80.74)
  BOTTOM w0.089: CPU1.AH69 95.99,81 95.35,81 95.16,81.05 95.16,81.05 95.15,81.06 94.5,81.06 94.16,81.39 93.01,81.39 92.93,81.32
  BOTTOM w0.14: DM2.17 82.55,22.11 81.68,21.24 v2(81.29,21.24) ; v2(91.35,80.74) 92.36,80.74 92.93,81.32
M_B_DQ16: length 76
  TOP w0.14: v2(89.15,23.47) 89.33,23.47 v1(89.64,23.16)
  L4 w0.127: v2(89.15,23.47) 89.15,23.63 88.16,24.61 88.16,24.88 82.75,30.29 82.75,36.16 82.75,36.16 82.75,37.14 81.38,38.51 81.38,38.86 80.27,39.97 80.27,47 80.43,47.15 80.65,47.15 80.81,47 80.81,43.46 80.96,43.31 81.18,43.31 81.34,43.46 81.34,52.19 80.6,52.92 80.6,56.93 92.13,68.46 92.13,70.89 93.27,72.03 94.27,72.03 95.17,72.94 95.17,73.93 v2(97.82,76.58)
  BOTTOM w0.14: DM2.39 v2(89.15,23.47) ; v2(97.82,76.58) 98.18,76.22 CPU1.AT66
M_B_DQ17: length 75.5
  TOP w0.14: v1(89.62,21.89) 89.32,22.2 v2(89.15,22.2)
  L4 w0.127: v2(89.15,22.2) 89.3,22.04 89.56,22.04 89.71,22.19 89.71,23.78 88.56,24.93 88.56,25.3 83.14,30.71 83.14,36 83.14,36 83.14,37.36 82.11,38.39 81.77,38.73 81.77,39.06 80.71,40.12 80.71,42.64 80.86,42.8 81.08,42.8 81.24,42.64 81.24,40.76 81.4,40.59 81.64,40.59 81.8,40.76 81.8,52.64 81.06,53.39 81.06,56.83 92.35,68.12 92.35,70.8 93.36,71.81 94.39,71.81 95.57,72.99 95.57,73.78 97.68,75.89 v2(97.85,75.89)
  BOTTOM w0.14: v2(97.85,75.89) 98.17,75.57 CPU1.AU66 ; DM2.41 89.75,24.02 89.6,23.87 89.6,22.6 89.2,22.2 v2(89.15,22.2)
M_B_DQ18: length 79.2
  TOP w0.14: v2(93.94,20.94) 94.18,20.94 v1(94.45,21.21)
  L4 w0.089: v2(99.68,77.2) 100.11,76.77 100.11,76.03
  L4 w0.127: 100.11,76.03 100.11,75.12 98.43,73.44 98.43,73.01 97.32,71.9 97.32,71.4 96.69,70.78 95.93,70.78 94.37,69.22 94.37,65 93.31,63.94 91.23,63.94 84.12,56.83 84.12,51.8 84.89,51.02 84.89,48.03 84.77,47.9 84.51,47.9 84.39,48.03 84.39,49.23 84.24,49.38 84.03,49.38 83.88,49.23 83.88,39.53 85.89,37.52 85.89,30.87 86.89,29.87 87.85,29.87 88.99,28.73 88.99,28.04 90.63,26.4 90.63,25.76 92.97,23.43 92.97,21.91 v2(93.94,20.94)
  BOTTOM w0.14: CPU1.AP65 99.35,77.52 v2(99.68,77.2) ; v2(93.94,20.94) 93.81,20.94 92.75,22.01 DM2.51
M_B_DQ19: length 80.1
  TOP w0.14: v1(94.35,22.67) 94.35,22.63 v2(93.93,22.21)
  L4 w0.089: v2(99.68,77.85) 100.07,77.46 100.07,77.06 100.38,76.74 100.38,76.05
  L4 w0.127: 100.38,76.05 100.38,75.09 98.96,73.67 98.96,73.21 97.78,72.03 97.78,71.56 96.76,70.53 96.09,70.53 94.68,69.13 94.68,65 93.33,63.65 91.5,63.65 84.51,56.66 84.51,52.02 85.29,51.25 85.29,44.38 85.14,44.23 84.93,44.23 84.78,44.38 84.78,47.18 84.63,47.33 84.42,47.33 84.27,47.18 84.27,39.7 86.28,37.68 86.28,31.04 87.05,30.27 88.26,30.27 89.51,29.02 89.51,28.57 89.51,28.57 89.51,28.09 91.03,26.56 91.03,25.93 93.36,23.59 93.36,22.78 v2(93.93,22.21)
  BOTTOM w0.14: CPU1.AN65 99.35,78.17 v2(99.68,77.85) ; DM2.53 93.35,22.79 93.92,22.21 v2(93.93,22.21)
M_B_DQ20: length 78.9
  TOP w0.14: v2(90.25,20.24) 90.05,20.24 v1(89.77,19.96)
  L4 w0.127: v2(98.76,77.85) 98.33,77.41 97.61,77.41 97.12,76.92 97.12,76.71 94.4,73.99 94.4,73.77 93.09,72.46 93.09,72.46 91.51,70.88 91.51,68.95 79.79,57.23 79.79,52.62 80.43,51.98 80.43,48.27 79.48,47.32 79.48,39.65 80.58,38.55 80.58,38.2 81.96,36.81 81.96,36.49 81.96,29.97 87.38,24.55 87.38,24.29 88.31,23.35 88.31,21.21 88.97,20.56 88.97,19.22 89.17,19.01 89.61,19.01 89.81,19.22 89.81,19.79 90.25,20.24 v2(90.25,20.24)
  BOTTOM w0.14: CPU1.AN66 98.44,78.17 v2(98.76,77.85) ; v2(90.25,20.24) 90.17,20.24 89.34,19.41 89.34,17.83 89.45,17.72 DM2.40
M_B_DQ21: length 77.8
  TOP w0.14: v2(90.25,18.97) 90.07,18.97 v1(89.77,18.67)
  L4 w0.127: v2(98.76,77.2) 97.7,77.2 97.33,76.83 97.33,76.47 94.77,73.91 94.77,73.82 93.2,72.24 93.18,72.24 91.92,70.98 91.92,68.8 80.18,57.07 80.18,52.79 80.83,52.15 80.83,48.11 79.88,47.16 79.88,39.81 80.99,38.7 80.99,38.34 82.35,36.98 82.35,36.32 82.35,30.13 87.77,24.71 87.77,24.45 88.71,23.51 88.71,21.38 89.13,20.95 90.79,20.95 91.38,20.36 91.38,19.25 91.1,18.97 v2(90.25,18.97)
  BOTTOM w0.14: DM2.42 90.05,17.73 89.77,18.01 89.77,18.75 89.99,18.97 v2(90.25,18.97) ; CPU1.AP66 98.44,77.52 v2(98.76,77.2)
M_B_DQ22: length 77.5
  TOP w0.14: v1(91.95,18.03) 92.25,18.32 v2(92.45,18.32)
  L4 w0.127: v2(99.68,75.9) 99.68,75.24 97.96,73.52 97.96,73 96.94,71.99 96.94,71.42 96.67,71.15 95.85,71.15 94.12,69.41 94.12,65.05 93.29,64.22 90.92,64.22 83.73,57.02 83.73,51.63 84.41,50.95 84.41,50.33 83.48,49.4 83.48,39.37 85.5,37.36 85.5,30.71 86.73,29.48 87.69,29.48 88.6,28.57 88.6,28.2 88.59,28.19 88.59,27.89 90.24,26.24 90.24,25.6 92.46,23.38 92.46,21.73 93.69,20.5 93.69,19.86 93.99,19.56 93.99,17.62 93.79,17.42 92.61,17.42 92.45,17.58 v2(92.45,18.32)
  BOTTOM w0.14: v2(99.68,75.9) 99.35,76.22 CPU1.AT65 ; v2(92.45,18.32) DM2.50
M_B_DQ23: length 77
  TOP w0.14: v2(92.45,19.59) 92.21,19.59 v1(91.93,19.32)
  L4 w0.127: v2(92.45,19.59) 92.45,19.59 92.77,19.27 92.92,19.12 92.92,18.38 93.12,18.17 93.4,18.17 93.6,18.38 93.6,19.4 93.29,19.71 93.29,20.35 92.06,21.57 92.06,23.22 89.83,25.46 89.83,26.06 87.71,28.18 87.71,28.46 87.08,29.08 86.56,29.08 85.1,30.55 85.1,37.19 83.09,39.21 83.09,49.24 83.09,49.57 83.93,50.41 83.93,50.87 83.33,51.47 83.33,51.55 83.33,57.31 90.61,64.58 92.55,64.58 93.16,65.2 93.16,69.82 93.86,70.52 93.86,70.61 94.1,70.85 94.62,70.85 95.98,72.21 96.86,72.21 97.69,73.04 97.69,73.95 v2(98.87,75.13)
  BOTTOM w0.14: v2(92.45,19.59) 92.6,19.59 93.05,19.14 DM2.52 ; CPU1.AU65 99.22,75.48 v2(98.87,75.13)
M_B_DQ24: length 76.1
  TOP w0.14: v2(94.67,19.64) 94.48,19.64 v1(94.15,19.31)
  L4 w0.127: v2(94.67,19.64) 94.23,20.08 94.23,20.55 94.41,20.73 94.41,23.1 91.48,26.03 91.48,27.46 90.91,28.04 90.91,28.61 89.76,29.76 89.52,29.76 88.55,30.73 87.15,30.73 86.68,31.2 86.68,38.03 85.05,39.66 85.05,43.32 85.82,44.09 85.82,51.47 85.05,52.24 85.05,56.41 91.92,63.28 93.46,63.28 95.09,64.9 95.09,69.21 95.84,69.96 95.85,69.96 96.1,70.22 96.75,70.22 98.16,71.63 98.16,72.02 99.39,73.26 99.39,73.79 100.61,75.01 100.61,77.17 v2(100.59,77.2)
  BOTTOM w0.14: CPU1.AT61 100.59,76.68 v2(100.59,77.2) ; v2(94.67,19.64) 94.54,19.64 94.1,19.19 94.1,18.14 94.25,17.99 DM2.56
M_B_DQ25: length 75.7
  TOP w0.14: v1(96.67,22.61) 96.39,22.34 v2(96.15,22.34)
  L4 w0.127: v2(101.5,75.24) 101.5,74.01 100.53,73.04 100.19,73.04 99.07,71.92 99.07,71.59 96.41,68.93 96.41,65.27 93.36,62.23 92.99,62.23 87.04,56.28 86.63,56.28 86.48,56.13 86.48,55.92 86.63,55.77 87.03,55.77 87.18,55.62 87.18,55.41 87.03,55.26 86.53,55.26 86.4,55.13 86.4,54.88 86.53,54.75 86.99,54.75 87.13,54.61 87.13,54.39 86.99,54.24 86.53,54.24 86.4,54.12 86.4,53.86 86.53,53.74 87.04,53.74 87.19,53.59 87.19,53.38 87.04,53.23 86.53,53.23 86.4,53.1 86.4,52.85 86.53,52.72 87.03,52.72 87.18,52.57 87.18,51.54 87.38,51.34 87.52,51.34 87.67,51.2 87.67,50.99 87.52,50.84 87.15,50.84 87.03,50.71 87.03,50.46 87.15,50.33 87.69,50.33 87.84,50.18 87.84,49.97 87.69,49.82 87.15,49.82 87.03,49.69 87.03,41.36 87.56,40.82 87.56,39.03 89.21,37.38 89.21,37.11 89.08,36.99 88.97,36.99 88.85,36.86 88.85,36.58 88.97,36.45 89.08,36.45 89.21,36.33 89.21,36.05 89.08,35.92 88.97,35.92 88.85,35.79 88.85,35.51 88.97,35.39 89.49,35.39 89.65,35.23 89.65,31.3 90.01,30.94 90.38,30.94 92.67,28.65 92.67,26.52 95.7,23.48 95.7,22.79 v2(96.15,22.34)
  BOTTOM w0.14: CPU1.AU61 101.38,75.24 v2(101.5,75.24) ; v2(96.15,22.34) 95.57,22.34 95.15,22.76 DM2.59
M_B_DQ26: length 78.3
  TOP w0.14: v1(98.68,19.89) 98.95,20.16 v2(99.22,20.16)
  L4 w0.127: v2(102.42,77.85) 102.66,77.85 102.83,77.68 102.83,76.27 102.71,76.16 102.71,75.26 102.79,75.19 103.01,75.19 103.14,75.05 103.14,74.79 103.04,74.69 102.76,74.69 102.64,74.57 102.64,74.29 102.53,74.18 102.53,73.67 100.74,71.88 100.74,71.53 99.97,70.77 99.67,70.77 98.05,69.15 98.05,64.89 89.76,56.6 89.76,45.68 90.01,45.43 90.01,45.11 89.88,44.98 89.46,44.98 89.33,44.85 89.33,44.6 89.46,44.47 89.88,44.47 90.01,44.34 90.01,44.09 89.88,43.96 89.46,43.96 89.33,43.84 89.33,43.58 89.46,43.45 89.88,43.45 90.01,43.33 90.01,43.07 89.88,42.95 89.46,42.95 89.33,42.82 89.33,42.57 89.46,42.44 89.88,42.44 90.01,42.31 90.01,42.06 89.88,41.93 89.46,41.93 89.33,41.8 89.33,41.55 89.46,41.42 89.88,41.42 90.01,41.3 90.01,38.94 92.2,36.75 92.2,31.63 94.33,29.5 94.33,27.21 97.91,23.63 97.91,21.45 98.67,20.69 98.67,20.1 98.82,19.95 99.02,19.95 99.22,20.15 v2(99.22,20.16)
  BOTTOM w0.14: CPU1.AP60 102.1,77.52 v2(102.42,77.85) ; v2(99.22,20.16) 98.95,20.16 97.85,19.06 DM2.68
M_B_DQ27: length 78.8
  TOP w0.14: v1(98.75,22.39) 99.06,22.08 v2(99.22,22.08)
  L4 w0.127: v2(101.51,78.5) 101.17,78.5 101.04,78.63 101.04,79.01 101.17,79.14 101.66,79.14 101.93,79.4 103.54,79.4 103.74,79.2 103.74,74.8 103.87,74.67 104.09,74.67 104.22,74.55 104.22,74.29 104.09,74.17 103.87,74.17 103.74,74.04 103.74,73.73 103.08,73.07 102.62,73.07 102.25,72.7 102.25,72.52 102.35,72.42 102.35,72.24 102.17,72.06 101.99,72.06 101.89,72.16 101.71,72.16 101.17,71.62 101.17,71.35 100.15,70.33 99.85,70.33 98.54,69.03 98.54,64.27 90.54,56.27 90.54,46.09 90.8,45.83 90.8,39.27 92.99,37.08 92.99,31.95 95.12,29.83 95.12,27.53 98.69,23.96 98.69,21.99 98.81,21.87 99.02,21.87 99.22,22.07 v2(99.22,22.08)
  BOTTOM w0.14: v2(101.51,78.5) 101.78,78.5 101.96,78.31 CPU1.AN60 ; v2(99.22,22.08) 98.94,22.08 98.77,21.92 98.77,21.44 98.59,21.26 98.33,21.26 98.15,21.44 98.15,23.04 98.25,23.13 98.25,23.82 98.15,23.92 DM2.69
