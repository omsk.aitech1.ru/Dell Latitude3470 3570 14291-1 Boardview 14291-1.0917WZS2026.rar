# Allegro board 14291-1.0917WZS2026.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM: 129.83,88.84 129.43,89.23 128.4,89.23 128.39,89.22 128.12,89.49 128.12,89.93 128.83,90.64 129.23,90.64 129.37,90.78 129.37,91.59 129.37,91.59 129.37,92.41 128.78,93 128.85,93.06 128.85,94.57 129.09,94.82 129.09,95.36 128.97,95.48 128.91,95.48 128.91,95.76 129.14,96 130.08,96 130.66,95.41 130.66,92.83 130.06,92.23 130.06,91.77 130.18,91.64 130.18,91.42 130.38,91.42 130.41,91.45 130.4,91.47 130.4,92.12 131.17,92.89 132.01,92.89 132.86,93.74 133.01,93.74 133.28,94.01 133.56,94.01 134.75,92.82 135.54,92.82 135.69,92.97 135.69,93.4 136.47,93.4 136.59,93.27 136.59,93.16 135.52,92.09 134.95,92.09 134.9,92.04 133.57,92.04 133.42,91.89 133.42,91.16 133.41,91.16 133.41,90.94 133.37,90.9 131.87,90.9 131.64,91.13 130.93,91.13 130.93,89.91 129.87,88.84
GND on BOTTOM: 182.86,28.24 182.77,28.33 182.77,28.83 182.83,28.9 184.59,28.9 184.68,28.8 184.68,28.38 184.54,28.24
GND on BOTTOM: 195.14,176.19 195,176.34 195,177.89 195.31,178.2 209,178.2 209.2,177.99 209.2,176.43 208.97,176.19 206.7,176.19 206.69,176.19 ; 15 cut-outs
GND on BOTTOM: 159.33,62.86 158.85,63.34 158.16,63.34 157.88,63.07 157.37,63.07 157.26,63.17 157.26,63.65 157.94,64.33 159.37,64.33 159.79,64.75 162.8,64.75 162.9,64.65 162.9,63.25 162.51,62.86 ; 2 cut-outs
GND on BOTTOM: 203.45,101.12 203.07,101.5 203.07,105.44 203.19,105.57 204.97,105.57 205.35,105.19 206.24,105.19 206.62,105.57 206.62,107.6 206.5,107.73 205.61,107.73 205.48,107.85 205.48,110.9 205.61,111.03 206.5,111.03 206.62,111.15 207.13,111.15 207.39,110.9 207.39,110.52 207.51,110.39 208.02,110.39 208.27,110.14 208.27,109.5 208.4,109.38 208.91,109.38 209.16,109.12 209.16,106.13 206.22,103.18 206.22,101.73 205.61,101.12 ; 2 cut-outs
GND on BOTTOM: 71.6,18.78 71.52,18.85 71.52,22.31 71.53,22.31 71.53,25.56 71.64,25.66 72.88,25.66 73.35,25.2 73.35,19.05 73.07,18.78 ; 3 cut-outs
GND on BOTTOM: 123.65,80.98 123.43,81.21 123.43,81.38 123.48,81.43 123.72,81.43 123.86,81.29 124.21,81.29 124.42,81.49 126.91,81.49 127.24,81.82 127.24,82.25 127.08,82.41 126.78,82.41 126.63,82.25 126.63,81.97 126.5,81.85 126.19,81.85 126.04,82 126.04,82.25 126.58,82.79 126.58,83.07 126.42,83.22 125.71,83.22 125.33,83.6 125.33,83.88 125.48,84.03 125.79,84.03 125.89,83.93 125.89,83.73 126.14,83.47 126.49,83.47 126.67,83.65 126.67,83.88 126,84.54 126,84.81 125.74,85.08 125.45,85.08 125.35,85.17 125.35,86.47 125.56,86.68 125.86,86.68 126,86.82 126,87.22 126.06,87.28 126.06,87.3 126.11,87.34 126.51,87.34 126.59,87.26 126.59,86.07 126.72,85.94 127.11,85.94 127.37,86.2 127.37,86.42 127.45,86.51 127.69,86.51 127.81,86.4 127.81,86.15 127.28,85.62 127.28,85.07 127.17,84.96 126.77,84.96 126.64,84.83 126.64,84.39 126.94,84.09 127.78,84.09 127.85,84.02 127.85,83.73 127.29,83.17 127.29,82.81 127.44,82.66 127.74,82.66 127.88,82.52 127.88,81.96 126.91,80.98
GND on BOTTOM: 212.87,148.46 212.74,148.59 212.74,149.23 213.13,149.63 215.88,149.63 216.09,149.41 216.09,148.89 215.67,148.46
GND on BOTTOM: 131.44,130.2 131.31,130.33 131.31,134.27 131.57,134.52 134.74,134.52 134.87,134.4 134.87,132.24 134.74,132.11 134.36,132.11 133.98,132.49 133.34,132.49 133.09,132.24 133.09,130.33 132.96,130.2 ; 1 cut-out
GND on BOTTOM: 128.54,107.98 128.46,108.07 128.46,115.46 128.46,115.89 129.64,117.07 129.64,119.59 129.81,119.77 131.82,119.77 132.33,119.26 132.33,110.85 132.3,110.82 132.03,110.82 129.19,107.98 ; 6 cut-outs
GND on BOTTOM: 104.59,125.9 104.13,126.35 104.13,135.1 104.56,135.53 107.61,135.53 107.82,135.32 107.82,130.33 108.25,129.9 110.87,129.9 110.97,130 110.97,130.69 110.99,130.71 111.15,130.71 111.17,130.69 111.17,130 111.25,129.93 113.18,129.93 113.25,129.85 113.25,128.12 113.3,128.07 113.96,128.07 114.02,128.02 114.02,127.87 113.99,127.84 113.33,127.84 113.25,127.77 113.25,127.31 113.13,127.18 112.11,127.18 112.11,127.19 112.11,127.84 112.02,127.93 111.36,127.93 111.27,127.85 111.27,127.19 111.26,127.18 107.61,127.18 107.24,126.82 107.24,126.27 106.86,125.9 ; 2 cut-outs
GND on BOTTOM: 146.6,144.68 150.36,144.68 150.46,144.78 150.46,147.65 148.61,149.51 147.29,149.51 146.45,148.67 146.07,148.67 145.77,148.98 145.77,150.02 145.71,150.07 145.16,150.07 144.83,150.4 144.24,150.4 144.19,150.35 144.19,148.95 143.78,148.54 143.78,147.98 143.96,147.81 144.8,147.81 145.94,146.66 145.94,145.34
GND on BOTTOM: 38.24,54.26 38.23,54.26 38.23,56 38.26,56.02 40.01,56.02 40.01,56.02 40.01,54.26
GND on BOTTOM: 132.53,110.82 132.46,110.89 132.46,115.66 132.62,115.83 133.7,115.83 134.11,115.42 134.11,110.9 134.03,110.82 ; 3 cut-outs
GND on BOTTOM: 201.09,159.11 200.48,159.72 200.48,161.75 200.58,161.85 203.36,161.85 203.48,161.73 203.48,161.05 203.27,160.84 203.27,159.26 203.12,159.11 ; 5 cut-outs
GND on BOTTOM: 154.17,89.9 153.85,90.22 153.85,91.74 153.86,91.73 153.86,91.96 155.84,93.94 158.48,93.94 159.34,93.08 159.34,90.51 158.98,90.14 158.09,90.14 157.73,90.51 157.06,90.51 155.19,90.51 154.58,89.9 ; 2 cut-outs
GND on BOTTOM: 165.79,102.79 165.49,103.09 165.49,106.26 165.66,106.44 167.35,106.44 167.45,106.34 167.45,102.94 167.3,102.79 ; 4 cut-outs
GND on BOTTOM: 171.22,131.22 171.19,131.24 171.19,132.2 171.09,132.29 168.7,132.29 168.49,132.5 168.49,133.09 168.58,133.18 170.29,133.18 170.3,133.17 172.68,133.17 172.89,132.97 173.51,132.97 173.69,133.15 174.54,133.15 175.33,133.93 176.73,133.93 176.87,133.79 176.87,132.26 176.65,132.03 175.28,132.03 174.97,131.72 173.43,131.72 172.86,132.29 171.48,132.29 171.41,132.22 171.41,131.25 171.38,131.22 ; 3 cut-outs
GND on BOTTOM: 32.91,45.49 32.66,45.74 32.66,50.31 32.79,50.44 36.72,50.44 37.61,49.55 37.61,46.25 36.85,45.49
GND on BOTTOM: 193.3,159.66 192.82,160.14 192.82,160.68 193.05,160.91 195.98,160.91 196.14,160.75 196.14,159.8 196.01,159.66 ; 2 cut-outs
GND on BOTTOM: 151.3,122.59 151.22,122.67 151.22,124.76 151.32,124.86 152.39,124.86 152.69,124.57 152.69,124.33 152.87,124.15 153.15,124.15 153.44,124.44 158.61,124.44 158.79,124.26 158.79,123.06 158.64,122.91 152.68,122.91 152.36,122.59 ; 5 cut-outs
GND on BOTTOM: 112.53,98.99 112.3,99.22 112.3,100.19 113.14,101.03 113.14,104.02 114.37,105.25 116.87,105.25 118.03,104.09 118.03,100.05 116.96,98.99 ; 3 cut-outs
GND on BOTTOM: 188.44,20.7 187.94,21.2 187.94,24.15 187.98,24.19 189.27,24.19 189.3,24.17 189.3,23.7 189.37,23.63 191.83,23.63 191.9,23.7 191.9,33.83 191.88,33.85 189.54,33.85 189.36,34.03 186.52,34.03 186.09,34.47 184.88,34.47 184.7,34.65 184.7,35.26 184.35,35.62 180.97,35.62 180.54,36.04 177.84,36.04 177.48,35.68 177.48,34.61 177.48,32.52 177.13,32.18 157.55,32.18 157.12,31.75 157.12,30.84 156.76,30.48 155.87,30.48 155.56,30.8 155.56,36.72 158.19,39.35 159.52,39.35 159.78,39.09 159.78,36.04 160.03,35.8 161.22,35.8 161.45,36.03 161.45,37.55 161.51,37.61 162.2,37.61 162.24,37.57 162.24,36.01 162.57,35.68 170.25,35.68 170.49,35.44 174.81,35.44 176.83,37.46 178.2,37.46 178.63,37.9 183.82,37.9 184.14,37.58 185.11,37.58 185.54,38.01 186.18,38.01 186.38,37.81 186.38,37.26 187.08,36.57 194.23,36.57 194.54,36.25 194.54,21.22 194.02,20.7 ; 6 cut-outs
GND on BOTTOM: 167.19,125.72 167.13,125.77 167.13,126.68 167.31,126.86 169.36,126.86 170.48,127.97 171.38,127.97 171.46,127.89 171.46,126.04 171.14,125.72
GND on BOTTOM: 139.64,112.98 139.46,113.16 139.46,115.33 139.65,115.52 141.98,115.52 142.24,115.26 142.24,113.28 141.94,112.98 ; 1 cut-out
GND on BOTTOM: 185.9,32.28 185.62,32.56 185.62,33.02 185.87,33.27 187.79,33.27 187.9,33.16 189.21,33.16 189.3,33.08 189.3,32.47 189.21,32.38 187.9,32.38 187.81,32.28
GND on BOTTOM: 208.5,139.09 208.4,139.2 208.4,139.55 208.12,139.83 207.41,139.83 207.31,139.93 207.31,140.44 207.41,140.54 209.39,140.54 209.47,140.47 209.47,140.03 209.09,139.65 209.09,139.25 208.94,139.09 ; 1 cut-out
GND on BOTTOM: 171.32,5.69 171.14,5.87 171.14,6.88 174.1,9.83 181.77,9.83 182.39,10.45 182.39,17.59 183.93,19.14 197.51,19.14 198.16,18.49 198.16,15.52 188.34,5.69 ; 2 cut-outs
GND on BOTTOM: 130.25,139.2 135.71,139.2 136.57,138.33 136.57,137.04 136.19,136.66 129.79,136.66 129.59,136.86 129.59,138.54
GND on BOTTOM: 64.62,13.98 64.49,14.12 64.49,16.05 64.63,16.2 72.3,16.2 72.46,16.04 72.46,14.14 72.3,13.98
GND on BOTTOM: 145.28,152.81 145.16,152.94 145.16,158.65 145.28,158.78 146.55,158.78 146.93,158.4 146.93,152.94 146.81,152.81 ; 2 cut-outs
GND on BOTTOM: 169.41,113.14 169.19,113.36 169.19,115.93 169.45,116.2 171.39,116.2 171.7,115.88 171.7,113.28 171.56,113.14 ; 1 cut-out
GND on BOTTOM: 51.54,27.46 51.3,27.7 51.3,28.83 51.4,28.93 56.5,28.93 56.7,28.73 56.7,27.67 56.49,27.46
GND on BOTTOM: 42.95,45.36 41.93,46.38 41.93,49.93 42.18,50.19 44.98,50.19 45.11,50.06 45.11,47.9 45.36,47.65 45.36,45.74 44.98,45.36
GND on BOTTOM: 205.89,141.76 205.71,141.94 205.71,142.35 206.7,143.34 208.53,143.34 208.68,143.18 208.68,142.62 208.84,142.45 209.43,142.45 209.49,142.38 209.49,141.83 209.42,141.76 ; 3 cut-outs
GND on BOTTOM: 140.08,117 139.95,117.12 139.95,124.11 140.08,124.24 141.85,124.24 142.36,123.73 142.36,117.25 142.11,117 ; 2 cut-outs
GND on BOTTOM: 182.93,32.93 182.6,33.27 182.59,33.26 181.44,33.26 181.24,33.47 181.24,34.58 181.37,34.71 183.42,34.71 183.82,34.32 183.82,33.1 183.65,32.93 ; 1 cut-out
GND on BOTTOM: 139.96,94.71 139.88,94.79 139.88,95.33 140.22,95.68 140.22,96.04 140.31,96.13 142.47,96.13 142.75,96.41 145.06,96.41 145.39,96.74 146.93,96.74 147.42,97.22 147.42,97.57 147.57,97.72 148.1,97.72 148.15,97.67 149.93,97.67 150.11,97.48 150.11,96.07 149.97,95.92 149.31,95.92 149.3,95.93 148.17,95.93 147.1,94.86 140.79,94.86 140.64,94.71 ; 9 cut-outs
GND on BOTTOM: 169.76,22.5 169.13,23.12 169.13,23.47 169.08,23.52 168.24,23.52 168.22,23.55 168.22,23.81 168.24,23.83 169.53,23.83 170.98,22.38 171.29,22.38 171.42,22.25 171.42,21.59 171.34,21.52 170.43,21.52 170.28,21.67 170.28,21.99 169.77,22.5
GND on BOTTOM: 23.17,59.42 21.13,61.46 21.13,61.84 21.34,62.05 21.34,63.3 21.07,63.56 21.07,64.11 21.36,64.4 21.36,67.49 20.67,68.18 19.61,68.18 19.3,68.49 19.3,70.62 19.54,70.85 21.79,70.85 22.79,71.86 25.73,71.86 25.91,71.68 25.91,59.74 25.59,59.42
GND on BOTTOM: 128.68,81.02 128.53,81.17 128.53,81.4 128.66,81.52 129.95,81.52 130.11,81.68 130.11,81.87 130.21,81.98 130.56,81.98 130.69,81.84 130.69,81.71 130.88,81.52 131.01,81.39 131.01,81.18 130.86,81.02
GND on BOTTOM: 86.86,135.85 86.47,136.25 86.47,140.94 87.54,142.02 91.1,142.02 91.36,141.76 91.36,140.21 91.1,139.96 90.32,139.96 90,139.63 90,136.1 89.75,135.85
GND on BOTTOM: 155.7,149.25 155.44,149.51 155.44,151.03 155.57,151.16 157.73,151.16 157.98,150.91 157.98,149.51 157.73,149.25 ; 1 cut-out
GND on BOTTOM: 188.95,26.89 188.85,26.99 186.98,26.99 186.8,27.17 185.83,27.17 185.46,27.55 185.46,27.88 185.55,27.96 187.72,27.96 187.93,28.17 189.24,28.17 189.28,28.13 189.28,26.98 189.27,26.98 189.19,26.89
GND on BOTTOM: 52.19,19.46 51.94,19.71 51.94,22.25 52.06,22.38 58.29,22.38 58.58,22.09 58.58,19.68 58.36,19.46
GND on BOTTOM: 188.68,139.41 188.42,139.67 188.42,139.79 195.28,146.65 195.28,146.78 194.9,147.16 194.65,147.16 188.93,141.45 188.68,141.45 188.55,141.57 188.55,141.83 193.57,146.85 193.57,147.27 193.37,147.48 193.06,147.48 188.93,143.35 188.68,143.35 188.42,143.6 188.42,143.73 191.64,146.95 191.64,147.25 191.38,147.5 191.03,147.5 190.81,147.28 190.81,147.26 188.93,145.38 188.68,145.38 188.42,145.64 188.42,145.76 190.33,147.67 195.68,147.67 196.14,147.2 196.14,146.63 188.93,139.41
GND on BOTTOM: 131.51,83.69 131.07,84.13 130.75,84.13 130.72,84.1 130.64,84.1 130.59,84.15 128.7,84.15 128.54,84.31 128.54,84.55 128.67,84.68 130.5,84.68 130.65,84.82 130.65,85.01 130.82,85.19 131.22,85.19 131.38,85.03 131.38,84.79 131.43,84.74 132.45,84.74 132.88,85.17 133.19,85.17 133.89,84.47 133.96,84.47 133.96,84.06 133.95,84.06 133.21,84.06 133.17,84.1 132.16,84.1 131.92,83.86 131.92,83.69
GND on BOTTOM: 94.58,108.38 94.18,108.78 94.18,113.01 96.18,115 99.4,115 99.72,114.69 99.72,109.67 98.43,108.38
GND on BOTTOM: 24.5,27.21 24.44,27.26 24.44,28.18 24.71,28.45 29.32,28.45 29.72,28.05 29.72,27.33 29.6,27.21 ; 1 cut-out
GND on BOTTOM: 172.23,97.49 172.07,97.65 172.07,98.72 171.84,98.95 171.82,98.95 171.68,99.09 171.68,101 171.83,101.15 173.98,101.15 174.45,100.68 174.45,97.58 174.36,97.49 ; 4 cut-outs
GND on BOTTOM: 111.06,163.85 109.46,165.45 109.46,169.99 108.74,170.71 106.4,170.71 105.86,170.17 105.86,167.92 104.41,166.48 101.89,166.48 100.6,167.77 100.6,169.81 107.76,176.97 117.46,176.97 118.07,176.36 118.07,172.23 118.45,171.84 118.79,171.84 119,172.06 119,175.92 119.91,176.82 120.64,176.82 121.59,177.78 128.92,177.78 129.7,177 129.7,167.94 129.53,167.77 126.42,167.77 126.06,168.12 126.06,173.28 123.96,175.38 123.96,176.9 123.82,177.05 123.07,177.05 122.86,176.84 122.86,174.71 125.02,172.55 125.02,168.14 124.39,167.51 121.96,167.51 121.06,166.61 121.06,165.66 119.25,163.85
GND on BOTTOM: 44.54,30.91 44.39,31.06 44.39,32.92 44.88,33.4 48.73,33.4 48.88,33.26 48.88,31.93 48.6,31.64 48.6,31.03 48.48,30.91
GND on BOTTOM: 96.31,154.09 96.21,154.18 96.21,155.65 95.87,155.99 95.87,158.47 94.68,159.66 93.12,159.66 92.77,160.02 92.77,164.61 93.25,165.09 95.65,165.09 96.76,163.97 96.76,160.28 97.74,159.31 97.74,154.38 97.44,154.09 ; 1 cut-out
GND on BOTTOM: 60.86,40.77 60.23,41.4 60.23,43.22 59.64,43.81 59.64,48.31 60.06,48.73 64.63,48.73 64.94,48.41 64.94,41.37 64.35,40.77
GND on BOTTOM: 47.02,21.33 46.95,21.41 46.95,23.07 47.02,23.14 48.73,23.14 48.82,23.05 48.82,21.45 48.7,21.33
GND on BOTTOM: 160.08,42.69 159.9,42.87 159.9,43.72 159.72,43.9 159.72,44.58 159.81,44.66 161.84,44.66 162.03,44.85 162.54,44.85 162.79,44.59 162.79,42.78 162.71,42.69
GND on BOTTOM: 119.6,127.66 118.76,128.51 118.76,132.89 118.01,133.63 118.01,135.06 119.11,136.16 121.44,136.16 121.55,136.05 121.55,130.58 121.75,130.38 124.23,130.38 124.3,130.46 124.3,131.17 124.33,131.2 124.45,131.2 124.51,131.14 124.51,130.46 124.58,130.38 126.56,130.38 126.61,130.33 126.61,129.42 126.66,129.37 127.44,129.37 127.69,129.62 127.82,129.62 127.97,129.77 128.26,129.77 128.37,129.66 128.37,129.34 128.27,129.24 127.67,129.24 127.58,129.15 126.65,129.15 126.59,129.09 126.59,128.6 126.61,128.58 127.61,128.58 127.73,128.7 127.96,128.7 128.09,128.57 128.09,128.41 127.96,128.29 127.64,128.29 127.58,128.35 126.69,128.35 126.59,128.25 126.59,127.82 126.44,127.66 125.46,127.66 125.44,127.69 125.44,128.35 125.35,128.44 124.7,128.44 124.61,128.35 124.61,127.69 124.58,127.66 ; 2 cut-outs
GND on BOTTOM: 167.43,66.25 167.33,66.35 167.33,67.97 167.74,68.38 169.9,68.38 170,68.28 170,66.6 169.64,66.25 ; 2 cut-outs
GND on L2VCC: outline of 213 points within 0.76,0.76 221.04,181.21 ; 4 cut-outs
GND on L3: outline of 324 points within 0.76,0.76 221.04,181.21 ; 7 cut-outs
GND on L3: 206.75,111.15 208.53,111.15 209.16,110.52 209.16,105.44 208.53,104.8 208.53,102.14 206.24,99.85 204.46,99.85 203.07,101.25 203.07,105.44 203.19,105.57 204.72,105.57 205.48,106.33 205.48,109.63 205.61,109.76 206.5,109.76 206.62,109.88 206.62,111.03
GND on L3: 213.1,110.77 209.93,110.77 209.67,110.52 209.67,105.06 209.93,104.8 209.93,102.26 212.59,99.6 214.24,99.6 215.13,100.49 215.13,104.42 214.88,104.68 212.34,104.68 211.96,105.06 211.96,107.09 212.08,107.22 213.1,107.22 213.23,107.34 213.23,110.65
GND on L3: 107.47,135.66 107.75,135.38 107.75,130.09 108.08,129.75 113.09,129.75 113.27,129.58 113.27,127.43 112.85,127.01 107.79,127.01 107.15,126.37 107.15,121.67 106.25,120.78 102.23,120.78 101.89,121.11 101.89,123.92 99.28,126.52 99.28,134.84 100.1,135.66
GND on L3: 118.92,136.17 118.6,135.86 118.6,132.07 114.18,127.65 114.18,121.85 114.78,121.25 119.18,121.25 119.68,121.75 119.68,127.28 120.16,127.77 126.52,127.77 126.67,127.92 126.67,130.11 126.4,130.38 121.91,130.38 121.61,130.69 121.61,135.84 121.28,136.17
GND on L3: 145.07,8.06 145.07,4.37 145.35,4.09 173.75,4.09 181.96,12.3 181.96,14.02 180.67,15.31 162.97,15.31 161.74,14.08 151.85,14.08 148.25,10.49 147.5,10.49
GND on L4: 149.59,64.57 152.43,64.57 154.4,62.59 154.4,59.73 152.93,58.25 149.73,58.25 148.13,59.85 148.13,64.21 147.76,64.58 147.76,65.95 147.96,66.15 148.34,66.15 148.71,65.78 148.71,65.44
GND on L4: 118.43,136.1 118.43,128.26 119.53,127.16 126.56,127.16 126.88,127.49 126.88,130.89 126.08,131.69 123.46,131.69 122.87,132.28 122.87,135.94 122.38,136.42 118.76,136.42
GND on L4: outline of 154 points within 0.76,1.23 87.45,117.63 ; 8 cut-outs
GND on L4: 103.79,135.48 103.79,127.28 104.84,126.22 112.62,126.22 113.32,126.93 113.32,129.6 112.95,129.96 110.02,129.96 109.21,130.78 109.21,135.68 108.96,135.93 104.24,135.93
GND on L4: outline of 153 points within 0.76,0.76 221.04,181.21 ; 1 cut-out
GND on L5GND: outline of 213 points within 0.76,0.76 221.04,181.21
VCC_CORE on TOP: 113.61,78.24 112.85,79 112.85,80.31 112.99,80.45 112.99,81.15 112.8,81.33 110.3,81.33 110.14,81.49 110.14,84.44 110.91,85.21 110.91,90.02 110.79,90.15 110.79,92.38 110.21,92.97 110.2,92.97 108.83,94.34 108.83,96.42 108.33,96.93 108.33,103.01 114.89,109.58 119.8,109.58 120.03,109.81 120.03,120.78 120.29,121.03 129.5,121.03 130.17,120.36 130.17,103.33 118.61,91.77 118.61,89.51 118.3,89.2 118.3,87.23 118.13,87.06 117,87.06 116.76,86.82 116.76,84.72 117.27,84.21 117.27,82.19 117.12,82.04 116.69,82.04 116.47,81.81 116.47,81.25 116.75,80.96 117.12,80.96 117.27,80.81 117.27,79.57 117.68,79.16 117.68,78.73 117.19,78.24 ; 53 cut-outs
VCC_CORE on BOTTOM: 113.74,78.28 112.51,79.5 112.51,80.22 112.89,80.6 116.86,80.6 117.26,80.2 117.26,79.65 117.68,79.23 117.68,78.69 117.27,78.28
VCC_CORE on BOTTOM: 111.14,88.7 110.79,89.06 110.79,90.58 111.83,91.62 118.26,91.62 118.63,91.25 118.63,90.85 118.19,90.41 118.19,89.74 117.53,89.07 117.53,89.03 117.2,88.7
VCC_CORE on BOTTOM: 120.94,107.88 120.03,108.79 120.03,120.75 120.33,121.05 121.93,121.05 122.6,120.38 128.69,120.38 129.26,119.82 129.26,117.02 128.29,116.06 128.29,108.23 127.94,107.88 ; 10 cut-outs
VCC_CORE on BOTTOM: 114.14,95.43 113.53,96.04 113.1,96.04 112.82,95.76 112.67,95.76 112.65,95.78 112.65,96.12 112.76,96.23 112.76,97.66 113.1,98 113.1,98.61 113.23,98.74 116.73,98.74 117.09,98.38 117.09,97.24 116.69,96.84 116.69,96.59 116.28,96.17 116.02,96.17 115.28,95.43 ; 3 cut-outs
VCC_CORE on L3: 128.6,119.77 128.6,110.9 128.56,110.86 128.56,107.74 128.56,107.71 121.04,100.19 121.04,98.96 119.62,97.54 119.62,93.49 119.38,93.25 119.38,93.24 119,92.86 119,82.54 117.49,81.02 117.49,79.97 116.9,79.37 113.01,79.37 112.55,78.92 108.3,78.92 108.29,78.94 105.86,78.94 105.5,79.29 105.5,81.32 106.81,82.63 106.81,88.61 107.06,88.86 107.06,89.32 106.71,89.66 105.93,89.66 105.3,90.29 105.3,94.79 107.27,96.76 107.27,106.35 111.2,110.28 113.14,110.28 113.93,111.07 114.01,111.15 114.01,119.18 115.14,120.31 115.19,120.31 115.91,121.04 121.97,121.04 122.42,120.59 127.78,120.59
VCC_CORE on L4: 114.2,98.05 116.56,98.05 116.99,97.62 116.99,91.9 116.76,91.67 116.76,90.02 116.17,89.44 114.35,89.44 114.12,89.67 114.12,94.95 112.95,96.11 112.95,96.8
VCCPRIM_CORE on BOTTOM: 150.36,116.62 150.24,116.74 150.24,119.79 151.89,119.79 152.14,119.54 152.14,117 152.01,116.87 151,116.87 150.74,116.62
VDD10 on TOP: 49.61,172.81 49.45,172.97 49.45,173.9 49.96,174.4 49.96,176.61 50.08,176.73 51.6,176.73 51.95,176.38 51.95,174.23 50.86,173.14 50.86,172.96 50.71,172.81 ; 2 cut-outs
VDD10 on BOTTOM: 43.18,166.59 43,166.77 43,167.1 43.32,167.42 43.32,168.98 42.72,169.58 42.72,170.64 44.75,172.67 48.33,172.67 50.72,170.29 50.72,167.41 50.54,167.24 48.84,167.24 48.73,167.34 48.73,170.2 48.47,170.47 44.51,170.47 44.15,170.1 44.15,166.95 44.1,166.9 43.75,166.9 43.44,166.59 ; 2 cut-outs
VDD10 on L4: 52.22,169.19 51.99,168.95 49.49,168.95 49.2,169.25 49.2,176.79 49.3,176.89 51.79,176.89 52.22,176.46
VDDREG on TOP: 52.04,169.59 51.76,169.86 48.2,169.86 48.17,169.89 48.17,170.05 48.2,170.07 49.19,170.07 50.21,171.09 51.32,171.09 53.53,171.09 53.59,171.02 53.59,169.65 53.53,169.59 ; 1 cut-out
0D675V_S0 on TOP: 137.18,14.66 136.93,14.91 136.93,15.58 137.26,15.91 138.91,15.91 139.95,16.95 139.95,19.71 140.08,19.84 141.41,19.84 141.79,19.46 141.79,16.02 140.43,14.66 ; 2 cut-outs
0D675V_S0 on TOP: 42.25,19.68 41.8,20.13 41.8,21.61 41.86,21.67 44.14,21.67 44.49,21.33 44.49,19.79 44.41,19.72 43.87,19.72 43.83,19.68
0D675V_S0 on BOTTOM: 63.9,11.24 62.13,13.01 54.35,13.01 52.27,15.1 46.59,15.1 45.96,15.72 45.96,16.65 44.68,17.93 44.68,19.54 44.54,19.68 42.93,19.68 42.57,20.05 42.57,21.37 42.87,21.68 45.23,21.68 46.81,20.1 46.81,19.8 46.83,19.8 49.66,16.97 52.79,16.97 54.5,15.25 63,15.25 64.81,13.45 134.13,13.45 136.25,15.56 139.33,15.56 139.62,15.27 139.62,14.06 137.18,11.62 74.84,11.62 74.47,11.24
0D675V_S0 on BOTTOM: 141.17,15.69 140.89,15.97 140.89,20.41 142.9,22.42 142.9,25.88 140.09,28.69 130.83,28.69 129.75,29.77 128.6,29.77 127.88,29.05 126.44,29.05 126.4,29.09 126.4,30.83 125.37,31.86 125.37,33.34 126.26,34.23 126.26,37.11 126.09,37.28 126.09,39.02 126.21,39.14 127.04,39.14 127.39,38.79 127.39,32.6 128.13,31.86 133.05,31.86 134.16,30.76 140.71,30.76 144.5,26.97 144.5,17.78 142.41,15.69
1D0V_PWR on BOTTOM: 149.35,116.74 149.09,117 142.87,117 142.62,117.25 142.62,127.03 143.12,127.54 148.77,127.54 148.86,127.45 148.86,125 147.14,123.28 147.14,122.25 147.7,121.7 148.97,121.7 149.22,121.95 149.22,123.09 149.35,123.22 150.87,123.22 151,123.09 151,120.3 150.74,120.04 150.11,120.04 149.98,119.92 149.98,116.87 149.85,116.74 ; 2 cut-outs
1D0V_PWR on BOTTOM: 151.59,135.54 151.51,135.63 151.51,136.94 151.62,137.05 152.4,137.05 152.92,136.54 152.92,136.13 152.34,135.54 ; 1 cut-out
1D0V_S5 on BOTTOM: 154.28,109.36 153.12,110.52 144.34,110.52 143.89,110.98 143.89,116.74 148.33,116.74 148.46,116.62 148.46,113.07 149.2,112.32 153.1,112.32 153.38,112.61 153.98,112.61 154.24,112.34 154.24,112.16 154.46,111.93 158.4,111.93 159.49,113.03 160.02,113.03 160.78,113.8 160.97,113.8 161.12,113.95 161.12,116.84 160.94,117.02 160.94,123.1 161.04,123.19 162.52,123.19 162.6,123.11 162.6,117.76 162.86,117.5 162.86,111.28 161.35,109.77 160.94,109.36 ; 2 cut-outs
1D5V_PWR on TOP: 36.58,14.49 36.38,14.69 36.38,16.74 36.73,17.1 38.78,17.1 38.98,16.9 38.98,16.34 38.58,15.93 38.35,15.93 38.22,15.8 38.22,15.22 37.99,14.99 37.68,14.99 37.18,14.49 ; 1 cut-out
1D05V_PWR on BOTTOM: 153.03,151.67 152.65,152.05 152.65,156.24 153.03,156.62 158.62,156.62 159.25,155.99 159.25,151.92 159,151.67 ; 3 cut-outs
1D5V_S0 on TOP: 34.63,12.89 34.44,13.08 34.44,13.55 34.7,13.82 34.93,13.82 35.28,14.17 36.44,14.17 36.52,14.25 37.18,14.25 37.3,14.13 37.3,13.52 36.67,12.89
1D05V_VGA_S0 on TOP: 195.78,130.74 195.65,130.87 195.65,131.96 196.51,132.82 197.45,132.82 197.66,132.62 197.66,130.89 197.51,130.74 ; 1 cut-out
1D05V_VGA_S0 on TOP: 185.53,145.97 185.24,146.26 185.24,146.71 184.52,147.43 183.41,147.43 183.08,147.1 183.08,146.59 182.81,146.32 181.38,146.32 180.85,146.84 175.61,146.84 175.12,146.36 166.54,146.36 164.71,148.18 164.71,150.29 165.91,151.48 165.91,154.19 163.35,156.75 155.7,156.75 155.44,157.01 155.44,159.69 156.21,160.46 163.92,160.46 163.92,160.46 164.36,160.46 169.07,155.75 169.07,151.76 170.92,149.91 174.09,149.91 174.1,149.92 174.14,149.92 175.12,150.9 184.98,150.9 187.75,148.13 187.75,146.23 187.49,145.97 ; 6 cut-outs
1D05V_VGA_S0 on BOTTOM: 188.54,129.62 187.94,130.22 185.82,130.22 185.53,130.51 185.53,131.51 185.67,131.65 192.37,131.65 193.14,132.41 197.73,132.41 197.94,132.21 197.94,130.81 197.72,130.6 193.81,130.6 192.83,129.62
1D05V_VGA_S0 on BOTTOM: 186.65,139.16 186.39,139.42 186.39,141.62 187.19,142.42 187.19,143.69 186.43,144.45 186.43,146.09 186.26,146.26 186.26,146.54 186.38,146.65 186.38,146.95 186.26,147.07 186.26,147.33 186.41,147.48 186.41,147.73 186.23,147.91 186.23,148.16 186.39,148.33 186.39,148.58 185.39,149.59 181.94,149.59 180.1,147.75 170.57,147.75 166.31,152.01 166.31,154.24 163.79,156.75 155.58,156.75 155.43,156.9 155.43,159.67 156.08,160.32 167.47,160.32 176.19,151.6 181.71,151.6 181.87,151.44 183.03,151.44 183.18,151.59 183.18,151.95 182.62,152.5 182.62,153.46 182.8,153.63 183.69,153.63 183.87,153.46 183.87,152.73 183.88,152.72 183.88,152.62 185.48,151.02 185.48,150.87 185.34,150.73 185.34,150.45 185.57,150.22 185.87,150.22 186.02,150.37 186.2,150.37 187.14,149.43 187.14,149.23 187.02,149.1 187.02,148.82 187.6,148.24 187.6,148.04 187.79,147.85 187.79,139.41 187.53,139.16 ; 4 cut-outs
1D05V_VGA_S0 on L3: 187.28,148.48 187.98,147.78 187.98,135.9 186.99,134.91 186.99,130.41 186.81,130.23 185.89,130.23 185.73,130.38 185.73,136.2 186.02,136.49 186.02,141.61 185.85,141.79 183.13,141.79 182.77,142.14 182.77,143.16 179.57,146.36 177.24,146.36 176.88,146.71 176.88,149.18 177.05,149.35 184.52,149.35 185.39,148.48
1D8V_PWR on BOTTOM: 171.38,101.57 171.25,101.7 171.25,102.13 171.13,102.26 168.75,102.26 167.7,103.32 167.7,106.87 167.9,107.08 168.45,107.08 169.76,105.77 171.96,105.77 172.12,105.61 172.12,101.61 172.09,101.57 ; 9 cut-outs
1D8V_S5 on BOTTOM: 167.36,95.79 167.13,96.01 167.13,98 167.3,98.17 167.3,99.69 167.13,99.87 167.13,102.47 167.28,102.62 168,102.62 168.83,101.79 170.9,101.79 171.04,101.66 171.04,101.41 171.45,101 171.45,100.99 171.48,100.96 171.48,97.62 171.33,97.47 169.57,97.47 169.12,97.02 169.12,96.12 168.78,95.79 ; 6 cut-outs
1D35V_S3 on TOP: 75.81,14.56 74.39,15.98 64.92,15.98 64.71,16.19 64.71,27.16 62.65,29.22 62.65,33.83 63.48,34.66 63.48,38.72 65.93,41.18 65.93,43.26 69.64,46.97 85.95,46.97 89.35,50.37 89.35,58.12 90.29,59.06 90.29,64.16 93.47,67.34 93.9,67.34 95.01,68.45 104.68,68.45 110.87,74.64 110.87,77.2 111.22,77.54 121.11,77.54 122.35,78.78 122.86,78.78 123.21,78.43 123.21,74.69 122.8,74.28 122.8,72.56 123.45,71.92 123.45,71.66 123.4,71.61 123.4,71.34 124.14,70.59 124.14,70.54 124.6,70.08 124.6,63.81 125.92,62.5 126.79,62.5 127.01,62.72 129.67,62.72 129.78,62.61 129.78,61.64 129.65,61.51 128.76,61.51 128.41,61.17 128.41,58.64 129.75,57.3 129.75,52.56 133.81,48.5 140.06,48.5 141.82,46.74 142.43,46.74 147.71,41.46 147.71,35.57 148.23,35.05 155.12,35.05 155.21,34.96 155.21,29.74 155.21,29.73 155.21,23.26 152.52,20.58 151.47,20.58 147.97,17.07 147.97,16.02 146.27,14.33 96.46,14.33 95.73,15.07 87.5,15.07 86.99,14.56 ; 80 cut-outs
1D35V_S3 on BOTTOM: 64.63,16.29 64.55,16.37 64.55,25.16 65.03,25.64 71.12,25.64 71.19,25.56 71.19,18.69 71.79,18.09 71.79,16.49 71.59,16.29 ; 3 cut-outs
1D35V_S3 on BOTTOM: outline of 152 points within 87.85,24.16 117.37,30.51
1D35V_VGA_S0 on TOP: outline of 306 points within 167.71,141.64 212.33,177.91 ; 53 cut-outs
1D35V_VGA_S0 on TOP: 156.06,26.8 155.52,27.34 155.52,33.35 155.84,33.67 158.13,33.67 158.36,33.9 158.36,34.54 158.56,34.75 163.65,34.75 165.71,36.8 167.43,36.8 170.63,40.01 170.63,41.59 180.45,51.41 183.4,51.41 183.79,51.8 186.86,51.8 187.67,52.61 187.67,52.84 189.6,54.77 189.6,60.29 192.93,63.61 199.61,63.61 199.91,63.32 199.91,60.33 199.26,59.68 195.69,59.68 193.72,57.72 193.72,54.84 195.76,52.81 199.14,52.81 199.8,52.15 199.8,46.68 198.13,45 184.25,45 178.65,39.4 178.65,36.77 177.53,35.65 177.53,33.27 176.8,32.55 176.11,32.55 174.8,31.23 172.39,31.23 171.55,30.4 171.55,27.87 170.82,27.14 167.54,27.14 166.94,27.74 164.81,27.74 163.88,26.8 ; 8 cut-outs
1D35V_VGA_S0 on BOTTOM: 173.43,170.41 173.3,170.54 173.3,170.97 173.4,171.07 173.76,171.07 174.21,170.62 174.47,170.62 174.65,170.79 174.65,171.05 173.92,171.77 173.92,172.46 173.68,172.7 173.22,172.7 172.97,172.45 172.97,171.66 172.87,171.56 172.66,171.56 172.54,171.68 172.54,171.86 172.36,172.04 171.19,172.04 170.91,172.32 169.11,172.32 168.33,173.09 168.33,175.64 168.65,175.96 177.6,175.96 177.65,175.91 177.65,173.36 176.78,172.5 176.78,172.11 176.93,171.96 176.93,171.66 176.8,171.53 176.68,171.53 176.14,172.06 175.05,172.06 174.85,171.86 174.85,171.48 175.36,170.97 175.36,170.87 174.9,170.41 ; 13 cut-outs
1D35V_VGA_S0 on BOTTOM: outline of 251 points within 174.98,158.07 211.63,178.09 ; 24 cut-outs
1D35V_VGA_S0 on BOTTOM: 198.04,141.64 197.82,141.86 197.82,145.98 197.23,146.57 197.23,146.86 197,147.1 196.45,147.1 195.75,147.8 188.04,147.8 187.73,148.11 187.73,148.75 187.79,148.81 188.63,148.81 188.84,148.59 189.2,148.59 189.33,148.72 189.47,148.72 189.77,148.42 190.7,148.42 191,148.72 191.21,148.72 191.36,148.57 191.69,148.57 191.84,148.72 191.99,148.72 192.17,148.54 193.31,148.54 193.49,148.72 193.67,148.72 193.85,148.54 194.13,148.54 194.33,148.75 194.38,148.75 195.19,149.56 195.32,149.56 195.42,149.45 195.42,149.25 195.15,148.98 195.15,148.65 195.36,148.44 195.71,148.44 196.08,148.81 196.84,148.81 197.11,148.54 198.38,148.54 198.52,148.68 199.47,148.68 199.6,148.56 199.6,148.42 198.62,147.44 198.62,147.07 198.8,146.89 198.8,146.69 198.65,146.54 198.65,146.21 198.84,146.02 198.84,144.29 198.62,144.07 198.62,143.77 198.83,143.56 198.88,143.56 199.46,142.98 199.46,142.88 199.6,142.74 199.6,142.57 198.66,141.64
1D35V_VGA_S0 on L4: 188.17,132.57 192.9,127.83 193.53,127.83 196.74,124.62 196.74,119.26 197.55,118.45 197.55,97.81 201.04,94.32 201.04,90.5 200.43,89.89 200.43,89.21 201.04,88.6 201.04,54.08 200.35,53.4 200.35,49.34 199.78,48.77 192.68,48.77 192.06,49.39 192.06,89.3 189.38,91.98 189.38,116.31 176.7,128.99 176.7,132.72 172.52,136.89 172.52,138.16 168.64,142.04 168.64,155.85 168.86,156.07 170.25,156.07 177.15,149.17 184.32,149.17 185.12,148.38 189.94,148.38 190.18,148.14 190.18,148.02 190.41,147.79 190.53,147.79 190.54,147.77 190.92,147.77 191.26,148.11 191.26,148.5 196.31,148.5 196.32,148.51 198.38,148.51 198.62,148.27 198.62,146.21 199.48,145.35 199.48,143.37 199.35,143.23 199.35,142.33 198.64,141.62 198.64,140 198.14,139.5 188.92,139.5 188.17,138.75
1D35V_VGA_S0 on L4: 208.61,171.56 207.18,171.56 206.65,172.09 204.85,172.09 204.69,172.24 204.69,172.5 205.02,172.83 205.02,173.16 204.77,173.41 203.96,173.41 203.42,172.88 203.42,172.45 203.58,172.29 203.58,171.94 203.5,171.86 203.09,171.86 202.89,172.06 202.89,173.44 201.92,174.4 201.92,174.96 201.67,175.21 199.49,175.21 198.42,174.15 196.24,174.15 193.31,177.07 186.25,177.07 185.08,175.9 185.08,174.2 184.22,173.33 183.61,173.33 183.23,172.95 183,172.95 182.77,172.72 182.77,172.27 182.62,172.11 182.19,172.11 182.06,172.24 182.06,172.65 182.37,172.95 182.37,174.15 181.35,175.16 178.51,175.16 176.35,173 168.5,173 168.3,173.21 168.3,178.11 169.72,179.53 186.89,179.53 187.88,178.54 211.5,178.54 211.96,178.08 211.96,173.72 211.4,173.16 209.52,173.16 208.88,172.52 208.88,171.84
3D3V_CAMERA_S0 on BOTTOM: 77.56,159.24 77.41,159.4 77.41,160.34 76.86,160.88 76.01,160.88 75.92,160.97 75.92,162.56 76.15,162.78 78.69,162.78 79.14,162.33 79.14,159.35 79.04,159.24 ; 1 cut-out
3D3V_LAN_S5 on TOP: 42.66,163.12 42.56,163.21 42.56,163.32 42.38,163.5 41.29,163.5 41.14,163.66 41.14,165.43 41.3,165.6 43,165.6 43.27,165.33 44.78,165.33 44.98,165.13 44.98,164.86 44.37,164.25 44.37,163.28 44.21,163.12 ; 4 cut-outs
3D3V_LAN_S5 on TOP: 54.71,162.04 54.43,162.33 51.92,162.33 51.07,163.18 50.59,163.18 50.5,163.27 50.5,164.17 50.62,164.29 54.67,164.29 55.46,163.5 55.46,162.09 55.41,162.04 ; 1 cut-out
3D3V_LAN_S5 on TOP: 44.82,170.64 44.64,170.82 44.17,170.82 43.64,171.35 43.25,171.35 43.18,171.28 42.74,171.28 42.64,171.37 42.64,172.22 42.8,172.37 43.82,172.37 44.15,172.04 44.15,171.75 44.39,171.51 45.2,171.51 45.23,171.48 45.23,170.66 45.21,170.64
3D3V_LAN_S5 on TOP: 52.56,171.57 52.43,171.7 52.43,172.56 52.25,172.74 52.25,173.18 52.34,173.27 53.65,173.27 53.76,173.37 53.76,174.43 53.94,174.61 55.35,174.61 55.54,174.42 55.54,171.67 55.44,171.57 ; 2 cut-outs
3D3V_LAN_S5 on L3: 40.84,171.19 40.84,164.79 43.43,162.2 54.58,162.2 54.9,162.52 54.9,164.07 54.74,164.22 47.48,164.22 46.78,163.52 45.52,163.52 44.48,164.56 44.48,169.6 43.69,170.39 43.69,171.62 44.95,172.88 54.4,172.88 54.61,173.09 54.61,174.77 54.42,174.95 42.29,174.95 42.29,174.93 41.53,174.17 41.53,171.87
3D3V_RUN_FFS on BOTTOM: 172.86,92.54 172.73,92.67 172.73,93.62 172.8,93.7 172.97,93.7 173.82,94.55 173.82,96.28 173.59,96.51 170.76,96.51 169.56,95.3 169.56,93.04 169.43,92.91 169.08,92.91 168.87,93.12 168.87,95.73 170.38,97.25 174.28,97.25 174.89,96.64 174.89,93.82 174.72,93.64 173.79,93.64 173.6,93.44 173.6,92.68 173.45,92.54
3D3V_S0 on TOP: 147.35,145.15 146.73,145.76 138.14,145.76 132.2,151.7 132.2,152.15 132.41,152.36 136.43,152.36 140.04,148.75 146.39,148.75 146.97,148.17 158.69,148.17 159.25,147.61 159.25,145.92 158.48,145.15 ; 2 cut-outs
3D3V_S0 on TOP: 45.04,26.69 44.96,26.77 44.96,27.3 44.27,27.99 44.27,28.65 44.82,29.2 45.72,29.2 45.9,29.02 45.9,27.93 45.54,27.57 45.54,26.8 45.44,26.69
3D3V_S0 on TOP: 140.76,93.42 140.63,93.55 140.63,94.45 140.77,94.59 143.24,94.59 143.4,94.43 143.4,93.7 143.13,93.42 ; 3 cut-outs
3D3V_S0 on TOP: 158.24,79.9 158.01,80.13 158.01,80.88 158.32,81.2 159.89,81.2 160.14,80.95 160.14,79.97 160.07,79.9
3D3V_S0 on TOP: 45.16,74.23 44.85,74.55 44.85,75.4 44.97,75.53 46.92,75.53 47.02,75.42 47.02,74.38 46.87,74.23 ; 2 cut-outs
3D3V_S0 on TOP: 14.03,69.27 13.85,69.45 13.85,70.59 14,70.75 14.6,70.75 14.61,70.74 14.61,69.91 14.8,69.72 15.95,69.72 15.98,69.68 15.98,69.3 15.94,69.27
3D3V_S0 on TOP: 139.24,62.86 139.08,63.02 139.08,63.82 139.48,64.22 144.09,64.22 144.09,64.22 144.7,64.22 144.82,64.09 144.82,63.34 144.33,62.86 ; 8 cut-outs
3D3V_S0 on TOP: 33.5,25.62 33.2,25.92 33.2,27.5 33.21,27.51 33.21,28.55 33.6,28.93 34.5,28.93 34.56,28.99 34.56,30.55 35.99,30.55 36.28,30.27 37.05,30.27 37.13,30.18 37.13,29.28 36.03,28.18 36.03,25.66 35.99,25.62 ; 1 cut-out
3D3V_S0 on TOP: 151.18,99.67 150.41,100.44 150.34,100.44 150.08,100.69 148.89,100.69 148.74,100.84 148.74,101.05 148.86,101.17 150.13,101.17 150.69,101.73 152.14,101.73 152.32,101.55 152.32,100.51 152.31,100.5 152.31,99.89 152.09,99.67
3D3V_S0 on BOTTOM: 86.61,148.15 81.65,153.11 81.65,157.85 81.98,158.18 83.6,158.18 83.76,158.02 83.76,155.25 84.14,154.87 84.14,153.81 86.56,151.39 88.95,151.39 89.15,151.19 89.15,149.47 88.39,148.71 87.83,148.15 ; 3 cut-outs
3D3V_S0 on BOTTOM: 142.35,80.73 142.16,80.93 142.16,81.17 142.27,81.28 142.58,81.28 142.79,81.49 142.79,81.96 142.9,82.06 143.47,82.06 143.63,82.22 143.63,82.81 143.77,82.94 144.24,82.94 144.34,82.85 144.34,80.86 144.21,80.73 ; 1 cut-out
3D3V_S0 on BOTTOM: 169.69,89.08 169.58,89.19 169.58,90.36 169.66,90.44 171.96,90.44 172.02,90.39 172.02,89.19 171.91,89.08 ; 2 cut-outs
3D3V_S0 on BOTTOM: 14.12,69.24 14.01,69.35 14.01,69.9 14.02,69.91 14.02,75.32 14.33,75.64 19.85,75.64 19.86,75.64 21.1,75.64 21.13,75.6 44.85,75.6 48.67,79.42 50.82,79.42 51.88,80.48 55.05,80.48 55.13,80.4 55.13,78.92 54.97,78.76 53.21,78.76 52.2,77.76 49.79,77.76 46.24,74.22 16.33,74.22 15.68,73.56 15.68,71.56 16.87,70.37 18.73,70.37 18.87,70.24 18.87,69.32 18.79,69.24 ; 2 cut-outs
3D3V_S0 on BOTTOM: 138.67,98.86 138.57,98.97 138.57,99.46 138.38,99.65 136.95,99.65 136.76,99.84 136.76,101.6 136.79,101.64 137.37,101.64 137.59,101.42 138.96,101.42 139.96,100.42 139.96,98.87 139.96,98.86 ; 1 cut-out
3D3V_S0 on BOTTOM: 172.99,133.14 172.77,133.36 172.03,133.36 172,133.39 172,134.25 172.1,134.35 174.19,134.35 174.36,134.18 174.36,133.49 174.17,133.3 173.49,133.3 173.33,133.14 ; 1 cut-out
3D3V_S0 on BOTTOM: outline of 83 points within 139.93,87.24 160.14,100.37 ; 3 cut-outs
3D3V_S0 on BOTTOM: 63.55,83.07 62.77,83.85 62.77,84.14 64.3,85.66 65.65,85.66 65.66,85.67 68.71,85.67 69.36,86.32 70.03,86.32 70.63,85.72 70.63,85.28 69.38,84.03 64.92,84.03 63.96,83.07 ; 2 cut-outs
3D3V_S0 on BOTTOM: 90.04,117.49 89.5,118.03 89.5,118.7 90.73,119.94 90.73,120.66 92.15,122.08 93.22,122.08 93.39,121.9 93.39,120.37 90.51,117.49
3D3V_S0 on BOTTOM: 76.26,155.87 76.09,156.05 76.09,158.62 76.17,158.7 79.03,158.7 79.1,158.62 79.1,157.42 78.93,157.24 77.73,157.24 77.44,156.96 77.44,156.02 77.29,155.87 ; 1 cut-out
3D3V_S0 on BOTTOM: 136.85,62.87 136.72,63 136.72,63.23 136.44,63.5 135.61,63.5 135.53,63.58 135.53,63.96 135.66,64.09 137,64.09 137.15,63.94 137.15,63.53 137.26,63.43 137.26,62.97 137.15,62.87
3D3V_S0 on BOTTOM: 168.38,133.35 168.23,133.5 168.23,137.09 168.64,137.5 169.51,137.5 170.24,136.77 170.24,135.13 170.62,134.74 170.62,133.4 170.57,133.35 ; 2 cut-outs
3D3V_S0 on BOTTOM: 170.55,35.72 170.19,36.08 170.19,37.6 170.22,37.64 174.8,37.64 176.09,38.93 177.55,38.93 180.25,41.64 181.55,41.64 181.77,41.42 181.77,40.7 181.53,40.45 180.61,40.45 177.9,37.74 176.75,37.74 174.73,35.72
3D3V_S0 on L3: 46.02,29.95 46.02,27.89 45.79,27.67 44.5,27.67 44.19,27.97 33.93,27.97 33.57,28.33 33.57,29.62 34.03,30.08 45.89,30.08
3D3V_S0 on L3: 135.71,63.63 137.56,63.63 137.94,63.25 139.95,63.25 140.1,63.4 146.04,63.4 146.86,62.59 146.86,61.68 146.32,61.14 135.4,61.14 134.75,61.79 134.75,62.5 134.46,62.79 133.6,62.79 133.47,62.92 133.47,64.14 133.6,64.27 135.07,64.27
3D3V_S0 on L3: 168.32,135.34 168.32,133.69 169.74,132.27 173.78,132.27 173.98,132.46 173.98,133.73 173.54,134.16 171.29,134.16 170.37,135.09 170.37,136.06 169.08,137.34 168.42,137.34 166.86,138.9 166.86,140.61 158.18,149.29 157.09,149.29 156.63,148.83 156.63,147.99 164.96,139.66 164.96,138.69
3D3V_S0 on L3: 103.88,156.06 103.14,155.33 99.33,155.33 97.33,153.32 92.62,153.32 91.41,152.12 88.08,152.12 88.07,152.11 85.32,154.86 84.11,154.86 80.79,158.18 75.98,158.18 75.58,157.77 75.58,155.38 75.99,154.97 78.87,154.97 80.05,153.78 80.05,153.77 80.51,153.32 80.51,152.13 83.91,148.74 83.94,148.74 84.35,148.32 95.56,148.32 95.96,148.72 99.49,148.72 101.3,150.53 102.03,150.53 102.58,151.08 111.94,151.08 113.72,152.85 116.58,152.85 118.87,150.57 120.04,150.57 120.38,150.23 134.13,150.23 134.91,151.02 134.91,152.29 133.32,153.88 130.14,153.88 130.13,153.87 120.7,153.87 118.51,156.06
3D3V_S0 on L3: 170.21,90.36 170.21,89.05 170.65,88.62 186.16,88.62 189.99,84.79 192.21,84.79 192.73,85.31 192.73,87.07 189.38,90.43 181.7,90.43 181,91.13 170.99,91.13
3D3V_S0 on L3: 92.1,123.39 93.34,123.39 93.5,123.23 93.5,120.45 93.23,120.19 92.2,120.19 91.89,120.5 91.89,123.17 92.1,123.39
3D3V_S0 on L4: 138.57,100.04 139.74,100.04 140.45,99.33 140.45,97.43 141.95,95.93 141.95,94.07 141.71,93.83 139.94,93.83 139.3,94.47 139.3,97.24 138.32,98.22 138.32,99.79
3D3V_S0 on L4: 74.99,170.08 77.28,170.08 77.99,169.36 77.99,156.28 77.7,155.99 75.49,155.99 74.74,156.74 74.74,169.83
3D3V_S0 on L4: 16.61,69.25 16.61,58.35 22.02,52.94 22.02,37.95 21.31,37.24 21.31,36 22.3,35.01 22.3,33.2 22.63,32.87 31.85,32.87 34.18,30.54 35.55,30.54 36.6,29.49 36.6,28 36.22,27.61 34.11,27.61 33.01,28.71 31.64,28.71 29.2,31.14 21.48,31.14 20.44,32.19 20.44,33.76 19.55,34.65 19.55,37.98 20.39,38.82 20.39,51.8 14.63,57.56 14.63,67.49 13.63,68.49 13.63,70.63 13.88,70.88 14.98,70.88
3D3V_S0 on L4: 46.17,23.45 46.17,19.58 50.05,15.7 51.86,15.7 52.75,14.81 62.43,14.81 63.95,16.34 76.51,16.34 82.63,10.22 156.81,10.22 156.82,10.21 164.28,17.67 181.03,17.67 189.1,25.74 189.1,59.78 189.46,60.14 189.46,61.77 190.14,62.45 190.14,71.26 189.54,71.86 189.54,87.51 189.1,87.95 189.1,89.29 189.44,89.63 191.35,89.63 191.89,89.1 191.89,23.27 183.64,15.02 183.22,15.02 183.09,14.88 166.29,14.88 158.77,7.37 80.16,7.37 76.15,11.38 59.27,11.38 58.25,12.4 49.15,12.4 43.02,18.52 43.02,24.29 43.63,24.9 43.63,29.19 44.06,29.62 46.27,29.62 46.5,29.39 46.5,23.78
3D3V_S5 on TOP: 39.02,69.87 38.18,70.71 27.31,70.71 26.94,71.08 26.94,73.23 27.17,73.47 39.15,73.47 39.42,73.73 39.42,74.52 39.53,74.63 40.27,74.63 40.55,74.36 40.55,72.35 41.34,71.56 41.34,70.1 41.12,69.87 ; 1 cut-out
3D3V_S5 on TOP: 32.75,31.53 32.63,31.64 32.63,33.96 32.89,34.21 36.6,34.21 36.75,34.07 36.75,33.24 36.95,33.04 36.95,32.8 37.14,32.61 37.14,31.59 37.08,31.53 ; 1 cut-out
3D3V_S5 on TOP: 75.96,10.01 72.5,13.47 65.42,13.47 63.9,11.95 60.08,11.95 59.57,12.47 45.33,12.47 43.26,14.54 41.74,14.54 40.79,15.49 40.08,15.49 39.45,16.12 39.45,16.89 39.6,17.04 41.34,17.04 41.74,17.45 45.17,17.45 45.19,17.42 45.74,17.42 47,16.16 57.22,16.16 57.69,15.69 74.35,15.69 75.67,14.37 85.52,14.37 85.72,14.17 85.72,10.63 85.1,10.01 ; 2 cut-outs
3D3V_S5 on TOP: 91.23,101.05 90.82,101.47 90.82,104.34 91.18,104.7 91.18,108.06 92.12,109 92.12,111.99 92.89,112.76 94.24,112.76 94.32,112.68 94.32,103.45 91.92,101.05
3D3V_S5 on TOP: 154.99,56.38 154.49,56.88 154.49,57.21 156.2,58.93 156.2,63.04 155.51,63.73 155.51,66.26 155.93,66.68 155.93,68.29 156.7,69.05 157.82,69.05 157.93,69.16 157.93,70.02 157.71,70.24 157.71,70.76 157.79,70.84 158.62,70.84 159.05,71.26 159.05,71.47 157.21,73.31 157.21,73.47 158.09,74.35 161.78,70.66 161.78,67.64 162.35,67.07 162.35,59.21 161.97,58.83 158.4,58.83 157.56,57.99 157.56,57.61 156.33,56.38 ; 3 cut-outs
3D3V_S5 on TOP: 56.12,172.63 55.97,172.77 55.97,175.83 56.19,176.05 61.38,176.05 61.53,175.9 61.53,173.72 61.4,173.6 60.26,173.6 60.19,173.53 60.19,172.78 60.04,172.63 ; 4 cut-outs
3D3V_S5 on TOP: 97.63,138 97.91,138.28 98.99,138.28 99.63,138.92 99.63,140.77 100.5,141.64 100.5,144.99 101.84,146.33 101.84,146.87 102.5,147.52 104.88,147.52 105.05,147.35 105.62,147.35 105.95,147.02 105.95,146.36 103.07,143.47 103.07,139.38 99.56,135.88 99.56,134.14 98.88,133.46 97.78,133.46 97.63,133.61
3D3V_S5 on TOP: 157.29,127.94 157.03,128.21 156.29,128.21 155.47,129.03 154.75,129.03 153.56,130.22 153.56,134.49 148.7,139.34 146.71,139.34 146.37,139.68 146.37,141.1 146.58,141.31 147.76,141.31 148.57,140.5 153.68,140.5 157.86,136.32 157.86,135.93 158.12,135.67 158.12,130.59 159.14,129.58 159.12,129.56 159.12,127.98 159.08,127.94
3D3V_S5 on BOTTOM: outline of 90 points within 25.49,13.02 94.55,104.76 ; 2 cut-outs
3D3V_S5 on BOTTOM: 141.35,159.03 140.96,159.41 140.96,160.68 141.85,161.57 147.06,161.57 155.32,169.83 162,169.83 162.36,170.19 164.81,170.19 165.11,169.89 165.11,167.28 164.88,167.05 160.74,167.05 160.32,166.63 156.74,166.63 149.14,159.03
3D3V_S5 on BOTTOM: 169.98,105.92 168.5,107.41 168.5,112.74 168.64,112.88 170.27,112.88 170.43,112.72 170.43,111.21 170.82,110.82 170.82,109.17 171.02,108.97 172.01,108.97 172.09,109.05 172.09,111.24 171.92,111.41 171.92,112.5 172.03,112.6 172.55,112.6 172.68,112.47 172.68,111.59 172.64,111.55 172.64,111.31 172.38,111.05 172.38,109.04 172.43,108.99 175.43,108.99 175.68,108.74 175.68,106.23 175.38,105.92 ; 1 cut-out
3D3V_S5 on BOTTOM: 167.28,122.4 163.95,125.74 160.53,125.74 159.98,126.29 159.98,126.29 157.61,128.66 157.56,128.66 157.55,128.65 157.3,128.65 157.16,128.79 157.16,131.17 157.25,131.27 158.01,131.27 161.37,127.91 165.7,127.91 166.59,127.01 166.59,125.51 167,125.11 167.99,125.11 168.33,124.77 168.33,122.57 168.16,122.4 ; 1 cut-out
3D3V_S5 on BOTTOM: 154.04,135.16 153.81,135.4 153.81,136.71 150.94,139.58 148.82,139.58 148.01,138.77 147.35,138.77 146.5,139.63 146.5,141.3 146.6,141.4 147.13,141.4 148.14,142.41 149.13,142.41 150.14,141.4 152.86,141.4 154.75,139.52 154.75,135.26 154.64,135.16 ; 3 cut-outs
3D3V_S5 on BOTTOM: 169.15,17.6 168.95,17.79 168.95,18.71 169.08,18.83 171.22,18.83 171.38,18.67 171.38,17.86 171.13,17.6 ; 1 cut-out
3D3V_S5 on BOTTOM: 92.93,108.36 92.32,108.97 92.32,114.46 96.91,119.05 96.91,135.87 97.17,136.13 98.67,136.13 98.93,135.87 98.93,117.9 97.11,116.08 96.95,115.92 94,112.96 94,108.53 93.83,108.36
3D3V_S5 on BOTTOM: 154.11,128.7 154.02,128.78 154.02,129.88 154.13,129.98 154.81,129.98 155.22,129.57 155.22,129.28 154.64,128.7
3D3V_S5 on BOTTOM: 153.61,81.75 153.49,81.86 153.49,84.05 153.96,84.51 153.96,86.07 154.04,86.15 154.95,86.15 155,86.1 155,84.31 154.19,83.51 154.19,82.81 154.26,82.74 155.93,82.74 156.07,82.6 157.4,82.6 158.04,83.24 158.39,83.24 158.53,83.09 158.53,82.58 158.37,82.42 158.14,82.42 157.47,81.75
3D3V_S5 on BOTTOM: 81.72,5.82 81.38,6.16 81.38,10.27 82.37,11.26 138,11.26 138.19,11.08 138.19,6.38 137.63,5.82
3D3V_S5 on L3: 184.74,86.63 184.74,85.7 183.99,84.95 179.53,84.95 179.15,84.57 173.54,84.57 172.5,85.62 171.48,85.62 170.81,84.95 165.62,84.95 164.95,85.61 161.07,85.61 160.9,85.79 160.9,86.45 161.02,86.58 165.87,86.58 166.41,86.04 169.13,86.04 169.5,86.41 173.24,86.41 174.11,85.54 178.03,85.54 178.26,85.78 179.6,85.78 180.48,86.65 184.15,86.65 184.33,86.83 184.54,86.83
3D3V_S5 on L3: 70.99,11.51 72.77,9.72 74.44,9.72 75.09,9.07 84.61,9.07 84.85,9.31 84.85,11.16 84.47,11.55 76.5,11.55 72.28,15.77 65.21,15.77 63.05,13.61 59.87,13.61 59.58,13.32 59.58,11.87 59.94,11.51
3D3V_S5 on L3: 62.85,174.42 68.14,179.71 135.16,179.71 137.2,177.66 154.42,177.66 159.92,172.17 163.77,172.17 164.36,171.58 164.36,168.57 164.17,168.37 162.98,168.37 161.69,169.66 159.74,169.66 153.44,175.96 136.11,175.96 134.96,177.11 124.65,177.11 123.7,176.16 122.38,176.16 120.85,177.68 68.47,177.68 63.08,172.3 57.81,172.3 57.32,172.78 57.32,173.61 57.33,173.61 57.33,174.23 57.53,174.42
3D3V_S5 on L3: 36.15,31.6 31.97,31.6 26.72,36.85 26.72,38.3 26,39.02 26,44.83 26.6,45.43 26.6,53.51 27.09,54 27.09,58 27.28,58.2 33.21,58.2 34.41,57 34.41,55.63 33.69,54.91 31.37,54.91 28.48,52.02 28.48,48.7 28.49,48.68 28.49,39.84 33.43,34.9 35.89,34.9 36.72,34.07 36.72,32.16
3D3V_S5 on L4: 93.41,112.58 98,117.17 98,131.88 96.55,133.33 96.55,135.68 94.86,137.37 94.86,140.92 95.69,141.74 95.69,144.78 104.32,153.42 106.78,153.42 107.22,153.86 117.31,153.86 118.37,152.8 139.43,152.8 140.52,153.89 140.52,160.27 140.8,160.55 143.9,160.55 144.08,160.37 144.08,154.54 144.89,153.73 144.89,152.3 148.61,148.58 148.61,139.77 148.51,139.68 146.62,139.68 146.06,140.24 146.06,145.05 145.59,145.52 142.36,145.52 137.81,150.06 117.15,150.06 116.59,150.62 112.23,150.62 107.04,145.43 102.59,145.43 100.6,143.44 100.6,124.28 100.06,123.74 100.06,115.67 97.84,113.46 97.84,107.8 97.51,107.47 94.62,107.47 93.41,108.67
3D3V_S5 on L4: 156.99,54.78 156.73,54.51 156.73,38.03 157.22,37.54 157.22,32.75 158.36,31.6 158.36,30.08 157.22,28.94 157.22,11.05 156.41,10.24 82.63,10.24 82.44,10.43 82.44,13.34 82.82,13.72 105.26,13.72 106.18,12.79 116.51,12.79 117.43,13.72 145.7,13.72 147.33,15.35 150.31,15.35 152.01,17.05 152.01,22.51 152.52,23.02 152.52,56.12 155.24,58.83 156.39,58.83 156.56,58.65 156.56,56.51 156.99,56.08
3D3V_S5 on L4: 27.05,57.5 29.11,57.5 29.28,57.33 29.28,52.83 28.48,52.02 28.48,39.89 33.47,34.9 35.91,34.9 36.7,34.11 36.7,32.03 36.23,31.56 33.28,31.56 25.85,38.99 25.85,44.78 26.54,45.47 26.54,53.56 26.99,54.01 26.99,57.45
3D3V_S5 on L4: 171.36,123.82 171.36,115.52 170.77,114.93 170.77,113.37 172.57,111.57 172.57,110.98 171.51,109.92 168.07,109.92 167.78,110.2 167.78,115.36 168.52,116.1 168.52,121.56 167.34,122.74 167.34,125.05 167.69,125.39 170.88,125.39 171.21,125.07
3D3V_S5 on L4: 52.9,168.63 54.56,168.63 61.4,175.46 77.42,175.46 79.08,177.13 86.46,177.13 87.25,177.92 116.97,177.92 118.74,176.15 123.86,176.15 124.27,176.55 124.27,178.22 123.67,178.82 61.64,178.82 52.55,169.72 52.55,168.98
3D3V_S5_KBC on TOP: 183.5,83.08 183.09,83.49 183.09,84.38 183.14,84.43 184.48,84.43 184.57,84.34 184.57,83.96 184.44,83.83 184.05,83.83 183.9,83.69 183.9,83.24 183.74,83.08
3D3V_S5_KBC on TOP: 171.77,73.03 171.66,73.14 171.66,73.46 171.17,73.95 171.17,74.45 171.24,74.52 171.64,74.52 172.12,75.01 172.35,75.01 172.54,74.82 172.54,74.18 172.82,73.91 174.37,73.91 174.37,73.77 174.32,73.72 172.94,73.72 172.25,73.03 ; 2 cut-outs
3D3V_S5_KBC on BOTTOM: 192.78,62.54 192.52,62.8 192.52,67.55 193.6,68.63 193.6,69.74 193.82,69.96 193.82,82.26 192.93,83.15 192.93,88.1 193.87,89.04 193.87,90.89 194.18,91.2 195.04,91.2 195.21,91.37 195.21,93.9 193.72,95.38 193.72,100.51 193.84,100.63 193.84,104.35 194.08,104.59 194.08,109.04 194.99,109.95 194.99,112.86 195.45,113.32 195.45,116 195.58,116.12 196.45,116.12 196.58,116 196.58,115.76 196.78,115.56 196.78,109.48 195.65,108.35 195.65,101.41 195.16,100.92 195.16,97.16 196.23,96.09 196.23,94.99 196.81,94.4 196.81,90.89 195.32,89.4 195.32,87.52 195.14,87.34 195.14,83.69 194.69,83.24 194.69,77.62 195.29,77.02 195.29,70.96 195.49,70.75 195.49,67.38 193.94,65.83 193.94,62.65 193.83,62.54
3D3V_S5_KBC on BOTTOM: 184.62,68.8 184.41,69.01 184.28,69.01 184.14,69.15 184.14,69.86 184.51,70.23 185.83,70.23 185.97,70.09 185.97,68.89 185.88,68.8
3D3V_S5_PCH on TOP: 148.53,97.83 148.48,97.88 148.48,99.3 148.75,99.57 150.55,99.57 150.65,99.46 150.65,97.96 150.52,97.83
3D3V_S5_PCH on BOTTOM: 147.75,47.16 147.73,47.17 147.73,47.91 147.77,47.94 148.52,47.94 148.97,48.39 148.97,52 149.08,52.1 149.87,52.1 149.87,52.09 151.41,52.09 151.56,51.95 151.56,50.11 151.55,50.1 151.55,48.03 150.68,47.16 ; 1 cut-out
3D3V_S5_PCH on BOTTOM: 135.96,56.28 135.88,56.36 135.88,57.09 135.99,57.2 136.61,57.2 138.18,58.76 138.18,59.3 137.43,60.05 137.43,62.59 137.57,62.72 139.99,62.72 140.16,62.55 140.16,56.48 139.96,56.28 ; 2 cut-outs
3D3V_S5_PCH on BOTTOM: 158.51,71.1 158.4,71.21 158.4,78.88 158.72,79.21 160.42,79.21 160.75,78.88 160.75,78.36 160.61,78.23 159.71,78.23 159.47,77.99 159.47,75.23 160.32,74.38 161.68,74.38 161.78,74.48 161.78,77.38 161.84,77.44 162.16,77.44 162.23,77.37 162.23,74.07 161.91,73.76 160.11,73.76 159.81,74.06 159.42,74.06 159.28,73.92 159.28,71.52 158.85,71.1
3D3V_S5_PCH on BOTTOM: 148.3,80.8 148.15,80.95 148.15,81.54 148.28,81.67 148.28,84.37 148.07,84.58 146.61,84.58 146.16,84.13 144.82,84.13 144.66,84.29 144.66,86.64 144.69,86.66 150.74,86.66 151.13,87.05 152.68,87.05 152.91,86.82 152.91,86.35 153.07,86.18 153.09,86.18 153.2,86.07 153.2,83.17 153.19,83.16 153.19,82.27 152.65,81.72 150.22,81.72 149.3,80.8 ; 9 cut-outs
3D3V_S5_PCH on BOTTOM: 150.82,67.92 150.45,68.28 150.45,70 150.69,70.24 151.84,70.24 152.78,69.29 152.78,68.24 152.46,67.92
3D3V_S5_PCH on BOTTOM: 131.61,98.94 131.53,99.01 131.53,99.78 132.25,100.5 133.74,100.5 134.18,100.06 134.18,98.96 134.16,98.94
3D3V_S5_PCH on BOTTOM: 142.25,64.34 140.96,65.62 140.96,66.35 141.02,66.41 141.57,66.41 141.7,66.28 141.7,65.84 142.46,65.08 142.92,65.08 143.17,64.83 143.17,64.62 142.89,64.34
3D3V_S5_PCH on L3: 138.49,55.81 140.35,55.81 141.55,54.61 141.55,53.87 146.66,48.76 155.07,48.76 155.56,49.24 155.56,50.72 155.4,50.87 146.2,50.87 143.49,53.58 143.49,55.01 141.22,57.27 138.44,57.27 138.28,57.11 138.28,56.02
3D3V_S5_PCH on L4: 149.59,103.42 149.94,103.42 150.67,102.69 150.67,101.48 151.32,100.83 151.32,98.21 150.98,97.88 149.85,97.88 149.37,98.36 149.37,103.19
3D3V_S5_WLAN on TOP: 163.78,38.66 163.6,38.85 163.6,41.36 163.9,41.66 168.96,41.66 169.24,41.38 169.24,40.72 168.7,40.19 168.7,39.02 168.35,38.66 ; 5 cut-outs
3D3V_S5_WLAN on TOP: 163.04,61.57 162.66,61.96 162.66,64.63 163.22,65.2 168.35,65.2 168.77,64.78 168.77,62.71 167.63,61.57
3D3V_S5_WLAN on BOTTOM: 165.65,61.7 164.56,62.79 164.56,64.06 165.53,65.03 166.82,65.03 166.97,65.18 166.97,65.92 167.03,65.97 168.75,65.97 169.34,65.38 169.34,62.31 169.16,62.13 166.87,62.13 166.44,61.7 ; 3 cut-outs
