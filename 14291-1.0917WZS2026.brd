# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_VTT: length 6.9
  TOP w0.203: KBC24.95 172.83,68.61 172.55,68.33
  TOP w0.356: v1(169.1,66.46) 169.35,66.21 R2440.2
  TOP w0.508: 172.55,68.33 172.22,68 172.22,67.56 171.75,67.09 C2406.1 171.5,66.8 171.8,66.5 R2402.2 R2492.2 R2440.2
EC_WAKE#: length 59.6
  TOP w0.102: R1736.1 150.87,65.88 150.86,65.87 v2(150.86,65.85) ; v2(186.89,78.68) 186.41,79.16 186.41,80.98 186.88,81.44 KBC24.35
  L3 w0.102: v2(150.86,65.85) 151.07,66.07 154.18,66.07 154.71,65.54 158.07,65.54 158.37,65.24 161.22,65.24 162.05,66.08 162.05,67.43 162.36,67.74 163.3,67.74 163.66,67.37 166.57,67.37 167,66.94 168.64,66.94 169.66,65.93 173.02,65.93 173.59,66.5 177.85,66.5 177.97,66.39 188.08,66.39 v2(188.16,66.31)
  L4 w0.102: v2(186.89,78.68) 186.62,78.42 186.62,75.4 186.68,75.35 186.68,74.93 187.06,74.55 187.06,71.76 188.15,70.67 188.15,69.33 187.45,68.63 187.45,67.02 v2(188.16,66.31)
  BOTTOM w0.102: v2(186.89,78.68) 186.71,78.68 v1(186.32,78.29)
ECVBAT: length 26.4
  TOP w0.203: v2(185.4,63.47) 185.28,63.59 KBC24.122
  TOP w0.508: R2473.1 180.54,52.47 R2472.1 181.54,52.4 183.58,52.4 183.74,52.24 186.52,52.24 186.99,52.71 186.99,53.71 v1(187.36,54.08) 187.83,54.56 188.73,54.56 189.14,54.96 189.14,58.87 188.9,59.11 R2452.2
  L3 w0.508: v2(185.4,63.47) 186.23,63.47 187.36,62.34 v2(188.18,62.34)
  BOTTOM w0.508: C2428.1 187.25,62.8 187.72,62.33 188.18,62.33 v2(188.18,62.34)
EDP_AUX_CON_N: length 5
  TOP w0.127: v1(81.71,172.12) 80.78,173.05 C5533.2 79.89,173.05 R5529.1 79.7,173.24 79.51,173.24 79.27,173 79.27,172.6 78.8,172.13 78.8,171.97 78.65,171.82 LCD1.12
EDP_AUX_CON_P: length 3.5
  TOP w0.127: C5531.2 79.89,173.94 R5528.1 79.03,173.1 79.03,172.7 78.65,172.32 LCD1.11
EDP_AUX_CPU_N: length 113.9
  TOP w0.127: C5533.1 81.86,173.05 82.27,173.46 83.53,173.46 83.63,173.36 83.63,173.2 v2(83.54,173.1) ; v2(109.72,92.63) 109.72,92.63 109.29,93.05 v1(109.21,93.05)
  L4 w0.114: v2(83.54,173.1) 83.63,173.19 83.63,173.37 83.53,173.47 82.69,173.47 81.85,172.63 81.85,171.4 78.65,168.2 78.65,155.02 79.32,154.36 79.32,151.31 80.29,150.34 80.29,148.43 83.07,145.65 83.07,144.47 86.15,141.4 86.15,134.18 88.11,132.21 88.11,128.45 91.73,124.83 91.73,119.26 86.88,114.4 86.88,100.29 89.16,98.01 101.21,98.01 101.64,97.58 102.96,97.58 105.42,95.12 107.81,95.12 109.45,93.48 109.45,92.74 109.56,92.63 v2(109.72,92.63)
  BOTTOM w0.127: v2(109.72,92.63) 110.09,92.63 110.19,92.52 CPU1.E45
EDP_AUX_CPU_P: length 113.4
  TOP w0.127: v2(83.54,173.91) 83.33,173.7 82.15,173.7 81.91,173.94 C5531.1
  L4 w0.114: v2(109.76,91.99) 109.22,92.53 109.22,93.38 107.72,94.89 105.33,94.89 102.87,97.35 101.54,97.35 101.11,97.78 89.07,97.78 86.65,100.19 86.65,114.5 91.5,119.35 91.5,124.74 87.89,128.36 87.89,132.12 85.92,134.08 85.92,141.3 82.85,144.38 82.85,145.55 80.06,148.33 80.06,150.24 79.09,151.22 79.09,154.26 78.42,154.93 78.42,168.3 81.62,171.49 81.62,172.72 82.59,173.7 83.33,173.7 v2(83.54,173.91)
  BOTTOM w0.127: v2(109.76,91.99) 110.04,91.71 CPU1.F45
EDP_BKLT_CTRL: length 11.7
  BOTTOM w0.14: D5503.1 67.83,160.97 68.49,161.63 68.49,162.4 70.32,164.23 v1(72.79,164.23) R5530.2 74.43,164.25 R5524.2
EDP_COMP: length 3.1
  TOP w0.381: R801.2 108.44,90.92 108.44,91.59 107.97,92.06 v1(107.76,92.06) v2(107.04,92.06)
  BOTTOM w0.305: CPU1.E52 106.84,92.06 v2(107.04,92.06)
EDP_DISP_UTIL: length 7.6
  BOTTOM w0.102: TP801.1 108.34,99.67 107.97,99.3 107.97,96.3 106.83,95.15 106.83,94.72 106.54,94.43 CPU1.B52
EDP_HPD: length 218.1
  L3 w0.102: v2(130.06,88.64) 130.48,89.06 130.87,89.06 131.07,89.25 132.04,89.25 132.25,89.46 132.8,89.46 135.87,92.53 136.3,92.53 137.2,93.44 137.58,93.44 138.32,94.18 138.85,94.18 139.71,95.04 141.76,95.04 142,94.8 143.12,94.8 143.65,95.33 147.11,95.33 147.11,95.33 149.67,95.33 150.46,94.54 153.54,94.54 154.69,95.69 159.23,95.69 v2(159.41,95.52) ; v2(71.17,176.71) 75.14,176.71 77.66,174.18 81.06,174.18 81.43,174.55 81.43,174.75 82.26,175.58 84.71,175.58 85.61,174.68 88.32,174.68 90.29,176.65 101.14,176.65 101.45,176.96 113.75,176.96 115.34,175.37 118.85,175.37 119.2,175.72 119.55,175.72 120.38,174.89 126.86,174.89 127.79,175.82 128.23,175.82 129.22,174.83 135.33,174.83 135.52,174.65 149.09,174.65 152.21,171.53 154.69,171.53 157.98,168.23 v2(158.6,168.23)
  L4 w0.102: v2(158.6,168.23) 158.18,167.81 158.18,164.3 160.37,162.11 160.37,159.95 161.01,159.32 161.01,155.02 159.72,153.74 159.72,151.58 160.29,151.01 160.29,149.22 159.21,148.14 159.21,140.3 159.21,137.63 160.1,136.75 160.1,131.61 161.84,129.87 161.84,120.03 161.23,119.43 161.23,109.32 161.9,108.66 161.9,103.5 161.21,102.81 161.21,101.81 160.44,101.04 160.44,100.83 159.84,100.22 159.84,99.52 159.53,99.22 159.53,95.64 v2(159.41,95.52)
  BOTTOM w0.102: CPU1.L10 130.06,88.79 v2(130.06,88.64) ; RN5502.6 70.16,167.73 v1(71.15,168.73) 72.03,169.61 R5519.2 v2(71.17,176.71)
EDP_HPD_CONN: length 9.1
  TOP w0.102: v2(76.38,172.82) 76.88,173.32 LCD1.9
  BOTTOM w0.102: R5519.1 73.81,176.71 v1(74,176.52) 74.57,175.95 74.57,172.96 75.19,172.34 75.9,172.34 v2(76.38,172.82)
EDP_TX_CON_N0: length 2.5
  TOP w0.127: C5508.2 79.88,171.04 79.28,171.04 78.91,170.67 78.68,170.67 78.53,170.82 LCD1.14
EDP_TX_CON_N1: length 2.3
  TOP w0.127: LCD1.17 78.65,169.32 78.78,169.19 79.39,169.19 79.78,169.57 C5534.2
EDP_TX_CON_P0: length 2.5
  TOP w0.127: C5532.2 79.86,170.8 79.38,170.8 79.01,170.43 78.66,170.43 78.54,170.32 LCD1.15
EDP_TX_CON_P1: length 2.3
  TOP w0.127: C5537.2 79.78,168.69 79.51,168.95 78.78,168.95 78.65,168.82 LCD1.18
EDP_TX_CPU_N0: length 110.3
  TOP w0.127: C5508.1 83.17,171.35 v2(83.29,171.48)
  L4 w0.114: v2(109.9,99.08) 109.72,98.89 108.57,98.89 108.38,99.08 103.33,99.08 102.79,99.62 98.86,99.62 98.08,100.4 93.52,100.4 92.96,99.84 91.8,99.84 90.64,101 90.64,102.17 88.38,104.43 88.38,113.54 93.79,118.95 93.79,121.95 93.23,122.51 93.23,125.46 90.05,128.63 90.05,132.48 88.46,134.07 88.46,142.42 81.81,149.06 81.81,151.04 80.82,152.04 80.82,159.62 81.94,160.74 81.94,164.8 82.46,165.32 82.46,167.04 84.36,168.94 84.36,170.9 83.93,171.33 83.45,171.33 v2(83.29,171.48)
  BOTTOM w0.127: v2(109.9,99.08) 109.58,98.75 109.45,98.75 109.27,98.75 109.17,98.65 ; 109.17,98.65 109.04,98.52 109.04,94.28 108.76,93.99 CPU1.C47 ; 109.17,98.65 v1(109.04,98.79)
EDP_TX_CPU_N1: length 109.8
  TOP w0.127: v1(110.94,96.32) 110.87,96.39 v2(110.35,96.39) ; C5534.1 81.34,169.57 81.58,169.33 82.67,169.33 v2(82.87,169.53)
  L4 w0.114: v2(82.87,169.53) 82.66,169.32 82.03,169.32 80.85,168.14 80.85,164.93 79.5,163.57 79.36,163.44 79.36,155.45 79.84,154.97 79.84,151.58 80.84,150.58 80.84,148.66 86.71,142.78 86.71,134.35 88.8,132.26 88.8,128.5 92.25,125.05 92.25,119.04 87.4,114.19 87.4,100.88 89.66,98.62 102.27,98.62 102.79,98.1 106.46,98.1 108.17,96.39 v2(110.35,96.39)
  BOTTOM w0.089: 109.88,96.13 109.88,96.11 109.85,96.08 109.85,95.81 110.36,95.31 110.36,95.01 110.3,94.84 110.3,94.67 110.34,94.54 110.34,94.36 110.33,94.34 110.21,93.94 110.21,93.85 110.15,93.63 109.98,93.46 109.78,93.46 CPU1.D46
  BOTTOM w0.127: v2(110.35,96.39) 110.19,96.55 109.96,96.55 109.88,96.46 109.88,96.13
EDP_TX_CPU_P0: length 110.2
  TOP w0.127: C5532.1 81.5,170.46 82.15,171.11 82.91,171.11 v2(83.27,170.75)
  L4 w0.114: v2(83.27,170.75) 83.27,170.86 83.51,171.1 83.84,171.1 84.13,170.8 84.13,169.04 82.23,167.13 82.23,165.42 81.71,164.89 81.71,160.84 80.59,159.72 80.59,151.94 81.59,150.95 81.59,148.97 88.23,142.32 88.23,133.98 89.82,132.38 89.82,128.54 91.08,127.29 93,125.36 93,122.41 93.56,121.85 93.56,119.04 88.15,113.63 88.15,104.33 90.41,102.07 90.41,100.91 91.71,99.61 93.06,99.61 93.61,100.17 97.99,100.17 98.76,99.39 102.7,99.39 103.23,98.85 108.29,98.85 108.48,98.66 109.74,98.66 109.9,98.5 v2(109.9,98.19)
  BOTTOM w0.127: v2(109.9,98.19) 109.58,98.51 109.45,98.51 109.37,98.51 109.28,98.42 109.28,97.13 ; 109.28,97.13 v1(109.44,97.13) ; 109.28,97.13 109.28,94.15 CPU1.C46
EDP_TX_CPU_P1: length 109.7
  TOP w0.127: v2(110.35,97.02) 109.94,97.02 v1(109.8,96.88) ; v2(82.87,168.68) 82.99,168.8 82.99,168.94 82.85,169.09 81.31,169.09 81.08,168.86 C5537.1
  L4 w0.114: v2(110.35,97.02) 109.94,96.62 108.27,96.62 106.55,98.33 102.89,98.33 102.37,98.85 89.75,98.85 87.63,100.97 87.63,114.09 92.48,118.95 92.48,119.13 92.48,119.76 92.48,125.14 89.03,128.6 89.03,132.36 86.94,134.45 86.94,142.88 81.07,148.75 81.07,150.68 80.07,151.67 80.07,155.07 79.59,155.54 79.59,163.34 81.08,164.83 81.08,168.05 82.13,169.1 82.86,169.1 83.02,168.94 83.02,168.77 82.93,168.68 v2(82.87,168.68)
  BOTTOM w0.089: CPU1.C45 110.04,94.06 110.1,94.16 110.15,94.36 110.15,94.51 110.11,94.64 110.11,94.87 110.17,95.04 110.17,95.23 109.66,95.74 109.66,96.08 109.64,96.11 109.64,96.13
  BOTTOM w0.127: 109.64,96.13 109.64,96.56 109.86,96.79 110.25,96.79 110.35,96.88 v2(110.35,97.02)
EDP_VDD_EN: length 250.2
  TOP w0.127: v2(152.08,161) 152.05,161 v1(150.99,162.07) 150.26,162.8 150.26,173.8 151.02,174.56 v2(151.02,174.93)
  L3 w0.127: v2(163.66,144.5) 162.51,145.65 162.51,146 157.68,150.83 157.68,154.72 154.15,158.25 154.15,158.93 v2(152.08,161) ; v2(146.83,88.15) 147.54,88.15 148.41,87.28 151.32,87.28 152.45,88.41 153.5,88.41 153.64,88.26 156.29,88.26 157.21,89.18 158.84,89.18 159.56,89.18 160.11,88.64 163.26,88.64 163.46,88.83 167.01,88.83 168.87,90.7 v2(168.87,90.79)
  L4 w0.127: v2(163.66,144.5) 164.34,143.82 164.34,139.09 166.43,137.01 166.43,135.69 167.01,135.1 167.85,134.26 167.85,130.5 171.94,126.41 171.94,126.41 172.48,125.88 172.48,116.7 172.13,116.35 172.13,115.62 171.25,114.75 171.25,113.67 173.19,111.73 173.19,111.05 171.55,109.42 171.55,103.24 170.67,102.35 170.67,97.73 169.46,96.52 169.46,95.52 168.49,94.55 168.49,93.67 168.61,93.56 168.61,92.65 168.49,92.53 168.49,92.25 168.49,92.25 168.49,91.14 168.83,90.79 v2(168.87,90.79) ; v2(90.57,147.22) 90.52,147.22 89.45,148.29 89.45,149.29 86.57,152.18 86.57,160.63 89.44,163.5 89.44,173.44 86.82,176.06 86.82,176.81 87.62,177.6 95.78,177.6 95.86,177.68 116.48,177.68 118.41,175.75 119.61,175.75 119.94,175.42 127.02,175.42 128.94,177.34 138.64,177.34 140.16,175.82 150.15,175.82 151.02,174.95 v2(151.02,174.93) ; v2(146.83,88.15) 146.83,88.22 146.55,88.51 145.82,88.51 145.58,88.26 145.58,88.03 144.4,86.85 139.61,86.85 139.47,86.99 138.24,86.99 137.25,86 136.33,86 134.93,84.6 132.76,84.6 132.27,85.08 129.31,85.08 v2(128.88,85.51)
  BOTTOM w0.127: D5502.1 85.99,147.65 90.06,147.65 90.5,147.22 v2(90.57,147.22) ; CPU1.U13 128.43,85.96 v2(128.88,85.51)
EMMC_RCOMP: length 3.7
  BOTTOM w0.203: R1502.1 v1(137.61,76.76) 137.09,76.76 136.51,76.18 135.93,76.18 135.79,76.33 CPU1.AT1
EXT_PWR_GATE#: length 18.9
  TOP w0.127: v2(130.78,79.18) 131.16,79.56 131.91,79.56 131.96,79.51 132.31,79.51 132.37,79.56 132.81,79.56 133.61,78.77 133.61,78.45 v1(134.03,78.03) 135.94,76.11 137.12,76.11 138.29,74.94 142.86,74.94 143.38,75.45 143.38,77.5 R1731.2
  BOTTOM w0.127: CPU1.AM10 130.34,78.82 130.67,79.15 130.74,79.15 130.75,79.16 130.77,79.16 v2(130.78,79.18)
FALL_INT2: length 7.1
  BOTTOM w0.152: R6703.2 177.58,93.7 v1(177.58,92.69) 177.58,92.69 177.58,91.74 177.35,91.51 177.35,90.94 177.03,90.62 Q6701.2 176.05,90.62 175.81,90.38 175.81,90.09 175.94,89.97 Q6701.3
FAN1_DAC_1: length 162.3
  TOP w0.203: v2(187.08,77.81) 187.98,77.81 188.38,77.41 KBC24.24
  TOP w0.254: v2(146.03,144.8) 147.33,144.8 149.44,142.69 v1(154.53,142.69) v2(167.29,142.69)
  L4 w0.254: v2(99.31,138.46) 99.31,138.79 100.73,140.21 100.73,142.93 102.94,145.14 107.33,145.14 112.91,150.72 114.74,150.72 115.15,151.13 115.93,151.13 117.1,149.95 124.79,149.95 125.44,149.31 134.28,149.31 134.92,149.95 135.77,149.95 140.92,144.8 v2(146.03,144.8) ; v2(187.08,77.81) 187.39,78.11 187.39,78.46 187.4,78.47 187.4,78.89 187.39,78.9 187.39,79.78 187.02,80.15 186.93,80.15 186.59,80.48 186.59,82.71 186.66,82.77 186.66,85.74 185.72,86.68 184.92,86.68 184.63,86.96 183.55,86.96 183.1,87.41 183.1,90.26 183.22,90.38 183.22,97.73 183.41,97.92 183.41,99.06 182.6,99.86 182.6,111.48 181.74,112.34 181.74,117.79 181.1,118.44 181.1,119.12 177.53,122.69 177.53,124.11 172.41,129.23 172.41,131.21 170.44,133.18 170.44,137.89 167.97,140.37 167.97,141.31 167.55,141.73 167.55,142.44 v2(167.29,142.69)
  BOTTOM w0.254: FAN261.4 96.01,136.35 97,137.34 98.19,137.34 v2(99.31,138.46)
FAN1_TACH: length 5.1
  TOP w0.203: v2(185.49,83.45) 185.37,83.45 184.88,82.96 KBC24.40
  TOP w0.254: v2(185.49,83.45) 185.5,83.46 185.77,83.46 R2430.1
  BOTTOM w0.254: v2(185.49,83.45) 185.49,83.05 185.64,82.9 v1(186.04,82.9) 186.58,83.43 D2403.A
FAN_TACH1: length 203.7
  TOP w0.254: R2606.1 EC2602.1 93.62,146.4 v2(93.47,146.56) ; v2(152.72,162.02) 152.72,162.4 v1(151.82,163.31) 150.96,164.16 150.96,172.22 v2(151.76,173.01)
  L3 w0.254: v2(152.72,162.02) 152.72,162.02 154.82,159.92 154.82,158.53 158.62,154.73 158.62,150.85 161.95,147.51 163.54,147.51 165.35,145.7 v2(167.95,145.7)
  L4 w0.254: v2(93.47,146.56) 93.47,147.05 92.22,148.29 92.22,149.03 89.15,152.1 89.15,160.57 91.18,162.6 91.18,172.37 96.05,177.24 116.29,177.24 118.75,174.78 119.59,174.78 119.72,174.92 121.85,174.92 123.34,173.42 124.89,173.42 126.08,174.61 137.12,174.61 138.71,173.01 v2(151.76,173.01) ; v2(167.95,145.7) 167.95,145.09 168.28,144.76 168.28,142.04 168.7,141.62 168.7,140.68 171.18,138.2 171.18,136.14 171.92,135.4 171.92,134.74 171.85,134.68 171.85,132.81 171.92,132.75 173.15,131.52 173.15,129.54 176.5,126.18 176.67,126.18 179.49,123.36 179.49,121.81 181.83,119.46 181.83,118.74 182.48,118.1 182.48,112.64 183.34,111.78 183.34,100.17 184.15,99.36 184.15,97.61 183.96,97.42 183.96,90.67 185.59,89.04 v2(185.59,88.07)
  BOTTOM w0.254: D2403.K 185.99,87.08 185.99,87.47 185.99,87.68 185.59,88.09 v2(185.59,88.07)
FAN_TACH1_C: length 5.4
  TOP w0.254: R2606.2 98.8,144.13 AFTP2802.1 96.74,142.06 FAN1.2
FAN_VCC1: length 2
  BOTTOM w0.635: v3(95.93,137.85) 95.7,137.62 FAN261.3
FB_CAL_PD_VDDQ: length 0.6
  BOTTOM w0.356: GPU1.D22 201.4,149.62 201.43,149.62 v2(201.47,149.66)
  vias: v1(202.22,149.6)
FB_CAL_PU_GND: length 0.6
  BOTTOM w0.305: GPU1.C24 201.9,150.97 202.24,151.31 202.24,151.34 v2(202.24,151.35)
  vias: v1(203.14,151.77)
FB_CAL_TERM_GND: length 2.7
  BOTTOM w0.127: GPU1.B25 203.03,152.15 203.67,152.15 204.16,152.65 204.16,152.85
  BOTTOM w0.508: v2(204.16,153.51) 204.16,152.85
  vias: v1(204.89,153.36)
FB_CLAM: length 4.8
  TOP w0.254: R7518.1 199.22,133.96 v2(199.74,133.96) 199.9,133.8 v1(200.43,133.8) 200.75,133.8 200.97,134.02 200.97,134.28 201.14,134.45 201.14,135.15 R7519.1
  BOTTOM w0.254: v2(199.74,133.96) 199.35,133.57 GPU1.F3
FB_VREF: length 1.2
  TOP w0.102: TP7503.1 200.59,149.72 v2(200.58,149.72)
  BOTTOM w0.102: v2(200.58,149.72) 200.97,150.12 GPU1.D23
FBA_CLK0N: length 56.8
  TOP w0.152: VRAM3.K7 200.55,166.92 200.89,166.92 200.99,167.03 200.99,167.23 201.51,167.74 201.51,168.36 v2(201.39,168.47) ; v2(200.7,174.56) 200.92,174.78 200.92,175.34 R7810.1
  L4 w0.127: v2(201.46,151.35) 201.87,150.94 201.87,150.52 202.26,150.13 202.26,148.12 202.12,147.99 202,147.86 201.42,147.86 201.27,147.71 201.27,147.46 201.42,147.3 202,147.3 202.26,147.04 202.26,145.32 202.41,145.17 202.72,145.17 202.89,145.34 202.89,150.57 203.56,151.24 205.81,151.24 206.94,152.36 206.94,152.7 207.33,153.09 207.33,154.97 207.79,155.42 207.79,158.46 207.12,159.12 205.07,159.12 202.62,161.58 202.11,161.58 201.94,161.4 201.52,161.4 201.22,161.7 201.22,162.12 201.51,162.41 201.51,162.59 201.29,162.8 201.11,162.8 200.74,162.43 200.34,162.43 200.06,162.71 200.06,163.11 200.27,163.33 200.27,167.05 200.61,167.39 201.31,167.39 201.65,167.73 201.65,168.37 201.55,168.47 v2(201.39,168.47) 201.39,168.74 201.06,169.07 201.06,170.26 200.3,171.02 200.3,171.62 201.09,172.41 201.09,174.17 v2(200.7,174.56)
  BOTTOM w0.152: v2(201.39,168.47) 201.39,168.73 201.06,169.07 201.06,169.49 200.82,169.72 200.82,170.04 200.74,170.12 VRAM1.K7 ; GPU1.D25 201.05,151.76 v2(201.46,151.35) ; v2(200.7,174.56) 200.39,174.25 v1(200.23,174.25)
FBA_CLK0P: length 56.6
  TOP w0.152: VRAM3.J7 201.35,167.2 201.82,167.67 201.82,168.29 201.99,168.46 v2(201.99,168.71) ; v2(201.46,174.56) 201.18,174.83 201.18,175.38 201.48,175.67 R7810.2
  L4 w0.127: v2(201.45,150.56) 201.5,150.56 201.57,150.5 201.64,150.42 202.03,150.04 202.03,148.22 201.9,148.09 201.32,148.09 201.04,147.8 201.04,147.36 201.32,147.07 201.9,147.07 202.03,146.95 202.03,145.23 202.32,144.94 202.82,144.94 203.12,145.24 203.12,150.47 203.65,151.01 205.91,151.01 207.17,152.27 207.17,152.6 207.56,153 207.56,154.87 208.02,155.33 208.02,158.55 207.22,159.35 205.17,159.35 202.71,161.8 202.02,161.8 201.85,161.63 201.61,161.63 201.45,161.8 201.45,162.03 201.73,162.31 201.73,162.68 201.38,163.03 201.02,163.03 200.64,162.66 200.43,162.66 200.29,162.81 200.29,163.02 200.5,163.23 200.5,166.96 200.71,167.16 201.41,167.16 201.87,167.63 201.87,168.6 v2(201.99,168.71) 201.75,168.71 201.29,169.17 201.29,170.35 200.53,171.12 200.53,171.53 201.32,172.32 201.32,174.42 v2(201.46,174.56)
  BOTTOM w0.152: v2(201.99,168.71) 201.79,168.71 201.32,169.18 201.32,169.6 201.09,169.83 201.09,169.99 201.22,170.12 VRAM1.J7 ; GPU1.D24 201.45,150.57 v2(201.45,150.56) ; v1(201.94,174.28) 201.74,174.28 v2(201.46,174.56)
FBA_CLK1N: length 60.7
  TOP w0.152: v2(179.73,168.86) 179.68,168.81 179.57,168.81 179.5,168.89 179.5,169.12 179.77,169.39 179.77,169.76 179.66,169.87 179.66,170.07 179.74,170.15 179.92,170.15 VRAM4.K7 ; R7914.1 180.53,175.43 180.07,174.97 180.07,174.07 180.06,174.05 v2(180.18,173.93)
  L4 w0.127: 179.71,168.84 179.5,168.84 179.36,168.98 179.36,169.37 180.22,170.23 180.22,172.17 180.22,172.36 179.97,172.61 179.97,173.72 v2(180.18,173.93) ; 179.71,168.84 179.57,168.7 179.57,167.29 181.02,165.84 181.02,163.88 180.54,163.39 180.54,163.38 176.91,159.75 176.91,157.71 177.13,157.48 177.39,157.48 177.59,157.69 177.59,159.34 177.9,159.64 178.33,159.64 178.63,159.34 178.63,157.64 178.84,157.43 179.06,157.43 179.27,157.64 179.27,159.3 179.57,159.59 179.99,159.59 180.28,159.3 180.28,157.91 180.76,157.43 186.07,157.43 190.25,153.25 190.25,151.14 190.46,150.93 190.91,150.93 191.17,151.19 191.17,153.31 191.47,153.61 191.89,153.61 192.19,153.31 192.19,152.94 192.31,152.81 193.52,152.81 193.85,152.48 193.85,149.86 v2(193.95,149.76) ; 179.71,168.84 v2(179.73,168.86)
  BOTTOM w0.152: v2(193.95,149.76) 194.38,149.33 GPU1.M22 ; v2(180.18,173.93) v1(180.18,174.49) ; VRAM2.K7 179.86,167.01 179.86,167.59 179.53,167.92 179.53,168.42 179.71,168.6 179.71,168.84 v2(179.73,168.86)
FBA_CLK1P: length 60.8
  TOP w0.152: v2(179.13,168.6) 179.14,168.6 179.23,168.69 179.23,169.23 179.51,169.5 179.51,169.65 179.4,169.76 179.4,170.06 179.34,170.12 VRAM4.J7 ; R7914.2 179.64,175.37 179.8,175.2 179.8,174.18 179.57,173.94 v2(179.48,173.94)
  L4 w0.127: v2(179.48,173.94) 179.74,173.68 179.74,172.51 179.99,172.26 179.99,170.32 179.13,169.47 v2(179.13,168.6) 179.34,168.39 179.34,167.2 180.8,165.74 180.8,163.98 180.31,163.49 180.31,163.48 176.68,159.85 176.68,157.61 177.03,157.26 177.48,157.26 177.82,157.59 177.82,159.24 177.99,159.41 178.23,159.41 178.4,159.24 178.4,157.54 178.74,157.21 179.16,157.21 179.5,157.54 179.5,159.2 179.66,159.36 179.89,159.36 180.06,159.2 180.06,157.81 180.67,157.21 185.97,157.21 190.02,153.16 190.02,151.04 190.36,150.7 191,150.7 191.4,151.1 191.4,153.21 191.56,153.38 191.79,153.38 191.96,153.21 191.96,152.84 192.22,152.58 193.43,152.58 193.62,152.38 193.62,150.06 193.33,149.77 v2(193.19,149.77)
  BOTTOM w0.152: v2(179.48,173.94) 179.25,173.94 v1(178.91,174.29) ; GPU1.N22 193.19,149.73 v2(193.19,149.77) ; v2(179.13,168.6) 179.26,168.47 179.26,167.81 179.59,167.48 179.59,167.1 179.41,166.92 VRAM2.J7
FBA_CMD0: length 49.7
  TOP w0.178: v1(202.23,155.65) R7512.1 202.23,154.42 v2(201.77,153.96) ; v2(198.99,168.27) 199.47,168.74 199.49,168.74 199.83,169.08 199.83,169.65 200.12,169.95 200.12,170.27 199.75,170.64 VRAM3.L2
  L4 w0.165: v2(201.77,153.96) 201.77,153.31 201.91,153.18 202.33,153.18 202.47,153.33 202.47,153.77 203.18,154.48 203.18,156.85 203.38,157.04 203.65,157.04 203.84,156.85 203.84,154.09 203.97,153.97 204.38,153.97 204.51,154.09 204.51,157.2 204,157.71 203.08,157.71 199.14,161.65 199.14,163.37 199.43,163.66 199.43,166.45 199.27,166.61 198.62,166.61 198.46,166.78 198.46,167.11 198.62,167.27 199.27,167.27 199.43,167.44 199.43,167.83 199.44,167.83 199.44,168 199.75,168.31 199.75,169.01 199.8,169.07 199.8,169.81 199.04,170.57 199.04,171.48 198.5,172.02 197.53,172.02 197.32,171.81 197.32,171.49 197.53,171.29 198.19,171.29 198.38,171.1 198.38,170.84 198.19,170.65 197.47,170.65 197.29,170.48 197.29,170.22 197.47,170.05 198.61,170.05 198.92,169.73 198.92,168.86 198.79,168.72 198.79,168.47 v2(198.99,168.27)
  BOTTOM w0.178: VRAM1.L2 199.75,165.91 199.62,165.79 199.41,165.79 199.32,165.88 199.32,167.27 199.09,167.5 199.09,168.17 v2(198.99,168.27) ; v2(201.77,153.96) 201.85,153.88 GPU1.C27
FBA_CMD1: length 1.2
  TOP w0.178: v2(201.43,152.96) 201.14,153.25 TP7501.1
  BOTTOM w0.178: v2(201.43,152.96) 201.82,152.57 GPU1.C26
FBA_CMD2: length 51.4
  TOP w0.178: VRAM3.K1 200.55,171.53 200.18,171.16 200.18,170.7 200.39,170.49 200.84,170.49 200.97,170.36 200.97,169.45 200.83,169.31 v2(200.62,169.31) ; v1(200.63,151.19) 200.63,150.63 v2(200.63,150.63)
  L4 w0.165: v2(200.62,169.31) 200.79,169.47 200.79,170.18 200.05,170.92 200.05,171.52 200.05,171.72 200.66,172.33 200.66,172.61 200.46,172.82 200.09,172.82 199.93,172.98 199.93,173.31 200.09,173.48 200.65,173.48 200.84,173.67 200.84,173.94 200.65,174.13 199.6,174.13 199.3,173.83 199.3,170.68 200.07,169.92 200.07,168.96 200.01,168.9 200.01,168.47 200.38,168.1 200.38,167.6 200.03,167.24 200.03,163.43 199.68,163.08 199.68,162.44 201.29,160.82 202.46,160.82 204.72,158.56 206.43,158.56 206.89,158.1 206.89,153.44 206.69,153.24 206.69,152.46 206.02,151.79 201.26,151.79 201.01,151.55 201.01,151.02 200.63,150.63 v2(200.63,150.63)
  BOTTOM w0.178: v2(200.62,169.31) 200.54,169.31 200.15,168.92 200.15,168.91 200,168.77 200,168.32 200.32,168.01 200.32,167.64 200.17,167.49 200.17,165.7 VRAM1.K1 ; GPU1.E24 200.28,150.97 v2(200.63,150.63)
FBA_CMD3: length 53
  TOP w0.178: VRAM3.K9 200.55,165.48 200.49,165.54 200.49,165.6 200.15,165.94 200.15,167.55 v2(199.88,167.82) ; v1(199.75,152.09) v2(199.75,151.34) 199.08,151.34 R7510.1
  L4 w0.165: v2(199.75,151.34) 200.14,150.96 200.32,150.96 200.65,151.28 200.65,151.48 200.11,152.02 200.11,152.22 200.46,152.58 200.49,152.58 200.65,152.73 201.04,152.73 201.31,152.46 201.31,152.27 201.47,152.11 201.8,152.11 201.97,152.27 201.97,152.7 202.16,152.89 202.44,152.89 202.63,152.7 202.63,152.27 202.79,152.11 203.43,152.11 203.62,152.3 203.62,152.87 203.78,153.03 204.12,153.03 204.28,152.87 204.28,152.31 204.48,152.1 205.76,152.1 206.41,152.74 206.41,158.05 206.27,158.18 205.88,158.18 205.75,158.06 205.75,153.05 205.55,152.85 205.28,152.85 205.09,153.05 205.09,157.67 204.1,158.65 203.87,158.65 203.37,158.15 203.17,158.15 202.88,158.44 202.88,158.6 203.4,159.12 203.4,159.36 202.3,160.45 201.45,160.45 201.1,160.45 199.41,162.14 199.41,163.23 199.73,163.55 199.73,166.53 199.47,166.79 199.47,167.09 199.73,167.36 199.73,167.68 v2(199.88,167.82)
  BOTTOM w0.178: v2(199.75,151.34) 199.37,150.97 GPU1.F24 ; VRAM1.K9 200.42,171.59 200.42,171.39 200.14,171.11 200.14,169.4 199.73,168.98 199.73,167.98 v2(199.88,167.82)
FBA_CMD4: length 55.7
  TOP w0.178: v2(194.6,168.01) 195.43,167.18 195.49,167.18 VRAM3.T7 ; v1(191.54,172.11) 191.47,172.05 v2(191.47,171.43) ; v2(186.29,167.99) 186.47,168.17 186.47,168.76 185.53,169.71 185.16,169.71 VRAM4.T7
  L3 w0.127: v2(194.6,168.01) 194.73,168.15 194.73,168.96 194.57,169.12 193.79,169.12 193.59,169.32 193.59,169.59 193.79,169.79 194.61,169.79 194.81,169.99 194.81,170.17 193.26,171.72 192.98,171.72 192.81,171.56 192.81,171.38 192.62,171.19 192.35,171.19 192.15,171.38 192.15,171.56 191.99,171.72 191.68,171.72 191.47,171.52 v2(191.47,171.43) 191.42,171.37 190.82,171.37 190.69,171.24 190.3,171.24 190.02,171.52 187.87,171.52 187.61,171.26 187.61,170.67 187.15,170.21 186.23,170.21 185.97,169.95 185.97,169.59 186.47,169.09 186.47,168.17 v2(186.29,167.99)
  L4 w0.165: v2(191.47,171.43) 191.47,172.2 192.24,172.97 195.02,172.97 195.97,172.01 195.97,169.31 195.63,168.97 195.63,168.61 195.96,168.28 195.96,167.9 196.88,166.98 196.88,163.76 198.03,162.61 198.03,161.2 201.95,157.28 201.95,155.84 v2(201.3,155.19)
  BOTTOM w0.178: GPU1.D27 201.3,153.62 v2(201.3,155.19) ; v2(194.6,168.01) 194.6,168.31 194.73,168.44 194.73,168.96 195.75,169.98 VRAM1.T7 ; VRAM2.T7 184.79,166.88 185.28,166.88 185.93,167.53 185.93,167.63 v2(186.29,167.99)
FBA_CMD5: length 64
  TOP w0.178: v2(193.39,170.61) 193.39,170.81 193.54,170.97 193.77,170.97 193.92,170.81 193.92,169.83 194.07,169.69 194.39,169.69 194.64,169.94 194.64,170.92 194.73,171.01 195.66,171.01 VRAM3.T2 ; VRAM4.T2 187.04,166.12 187.57,166.65 188.35,166.65 188.87,167.17 188.87,167.95 189.16,168.24 189.16,168.72 188.67,169.2 188.67,170.17 v2(188.43,170.41)
  L3 w0.127: v2(188.43,170.41) 190.01,170.41 190.24,170.17 v2(191.31,170.17) 191.26,170.11 191.26,169.83 191.46,169.63 192.25,169.63 193.24,170.61 v2(193.39,170.61)
  L4 w0.165: v2(191.31,170.17) 191.66,170.17 192.27,169.56 192.62,169.56 192.79,169.72 192.79,170.09 192.17,170.7 192.17,170.94 192.47,171.23 192.47,171.7 192.67,171.9 193.2,171.9 193.4,171.7 193.4,171.43 194.04,170.79 194.04,170.56 193.67,170.19 193.67,169.92 193.93,169.66 194.08,169.66 194.67,170.26 194.96,170.26 195.19,170.03 195.19,169.74 194.51,169.06 194,169.06 193.75,168.82 193.75,168.51 194.14,168.12 194.14,167.66 194.93,166.87 195.16,166.87 195.26,166.98 195.5,166.98 195.73,166.74 195.73,166.51 195.63,166.41 195.63,166.17 195.86,165.94 195.86,164.99 195.74,164.86 195.74,164.09 197.21,162.62 197.21,160.98 200.87,157.32 200.87,156.37 v2(201.14,156.09)
  BOTTOM w0.178: GPU1.D26 200.67,152.95 200.67,153.55 200.85,153.73 200.85,155.79 v2(201.14,156.09) ; VRAM1.T2 194.66,166.12 194.37,165.83 193.41,165.83 192.74,166.5 192.74,166.75 v1(192.48,167.01) 192.36,167.13 192.36,168.26 192.67,168.56 192.67,170.05 193.04,170.42 193.22,170.42 193.31,170.52 193.31,170.53 v2(193.39,170.61) ; v2(188.43,170.41) 187.93,170.41 187.56,170.03 187.2,170.03 186.88,170.36 186.88,171.05 186.65,171.27 186.01,171.27 185.78,171.04 184.87,171.04 VRAM2.T2
FBA_CMD6: length 58
  TOP w0.178: VRAM4.R3 184.14,166.92 184.56,167.34 185.14,167.34 185.23,167.25 185.6,167.25 185.86,167.51 185.86,167.88 185.83,167.9 185.83,168.29 186.03,168.48 v2(186.03,168.58) ; v1(190.22,172.24) 190.49,171.97 v2(190.49,171.73) ; VRAM3.R3 196.17,169.74 195.84,169.74 195.17,169.07 v2(195.17,168.72)
  L3 w0.127: v2(195.17,168.72) 195.36,168.92 195.36,169.99 195.32,170.03 193.35,172.01 193.01,172.01 192.92,172.1 190.86,172.1 v2(190.49,171.73) 190.49,171.73 190.32,171.89 187.54,171.89 185.68,170.03 185.68,169.5 186.03,169.15 v2(186.03,168.58)
  L4 w0.165: v2(190.49,171.73) 191.1,172.35 191.1,172.35 192.09,173.34 192.1,173.34 195.02,173.34 196.24,172.12 196.24,172.11 196.34,172.01 196.34,169.62 196.52,169.44 196.52,168.6 196.86,168.26 196.86,167.71 197.4,167.18 197.4,165.36 197.79,164.96 197.79,164.29 197.88,164.19 197.88,163.21 198.41,162.68 198.41,161.34 202.35,157.4 202.35,155.62 200.76,154.03 v2(200.4,154.03)
  BOTTOM w0.178: v2(195.17,168.72) 195.04,168.59 195.04,167.89 195.31,167.62 195.75,167.62 196.45,166.92 VRAM1.R3 ; GPU1.F25 199.74,152.16 199.74,153.49 200.28,154.03 v2(200.4,154.03) ; v2(186.03,168.58) 185.83,168.58 185.63,168.79 185.63,169.57 185.45,169.75 184.32,169.75 VRAM2.R3
FBA_CMD7: length 74.2
  TOP w0.178: v2(188.31,171.04) 188.56,171.04 189.13,170.47 189.13,169.48 189.6,169.01 189.6,168.91 189.6,168.9 189.6,168.05 189.6,168.05 189.6,167.96 189.36,167.73 189.36,167.03 188.41,166.07 187.39,166.07 187.16,165.84 187.09,165.77 184.96,165.77 184.91,165.73 184.59,165.73 184.36,165.96 184.36,165.96 184.2,166.12 VRAM4.R2 ; VRAM3.R2 196.19,170.92 196.12,170.99 196.12,171.08 195.91,171.29 194.76,171.29 194.69,171.36 194.69,171.77 194.53,171.93 194.13,171.93 193.98,171.77 193.98,171.36 193.91,171.29 193.35,171.29 193.26,171.37 193.26,171.53 193.06,171.73 192.71,171.73 192.5,171.53 192.5,170.96 192.7,170.76 v2(192.74,170.76)
  L3 w0.127: v2(192.74,170.76) 192.74,170.64 192.64,170.54 192.16,170.54 192.05,170.64 192.05,170.71 191.84,170.91 190.89,170.91 190.68,170.71 v2(190.68,170.7) 190.68,170.69 190.3,170.69 189.95,171.04 v2(188.31,171.04)
  L4 w0.165: v2(200.4,155) 201.06,155.65 201.32,155.65 201.58,155.91 201.58,157.13 197.65,161.05 197.65,162.55 196.01,164.2 196.01,164.75 196.48,165.23 196.48,166.43 195.04,167.87 195.04,168.21 194.73,168.51 194.73,168.9 195.71,169.88 195.71,170.35 195.54,170.52 195.06,170.52 194.86,170.71 194.86,170.98 195.06,171.18 195.54,171.18 195.71,171.34 195.71,171.89 195.42,172.18 194.58,172.18 194.42,172.01 194.42,171.45 194.22,171.26 193.95,171.26 193.76,171.45 193.76,172.21 193.39,172.58 192.42,172.58 191.95,172.11 191.95,171.26 191.61,170.91 191,170.91 190.78,170.7 v2(190.68,170.7)
  BOTTOM w0.178: VRAM1.R2 196.3,166.12 195.93,165.75 195.36,165.75 195.34,165.77 194.79,165.77 194.57,165.55 193.29,165.55 191.92,166.93 191.92,168.52 192.22,168.82 v1(192.22,169.94) 192.22,170.24 v2(192.74,170.76) ; VRAM2.R2 184.21,170.92 184.61,171.32 185.51,171.32 185.97,171.78 186.5,171.78 186.68,171.96 186.68,172.45 186.88,172.65 187.19,172.65 187.39,172.45 187.39,172.06 187.58,171.87 187.58,171.59 187.18,171.19 187.18,170.91 187.37,170.72 187.65,170.72 187.97,171.04 v2(188.31,171.04) ; GPU1.F26 198.96,152.96 198.96,153.74 198.8,153.9 198.8,154.3 199.49,155 v2(200.4,155)
FBA_CMD8: length 63.3
  TOP w0.178: v2(191.3,173.73) 191.64,173.38 v1(191.76,173.38) ; v2(196.07,168.79) 196.07,168.84 VRAM3.P3 ; v2(185.14,168.68) 185.13,168.67 185.13,168.06 184.86,167.79 184.25,167.79 183.38,166.92 VRAM4.P3
  L3 w0.127: v2(185.14,168.68) 184.95,168.87 184.95,170.39 186.05,171.49 186.05,172.09 186.21,172.25 187.89,173.92 189.56,173.92 189.79,173.69 191.26,173.69 v2(191.3,173.73) 191.58,174 192.11,174 192.28,173.84 192.28,173.58 192.44,173.41 192.77,173.41 192.94,173.58 192.94,173.84 193.1,174 193.35,174 194.72,172.64 194.72,171.56 194.97,171.3 195.98,171.3 196.25,171.04 196.25,168.96 v2(196.07,168.79)
  L4 w0.165: v2(191.3,173.73) 195.03,173.73 196.62,172.13 196.62,169.79 197.4,169.01 197.4,168.76 197.74,168.43 197.74,165.46 198.05,165.15 198.05,164.4 198.17,164.29 198.17,163.4 198.78,162.79 198.78,161.49 202.74,157.53 202.74,155.54 200.73,153.53 200.73,153.19 200.38,152.84 200.35,152.84 199.31,151.8 199.31,151.05 v2(199.79,150.57)
  BOTTOM w0.178: v2(199.79,150.57) 199.39,150.17 GPU1.F23 ; v2(196.07,168.79) 195.95,168.66 195.95,167.91 196.32,167.53 196.74,167.53 VRAM1.P3 ; v2(185.14,168.68) 184.99,168.68 183.93,169.73 183.74,169.73 183.36,170.12 VRAM2.P3
FBA_CMD9: length 67.3
  TOP w0.178: v1(189.4,175.09) 189.77,175.09 v2(189.95,175.27) ; v2(197.3,168.24) 197.41,168.36 197.41,169.23 198.15,169.96 VRAM3.N3 ; v2(183.72,168.39) 183.57,168.39 182.35,167.17 VRAM4.N3
  L3 w0.127: v2(197.3,168.24) 197.51,168.45 197.51,169.33 198.07,169.9 198.07,170.42 197.86,170.63 197.86,170.86 197.93,170.92 197.93,171.15 197.76,171.31 197.53,171.31 197.47,171.25 197.24,171.25 193.08,175.41 190.1,175.41 v2(189.95,175.27) 189.85,175.37 187.73,175.37 186.91,174.55 186.91,174.3 186.44,173.83 185.83,173.23 185.52,173.23 182.04,169.75 182.04,169.4 182.22,169.22 183.42,169.22 183.72,168.92 v2(183.72,168.39)
  L4 w0.165: v2(199.03,149.73) 198.24,150.52 198.24,154 198.92,154.68 198.92,155.75 199.36,156.18 199.36,156.71 195.7,160.37 195.7,162.62 194.44,163.88 194.44,164.29 194.16,164.57 194.16,165.09 192.81,166.43 192.42,166.43 191.6,167.26 191.6,167.66 189.26,169.99 189.26,174.71 189.82,175.27 v2(189.95,175.27)
  BOTTOM w0.178: GPU1.G22 198.63,149.33 v2(199.03,149.73) ; VRAM2.N3 182.35,169.77 182.9,169.23 183.35,169.23 183.72,168.85 v2(183.72,168.39) ; v2(197.3,168.24) 197.3,167.93 198.15,167.08 VRAM1.N3
FBA_CMD10: length 80.1
  TOP w0.178: VRAM3.P8 196.93,165.7 196.31,165.7 196.12,165.5 196.12,165.1 195.87,164.85 194.29,164.85 191.92,167.22 191.92,168.55 192.51,169.14 192.51,169.66 192.82,169.98 193.22,169.98 v2(193.23,169.98) ; VRAM4.P8 183.15,171.08 183.39,171.33 184.11,171.33 184.36,171.57 184.36,172.98 184.66,173.29 185.22,173.29 185.4,173.11 185.4,173.03 185.6,172.83 185.91,172.83 186.11,173.03 186.11,173.11 186.29,173.29 186.98,173.29 187.28,172.98 187.28,171.31 187.82,170.77 187.82,170.25 188.18,169.89 v2(188.18,169.24)
  L3 w0.127: v2(188.18,169.24) 188.22,169.21 189.13,169.21 189.34,169.41 189.34,169.77 189.53,169.97 189.91,169.97 190.17,169.71 190.17,168.13 190.37,167.93 191.01,167.93 191.22,168.13 v2(191.22,169.21) 191.41,169.21 191.61,169.01 191.61,168.39 191.82,168.19 192.78,168.19 192.99,168.39 192.99,168.85 192.73,169.11 192.69,169.15 192.69,169.54 193.13,169.98 v2(193.23,169.98)
  L4 w0.165: v2(191.22,169.21) 191.56,169.21 192.33,168.44 192.33,167.57 192.73,167.17 193.88,167.17 195.01,166.03 195.01,165.8 194.72,165.5 194.72,164.91 195.03,164.59 195.03,164.04 196.44,162.64 196.44,160.67 200.13,156.98 200.13,155.99 199.68,155.54 199.68,153.88 199.39,153.59 199.11,153.59 198.95,153.76 198.66,153.76 198.53,153.62 198.53,153.29 198.69,153.12 198.69,152.89 198.51,152.71 198.51,150.63 198.66,150.48 198.88,150.48 v2(198.96,150.56)
  BOTTOM w0.178: v2(198.96,150.56) 198.58,150.17 GPU1.G23 ; v2(188.18,169.24) 188.1,169.15 188.1,168.19 188.21,168.07 188.21,166.24 v1(188.13,166.16) 187.47,165.5 187.47,165 187,164.53 186.66,164.53 186.48,164.7 186.48,164.9 186.31,165.07 185.95,165.07 185.77,164.9 185.77,164.7 185.6,164.53 184.95,164.53 184.38,165.1 184.38,165.44 184.1,165.72 183.55,165.72 VRAM2.P8 ; VRAM1.P8 197.35,171.18 197.21,171.31 196.43,171.31 196.12,171.63 196.12,171.9 196.12,171.9 196.12,172.65 195.42,173.35 193.89,173.35 193.29,172.74 193.29,171.83 193.49,171.62 194.39,171.62 194.59,171.42 194.59,171.11 194.39,170.91 194.01,170.91 193.84,170.73 193.84,170.43 193.57,170.17 193.41,170.17 v2(193.23,169.98)
FBA_CMD11: length 61.1
  TOP w0.178: VRAM4.P7 183.1,170.07 183.1,169.56 183.46,169.21 184.43,169.21 184.69,168.94 184.69,168.26 v2(184.67,168.23) ; v2(190.28,174.15) 190.28,173.63 v1(190.32,173.59) ; v2(196.39,168.09) 196.83,168.09 197.35,167.57 VRAM3.P7
  L3 w0.127: v2(196.39,168.09) 196.52,168.21 196.52,171.22 193.36,174.37 190.5,174.37 v2(190.28,174.15) 190.01,174.42 187.9,174.42 185.79,172.31 185.79,171.6 185.53,171.35 184.61,171.35 184.29,171.02 184.29,169.34 184.69,168.94 184.69,168.25 v2(184.67,168.23)
  L4 w0.165: v2(198.95,152.19) 198.95,152.67 199.95,153.67 199.95,155.41 200.5,155.96 200.5,157.17 196.84,160.83 196.84,162.61 195.42,164.04 195.42,164.96 195.59,165.14 195.59,165.83 193.95,167.47 193.55,167.47 193.27,167.76 193.27,168.04 191.6,169.7 191.01,169.7 190.01,170.71 190.01,173.88 v2(190.28,174.15)
  BOTTOM w0.178: VRAM1.P7 196.52,169.29 196.52,168.57 196.39,168.45 v2(196.39,168.09) ; v2(184.67,168.23) 184.19,167.76 183.62,167.76 183.15,167.28 VRAM2.P7 ; GPU1.G24 198.55,150.97 198.96,151.38 198.96,152.18 v2(198.95,152.19)
FBA_CMD12: length 65.1
  TOP w0.178: v2(190.97,174.86) 191.3,174.86 v1(191.51,174.65) ; VRAM4.M2 181.79,166.12 182.2,166.53 182.48,166.53 182.74,166.79 182.74,167.07 183.21,167.53 183.49,167.53 184.17,168.21 184.17,168.23 184.23,168.29 184.23,168.74 v2(184.25,168.76) ; VRAM3.M2 198.56,170.53 197.97,170.53 197.72,170.27 197.72,170.27 197.72,169.97 196.96,169.21 v2(196.96,168.78)
  L3 w0.127: v2(184.25,168.76) 183.99,169.02 183.99,171.28 185.67,172.96 185.94,172.96 187.79,174.8 190.15,174.8 190.15,174.81 190.91,174.81 v2(190.97,174.86) 191.11,175.01 192.96,175.01 193.28,174.69 193.42,174.69 196.96,171.15 196.96,170.94 196.78,170.77 196.78,170.43 196.95,170.26 197.28,170.26 197.44,170.1 197.44,169.77 197.28,169.6 196.95,169.6 196.78,169.44 196.78,168.96 v2(196.96,168.78)
  L4 w0.165: v2(190.97,174.86) 190.33,174.86 189.64,174.18 189.64,170.14 191.96,167.81 191.96,167.41 192.57,166.8 193.01,166.8 194.45,165.36 194.45,164.72 194.76,164.41 194.76,163.94 196.07,162.63 196.07,160.52 199.76,156.83 199.76,156.08 199.24,155.56 v2(199.24,154.08)
  BOTTOM w0.178: GPU1.F27 199.35,153.97 v2(199.24,154.08) ; VRAM1.M2 198.53,166.54 197.99,166.54 197.77,166.76 197.77,167.07 196.84,167.99 196.84,168.42 196.96,168.53 v2(196.96,168.78) ; VRAM2.M2 181.73,170.92 182.1,170.55 182.46,170.55 182.75,170.26 182.75,169.97 183.09,169.63 183.38,169.63 v2(184.25,168.76)
FBA_CMD13: length 64.8
  TOP w0.178: VRAM3.L3 199.36,169.73 v2(199.36,169.25) ; VRAM4.L3 181.29,167.46 181.29,167.51 181.81,168.03 181.81,168.83 v2(181.49,169.16) ; v2(190.98,175.9) v1(191.56,175.9)
  L3 w0.127: v2(181.49,169.16) 181.49,169.61 185.37,173.49 185.72,173.49 186.32,174.1 186.33,174.1 186.64,174.41 186.64,174.81 187.73,175.9 v2(190.98,175.9) 193.29,175.9 194.5,174.69 194.51,174.69 196.71,172.48 196.71,172.15 197.12,171.74 197.74,171.74 198.59,170.89 198.59,170.66 198.4,170.48 198.4,170.21 198.53,170.08 198.8,170.08 198.98,170.27 199.21,170.27 199.52,169.96 199.52,169.41 v2(199.36,169.25)
  L4 w0.165: v2(190.98,175.9) 190.98,175.89 189.93,175.89 188.89,174.86 188.89,169.75 190.21,168.44 190.29,168.44 190.29,168.44 191.12,167.61 191.12,167.2 192.25,166.07 192.73,166.07 193.89,164.91 193.89,164.46 194.17,164.18 194.17,163.77 195.33,162.61 195.33,160.22 198.82,156.73 198.82,156.32 198.05,155.55 198.05,155.04 198.17,154.92 198.17,154.55 v2(197.72,154.1)
  BOTTOM w0.178: v2(197.72,154.1) 197.72,153.24 198.1,152.87 198.1,152.22 GPU1.G25 ; v2(199.36,169.25) 199.36,168.53 199.44,168.46 199.44,168.08 199.43,168.08 199.43,167.64 199.75,167.32 VRAM1.L3 ; v2(181.49,169.16) 181.16,169.49 181.16,169.95 180.99,170.12 VRAM2.L3
FBA_CMD14: length 3.9
  TOP w0.178: v2(198.48,155.37) 198.47,155.38 TP7502.1
  BOTTOM w0.178: GPU1.G27 198.55,153.56 198.49,153.62 198.49,155.21 198.48,155.21 v2(198.48,155.37) 198.48,155.59 v1(199.25,156.36)
FBA_CMD15: length 66.5
  TOP w0.178: v2(200.5,168.63) 200.18,168.96 200.18,169.53 200.55,169.91 VRAM3.K3 ; VRAM4.K3 179.95,168.13 179.99,168.17 v2(179.99,168.27) ; v1(189.38,176.33) 189.88,176.33 v2(189.95,176.4)
  L3 w0.127: v2(179.99,168.27) 180.05,168.27 181.05,169.27 181.05,169.68 185.56,174.2 185.56,175.75 186.21,176.4 v2(189.95,176.4) 193.32,176.4 196.98,172.74 196.98,172.26 197.24,172.01 197.85,172.01 199.88,169.98 199.88,169.25 v2(200.5,168.63)
  L4 w0.165: v2(189.95,176.4) 189.82,176.27 189.78,176.27 188.33,174.82 188.33,171.88 187.79,171.35 187.79,170.33 190.05,168.07 190.14,168.07 190.75,167.46 190.75,167.05 192.25,165.55 192.25,165.21 192.53,164.94 193.04,164.94 193.9,164.07 193.9,163.66 194.97,162.6 194.97,160.06 198.22,156.81 198.22,156.19 197.78,155.75 197.78,154.78 v2(197.73,154.74)
  BOTTOM w0.178: GPU1.G26 198.55,152.83 198.17,153.21 198.17,154.3 v2(197.73,154.74) ; VRAM1.K3 200.55,167.47 200.6,167.52 200.6,168.53 v2(200.5,168.63) ; VRAM2.K3 179.95,169.29 180.31,168.93 180.31,168.59 v2(179.99,168.27)
FBA_CMD16: length 55.2
  TOP w0.178: v1(193.53,155.21) 193.03,155.21 v2(192.87,155.04) 193.42,154.5 R7511.1 ; VRAM4.L2 181.15,166.52 181.74,166.52 181.96,166.73 181.96,167.26 182.63,167.94 v2(182.63,168.13)
  L4 w0.165: v2(192.87,155.04) 190.4,155.04 186.67,158.77 184.96,158.77 183.45,160.28 183.45,161.01 182.9,161.55 182.67,161.55 182.41,161.29 182.17,161.29 181.94,161.53 181.94,161.76 182.2,162.02 182.2,162.25 182,162.46 181.66,162.46 181.49,162.62 181.49,162.95 181.66,163.12 182.33,163.12 182.5,163.28 182.5,163.5 183.49,164.49 183.49,165.2 183.22,165.47 183.22,165.8 183.38,165.97 183.96,165.97 184.15,166.16 184.15,166.44 183.96,166.63 182.87,166.63 181.8,167.7 181.8,168.86 181.92,168.98 181.92,169.34 181.4,169.86 181.4,170.5 181.57,170.67 184.58,170.67 184.75,170.83 184.75,171.15 184.91,171.31 185.24,171.31 185.41,171.15 185.41,170.83 185.57,170.67 186.01,170.67 186.21,170.47 186.21,170.18 186.01,169.98 185.74,169.98 185.57,169.82 185.57,169.39 185.41,169.23 185.08,169.23 184.91,169.39 184.91,169.82 184.75,169.98 184.42,169.98 184.25,169.82 184.25,169.39 184.09,169.23 183.76,169.23 183.59,169.39 183.59,169.82 183.43,169.98 182.92,169.98 182.71,169.78 182.71,168.22 v2(182.63,168.13)
  BOTTOM w0.178: VRAM2.L2 181.01,170.66 181.29,170.66 181.4,170.55 181.67,170.55 181.96,170.26 181.96,169.77 182.71,169.02 182.71,168.21 v2(182.63,168.13) ; v2(192.87,155.04) 192.87,154.82 194.01,153.68 194.01,151.35 GPU1.M24
FBA_CMD17: length 1.2
  TOP w0.178: TP7505.1 194.85,149.25 v2(194.85,149.76)
  BOTTOM w0.178: v2(194.85,149.76) 194.85,149.78 194.45,150.17 GPU1.M23
FBA_CMD18: length 55.7
  TOP w0.178: v2(180.6,169.44) 180.6,168.68 180.75,168.53 180.75,168.21 180.92,168.04 180.92,167.68 180.34,167.1 180.34,165.43 180.23,165.32 VRAM4.K1 ; v2(195.61,150.57) v1(195.61,151.18)
  L4 w0.165: v2(180.6,169.44) 180.86,169.44 181.14,169.72 181.14,170.84 181.34,171.05 184.22,171.05 184.45,171.28 184.45,172.79 184.26,172.98 183.99,172.98 183.79,172.79 183.79,171.87 183.63,171.71 180.72,171.71 180.51,171.5 180.51,170.13 179.98,169.6 179.98,169.24 180.55,168.66 180.55,168.57 181.14,167.98 181.14,167.75 180.76,167.37 180.76,167.14 181,166.9 181.23,166.9 181.61,167.28 181.84,167.28 182.49,166.63 182.49,166.15 182.29,165.94 182.29,165.56 182.49,165.36 182.49,164.34 181.12,162.97 181.12,162.01 181.52,161.61 181.52,161.37 181.51,161.36 181.51,161.12 181.74,160.89 181.97,160.89 181.99,160.91 182.22,160.91 182.74,160.39 182.74,160.16 182.62,160.04 182.62,159.8 182.85,159.57 183.09,159.57 183.21,159.69 183.44,159.69 183.98,159.15 183.98,158.92 183.93,158.87 183.93,158.63 184.16,158.4 184.4,158.4 184.45,158.45 184.68,158.45 184.72,158.4 186.48,158.4 188.63,156.25 188.63,156.02 188.57,155.95 188.57,155.72 188.8,155.49 189.04,155.49 189.1,155.55 189.33,155.55 189.57,155.32 189.57,155.08 189.5,155.02 189.5,154.79 189.74,154.55 189.97,154.55 190.03,154.61 190.27,154.61 190.27,154.61 192.99,154.61 193.43,154.17 193.43,153.95 193.43,153.94 193.43,153.63 194.39,152.67 194.39,151.81 194.97,151.23 195.59,150.62 195.59,150.6 195.61,150.59 v2(195.61,150.57)
  BOTTOM w0.178: v2(195.61,150.57) 196.01,150.97 GPU1.K24 ; v2(180.6,169.44) 180.37,169.66 180.37,171.29 VRAM2.K1
FBA_CMD19: length 61
  TOP w0.178: v2(180.47,167.86) 180.47,168.41 180.21,168.67 180.21,169.19 180.15,169.25 180.15,169.62 180.35,169.82 180.35,171.04 180.01,171.38 180.01,171.48 179.95,171.55 VRAM4.K9 179.95,172.74 v2(180.49,173.28) ; v2(196.47,149.7) v1(196.47,149.14)
  L4 w0.165: v2(180.47,167.86) 180.47,166.97 181.01,166.43 181.24,166.43 181.53,166.72 181.77,166.72 182,166.49 182,166.25 181.71,165.96 181.71,165.73 182.11,165.33 182.11,164.37 180.84,163.1 180.84,162.3 180.68,162.13 179.89,162.13 179.7,161.94 179.7,161.67 179.89,161.47 180.88,161.47 181.07,161.28 181.07,161.01 180.88,160.81 178.75,160.81 178.56,160.62 178.56,160.35 178.75,160.15 180.68,160.15 180.84,159.99 180.84,158.22 181.02,158.04 181.4,158.04 181.56,158.2 181.56,160.31 181.75,160.51 182.03,160.51 182.22,160.31 182.22,158.2 182.38,158.04 182.72,158.04 182.88,158.2 182.88,158.97 183.05,159.14 183.38,159.14 183.54,158.97 183.54,158.2 183.72,158.02 186.28,158.02 187.83,156.47 187.83,156.04 190.19,153.67 190.65,153.67 190.85,153.88 190.85,154 191.18,154.34 192.88,154.34 193.16,154.06 193.16,153.52 194.13,152.56 194.13,151.5 194.43,151.19 194.43,150.91 194.13,150.6 194.13,150.35 194.41,150.07 194.41,149.13 194.46,149.08 194.46,148.85 194.61,148.7 194.91,148.7 195.09,148.88 195.09,149.08 195.32,149.3 196.31,149.3 196.47,149.47 v2(196.47,149.7)
  BOTTOM w0.178: v2(180.49,173.28) 180.63,173.42 180.63,174.9 R7509.1 ; v2(180.47,167.86) 180.34,167.72 180.34,165.71 VRAM2.K9 ; GPU1.K23 196.07,150.1 v2(196.47,149.7)
FBA_CMD20: length 69
  TOP w0.178: v2(193.73,166.69) 193.73,167.28 193.26,167.75 193.26,168.32 194.02,169.08 194.71,169.08 VRAM3.T3 ; v2(194.22,155.15) 194.84,154.54 R7508.1 ; VRAM4.T3 185.76,166.92 186.39,167.55 186.48,167.55 186.74,167.81 186.74,167.84 186.75,167.85 186.75,169.35 186.41,169.69 v2(186.41,169.77) ; v1(189.3,165.28) 189.67,164.92 v2(189.73,164.92)
  L3 w0.127: v2(186.41,169.77) 186.82,169.77 188.08,168.51 188.08,168.26 188.67,167.68 188.67,167.04 188.26,166.63 188.26,166.63 188.2,166.57 188.2,166.49 187.63,165.93 187.63,164.81 187.9,164.53 187.95,164.53 187.95,164.53 188.55,164.53 188.93,164.92 v2(189.73,164.92) 189.73,164.99 189.96,165.21 190.23,165.48 190.59,165.48 190.78,165.29 191.47,165.29 191.59,165.41 191.59,165.69 191.78,165.88 192.03,165.88 192.25,165.66 192.25,165.14 192.46,164.94 192.52,164.94 192.53,164.94 192.91,164.94 192.91,164.94 192.98,164.94 193.18,165.14 193.18,166.42 192.98,166.62 192.76,166.62 192.6,166.78 192.6,167.12 192.76,167.28 193.35,167.28 193.73,166.9 v2(193.73,166.69)
  L4 w0.165: v2(189.73,164.92) 189.17,165.48 189.17,165.75 188.19,166.73 187.95,166.73 187.79,166.57 187.79,166.01 187.66,165.88 187.65,165.88 187.62,165.85 187.29,165.85 187.13,166.01 187.13,166.42 186.94,166.61 186.66,166.61 186.47,166.42 186.47,165.97 186.28,165.78 185.91,165.78 185.71,165.98 185.71,167.04 185.51,167.24 184.95,167.24 184.74,167.04 184.74,164.52 184.73,164.52 184.66,164.45 184.24,164.04 183.79,164.04 183.03,163.27 183.03,162.47 184.25,161.25 184.26,161.25 184.26,160.61 185.36,159.51 187.05,159.51 187.94,158.62 188.17,158.62 188.54,158.98 188.77,158.98 189,158.75 189,158.52 188.64,158.15 188.64,157.92 188.87,157.69 189.11,157.69 189.47,158.05 189.7,158.05 189.94,157.82 189.94,157.58 189.57,157.22 189.57,156.99 189.81,156.75 190.04,156.75 190.41,157.12 190.64,157.12 190.87,156.88 190.87,156.65 190.51,156.28 190.51,156.05 190.78,155.77 193.14,155.77 193.58,155.34 193.58,155.04 193.72,154.89 193.96,154.89 v2(194.22,155.15)
  BOTTOM w0.178: GPU1.M27 194.39,153.72 193.76,154.35 193.76,154.82 194.09,155.15 v2(194.22,155.15) ; VRAM1.T3 193.96,166.92 v2(193.73,166.69) ; v2(186.41,169.77) 186.06,170.12 VRAM2.T3
FBA_CMD21: length 62.8
  TOP w0.178: VRAM3.T8 195.74,166.13 194.83,166.13 194.48,166.47 194.48,166.93 193.7,167.71 v2(193.7,167.94) ; v2(189.73,163.95) 189.55,163.95 189.52,163.99 v1(189.17,163.99) ; v2(187.51,168.33) 187.43,168.41 187.43,169.6 187.19,169.84 187.19,170.22 186.48,170.92 VRAM4.T8
  L3 w0.127: v2(193.7,167.94) 193.7,167.84 194.44,167.1 194.44,165.65 193.22,164.43 193.22,164.43 193.07,164.27 192.96,164.17 192.04,164.17 191.68,164.52 190.76,164.52 190.69,164.45 190.49,164.45 189.99,163.95 v2(189.73,163.95) 189.01,163.95 188.85,163.8 187.7,163.8 186.85,164.65 186.85,166.73 186.97,166.86 186.97,167.22 186.74,167.45 186.74,168.44 186.94,168.64 187.31,168.64 187.51,168.44 v2(187.51,168.33)
  L4 w0.165: v2(194.22,154.52) 194.66,154.96 194.66,156.08 194.36,156.37 191.97,156.37 191.66,156.68 191.66,157.18 189.11,159.73 187.87,159.73 187.36,160.25 186.77,160.25 186.6,160.43 186.6,162.69 186.4,162.89 186.13,162.89 185.94,162.69 185.94,160.8 185.74,160.61 185.47,160.61 185.27,160.8 185.27,164.3 186.21,165.24 187.19,165.24 187.89,164.53 188.78,164.53 189.36,163.95 v2(189.73,163.95)
  BOTTOM w0.178: v2(193.7,167.94) 193.69,167.94 193.69,167.93 193.69,167.93 193.69,169.09 195.27,170.66 195.27,170.67 195.52,170.92 VRAM1.T8 ; VRAM2.T8 186.38,166.12 187.16,166.9 187.16,167.98 v2(187.51,168.33) ; GPU1.M26 194.29,152.67 194.29,152.9 194.37,152.99 194.59,152.99 195.03,153.42 195.03,153.71 v2(194.22,154.52)
FBA_CMD22: length 72
  TOP w0.178: v2(193.13,169.33) 193.13,169.1 192.36,168.33 192.36,167.48 193.31,166.53 193.31,166.22 193.77,165.77 195.58,165.77 195.6,165.75 195.9,165.75 195.92,165.77 195.96,165.77 196.31,166.12 VRAM3.R8 ; VRAM4.R8 184.14,170.92 184.54,171.32 186.68,171.32 187.46,170.53 187.46,169.96 187.71,169.72 187.71,168.76 187.98,168.5 187.98,167.95 v2(187.74,167.71) ; v2(190.5,164.92) 190.5,165.47 v1(190.52,165.49)
  L3 w0.127: v2(193.13,169.33) 193.25,169.21 193.25,167.77 193.52,167.5 193.55,167.5 194.17,166.88 194.17,166.39 193.48,165.7 193.48,165.06 192.96,164.54 192.19,164.54 191.81,164.92 v2(190.5,164.92) 190.39,164.92 189.93,164.45 188.99,164.45 188.7,164.16 187.71,164.16 187.11,164.76 187.11,166.01 187.31,166.21 187.31,166.44 187.23,166.52 187.23,166.76 187.46,166.99 187.7,166.99 187.78,166.91 188.01,166.91 188.3,167.19 188.3,167.53 188.12,167.71 v2(187.74,167.71)
  L4 w0.165: v2(190.5,164.92) 190.02,164.43 189.48,164.43 188.4,165.51 186.11,165.51 185,164.41 185,163.97 184.8,163.77 183.92,163.77 183.77,163.61 183.77,163.34 183.96,163.15 184.84,163.15 185,162.98 185,162.65 184.84,162.49 184.19,162.49 184,162.29 184,162.02 184.19,161.83 184.49,161.83 184.75,161.57 184.75,160.64 185.51,159.88 187.2,159.88 187.72,159.36 188.96,159.36 191.29,157.03 191.29,156.46 191.64,156.11 193.22,156.11 193.54,155.79 v2(194.22,155.79)
  BOTTOM w0.178: v2(193.13,169.33) 193.2,169.33 195.12,171.24 195.44,171.24 195.49,171.29 195.87,171.29 195.88,171.29 195.9,171.29 196.27,170.92 VRAM1.R8 ; VRAM2.R8 184.22,166.12 184.59,165.75 184.87,165.75 184.89,165.76 186.8,165.76 187.74,166.7 v2(187.74,167.71) ; GPU1.M25 194.6,151.77 194.81,151.98 194.81,152.81 195.3,153.3 195.3,154.7 v2(194.22,155.79)
FBA_CMD23: length 60.3
  TOP w0.178: v2(187.85,172.36) v1(188.42,172.36) ; VRAM4.R7 184.03,170.04 184.03,169.71 184.13,169.61 184.84,169.61 185.58,168.86 185.58,168.5 185.49,168.4 185.49,167.77 v2(185.42,167.69) ; v2(195.49,168.07) 195.78,168.07 196.55,167.3 VRAM3.R7
  L3 w0.127: v2(185.42,167.69) 185.59,167.87 185.59,168.4 185.59,168.4 185.59,168.76 185.59,168.77 185.59,168.87 185.22,169.25 185.22,170.28 186.32,171.38 186.32,171.92 187.75,173.36 189.38,173.36 189.58,173.15 189.58,172.83 189.38,172.63 188.11,172.63 v2(187.85,172.36) 187.95,172.26 190.41,172.26 190.76,172.62 192.78,172.62 193.12,172.27 193.46,172.27 195.59,170.14 195.63,170.1 195.63,168.97 195.63,168.97 195.63,168.61 195.63,168.6 195.63,168.22 v2(195.49,168.07)
  L4 w0.165: v2(196.42,153.8) 196.91,154.29 196.91,156.08 196.91,156.08 196.91,157.08 194.23,159.76 194.23,162.58 192.85,163.96 192.41,163.96 191.75,164.63 191.51,164.63 188.08,168.05 188.08,168.45 186.85,169.68 186.85,169.95 186.84,169.95 186.84,170.51 185.96,171.4 185.96,172.59 186.37,173 187.21,173 v2(187.85,172.36)
  BOTTOM w0.178: VRAM1.R7 196.3,170.12 195.47,169.29 195.47,169.05 195.62,168.91 195.62,168.2 v2(195.49,168.07) ; GPU1.K26 196.47,152.97 196.47,153.74 v2(196.42,153.8) ; v2(185.42,167.69) 185.07,167.35 184.38,167.35 VRAM2.R7
FBA_CMD24: length 97.6
  TOP w0.178: v2(192.72,165.4) 191.45,166.66 191.45,168.75 192.06,169.36 192.06,171.86 192.4,172.21 195.88,172.21 196.15,171.93 196.15,171.53 196.34,171.33 196.94,171.33 VRAM3.P2 ; v2(188.1,165) 188.2,164.9 188.2,164.21 188.08,164.09 187.35,164.09 187.17,164.27 187.17,165.29 186.98,165.49 186.66,165.49 186.46,165.29 186.46,163.95 186.26,163.75 185.95,163.75 185.75,163.95 185.75,164.67 185.55,164.87 185.24,164.87 185.04,164.67 185.04,163.96 184.86,163.78 184.6,163.78 184.42,163.96 184.42,165.13 184.38,165.17 184.38,165.45 184.32,165.51 184.32,165.52 184.12,165.72 183.55,165.72 VRAM4.P2
  L3 w0.127: v2(192.72,165.4) 192.72,165.72 192.18,166.25 191.57,166.25 191.17,165.85 189.94,165.85 v2(189.77,165.68) 189.77,165.8 189.56,166.01 189.25,166.01 189.08,165.84 189.08,165.47 188.89,165.29 188.62,165.29 188.61,165.28 188.42,165.47 188.42,165.68 188.3,165.8 188.05,165.8 187.9,165.65 187.9,165.15 188.05,165 v2(188.1,165)
  L4 w0.165: v2(195.54,148.83) 196.37,148.83 196.91,149.37 196.91,149.89 196.65,150.14 196.3,150.14 196.05,150.4 196.05,150.75 195.66,151.13 195.53,151.13 194.66,152 194.66,152.78 193.7,153.74 193.7,154.28 193.31,154.67 193.31,155.23 193.03,155.5 190.48,155.5 186.84,159.14 185.2,159.14 183.89,160.46 183.89,161.09 182.77,162.21 182.77,163.39 183.68,164.3 184.13,164.3 184.39,164.56 184.48,164.65 184.48,166.71 184.13,167.05 183.73,167.05 183.54,167.25 183.54,167.54 183.74,167.74 184.84,167.74 185.58,168.47 185.58,168.85 185.74,169.02 186.42,169.02 186.94,168.5 186.94,167.81 187.66,167.1 188.35,167.1 v2(189.77,165.68)
  BOTTOM w0.178: v2(192.72,165.4) 192.67,165.4 192.47,165.2 192.47,164.74 192.67,164.54 193.26,164.54 193.43,164.36 193.43,163.81 193.61,163.63 193.97,163.63 194.15,163.81 194.15,164.64 194.35,164.85 194.65,164.85 194.86,164.64 194.86,163.81 195.03,163.63 195.39,163.63 195.57,163.81 195.57,164.36 195.75,164.54 195.75,164.54 196.12,164.9 196.12,165.41 196.41,165.71 197.12,165.71 197.35,165.94 VRAM1.P2 ; VRAM2.P2 183.55,171.32 184.1,171.32 184.36,171.58 184.36,171.87 185.42,172.94 187.94,172.94 188.42,172.46 v1(188.42,172.07) 188.42,171.63 189.23,170.82 189.23,168.3 188.66,167.74 188.66,165.62 188.1,165.05 v2(188.1,165) ; v2(195.54,148.83) 196.04,149.33 GPU1.K22
