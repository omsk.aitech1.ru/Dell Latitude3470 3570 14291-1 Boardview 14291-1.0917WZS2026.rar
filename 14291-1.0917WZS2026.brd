# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_CODEC_SYNC: length 174.3
  TOP w0.14: v2(34.84,21.22) 34.72,21.1 32.81,21.1 32.41,20.71 32.41,20.68 32.36,20.63 32.36,20.27 31.42,19.33 31.42,19.29 31.27,19.14 31.27,18.52 31.52,18.27 31.52,17.75 31.04,17.27 HDA27.10
  L3 w0.127: v2(149.33,13.11) 148.94,13.5 147.74,13.5 138.67,4.43 92.82,4.43 90.06,7.2 72.38,7.2 71.78,7.8 69.8,9.78 58.72,9.78 57.77,10.74 48.97,10.74 48.55,11.15 46.54,11.15 40.11,17.59 39.85,17.59 39.1,18.34 38.1,18.34 37.41,19.02 35.4,21.04 35.02,21.04 v2(34.84,21.22)
  BOTTOM w0.14: v2(149.33,13.11) 149.33,14.46 149.63,14.76 149.63,22.87 v1(148.75,23.75) 148.46,24.04 148.46,36.02 147.96,36.52 147.96,37.69 144.58,41.08 143.47,41.08 138.19,46.36 136.05,46.36 R1908.1
HDA_RST#: length 31.6
  BOTTOM w0.089: CPU1.AW22 123.55,74.17 123.82,73.9 123.82,73.15 124.31,72.66 124.31,72.23 124.84,71.69 124.84,70.11 124.99,69.96 124.99,69.71
  BOTTOM w0.14: 124.99,69.71 124.99,67.27 125.45,66.81 125.45,65.2 125.91,64.74 125.91,57.51 126.69,56.73 130.1,53.33 133.65,49.77 v1(133.65,49.16) 133.65,48.54 134.65,47.55 R1911.2
HDA_SDIN0: length 203.4
  TOP w0.14: v2(34.67,19.92) 34.4,19.64 R2718.1
  L3 w0.127: v2(151.04,13.92) 149.62,12.5 148.22,12.5 139.19,3.47 92.03,3.47 89.87,5.63 71.61,5.63 68.43,8.81 54.84,8.81 53.89,9.77 48.57,9.77 48.15,10.19 46.14,10.19 39.71,16.62 38.44,16.62 37.22,17.84 37.22,17.85 36.95,18.12 36.25,18.12 35.99,18.38 35.99,18.74 34.82,19.92 v2(34.67,19.92)
  BOTTOM w0.089: CPU1.BA21 124.12,73.11 124.49,72.74 124.49,72.3 125.05,71.74 125.05,70.25 125.22,70.07 125.22,69.73
  BOTTOM w0.14: 125.22,69.73 125.22,67.36 125.68,66.9 125.68,65.3 126.26,64.72 126.26,64.15 127.03,63.38 127.03,57.1 127.19,56.94 130.94,53.19 134.15,49.98 134.15,48.81 134.72,48.23 138.37,48.23 139.13,47.48 139.13,46.83 143.88,42.07 144.99,42.07 147.33,39.73 148.45,39.73 149.45,38.72 149.45,25.11 v1(150.38,24.19) 150.62,23.95 150.62,14.34 v2(151.04,13.92)
HDA_SDOUT: length 33.3
  BOTTOM w0.14: R1909.2 135.25,44.4 R1912.2 v1(133.72,45.93) 131.95,47.7 131.95,49.06 129.03,51.97 128.98,51.97 124.18,56.77 124.18,71.57 123.96,71.79 123.55,72.19 CPU1.BB22
HDA_SPKR_R: length 5.7
  TOP w0.254: v1(36.04,24.98) D2701.2 36.84,23.59 37.28,24.03 37.98,24.03 38.65,23.36 RN2701.3
HDA_SYNC: length 31.1
  BOTTOM w0.089: CPU1.BA22 123.62,73.11 124.13,72.59 124.13,72.16 124.67,71.62 124.67,70.03 124.76,69.94 124.76,69.55
  BOTTOM w0.14: R1908.2 134.68,46.72 v1(133.75,47.65) 133.16,48.24 133.16,49.57 125.42,57.31 125.42,64.91 125.22,65.11 125.22,66.71 124.76,67.17 124.76,69.55
HDD_DET#: length 129.3
  TOP w0.127: 142.01,88.39 142.22,88.6 R2044.2 ; 142.01,88.39 v2(142.01,88.39) ; 142.01,88.39 142.01,88.45 141.71,88.76 141.16,88.76 140.65,88.25 140.28,88.25 140.12,88.41 v1(139.8,88.41) 139.5,88.41 139.47,88.38 135.81,88.38 133.35,85.92 131.9,85.92 v2(131.48,85.51)
  L3 w0.127: v2(142.01,88.39) 142.15,88.52 143.07,88.52 144.06,89.51 145.62,89.51 145.76,89.37 148.29,89.37 148.52,89.13 151.29,89.13 151.81,89.65 154.02,89.65 154.16,89.51 155.78,89.51 156.69,90.43 157.73,90.43 159.36,90.43 160.08,90.43 160.62,89.89 161.51,89.89 161.66,90.04 161.66,90.91 162,91.25 164.55,91.25 164.96,90.84 164.96,90.18 165.21,89.93 166.18,89.93 167.49,91.24 169.05,91.24 169.31,90.98 169.31,89.69 169.38,89.62 170.41,88.59 172.18,88.59 172.63,88.15 175.87,88.15 176.07,87.95 176.46,87.95 176.65,88.14 177.36,88.14 177.89,87.61 182.74,87.61 183.19,87.16 184.7,87.16 185.12,86.75 185.12,86.04 v2(185.27,85.89)
  L4 w0.127: v2(185.27,85.89) 185.27,84.8 185.94,84.13 185.94,82.9 185.85,82.81 185.85,75.08 185.9,75.03 185.9,74.61 186.29,74.22 186.29,71.44 186.98,70.74 186.98,68.87 186.96,68.84 186.96,66.3 187.42,65.83 187.42,61.87 186.9,61.35 186.9,58.27 185.72,57.1 185.72,54.33 185.34,53.94 185.34,45.3 184.55,44.52 184.55,44.06 186.81,41.8 186.81,31.3 185.41,29.9 v2(185.41,29.63)
  BOTTOM w0.127: v2(185.41,29.63) 185.28,29.5 EC6001.1 185.28,28.42 185.53,28.16 187.49,28.16 187.84,28.52 HDD1.10 ; v2(131.48,85.51) 131.48,85.82 131.68,86.02 CPU1.U8
HDD_DEVSLP: length 113.1
  L3 w0.102: v2(137.97,91.33) 138.22,91.59 139.05,91.59 140.11,92.65 141.11,92.65 141.75,93.29 143.92,93.29 144.18,93.55 145.34,93.55 146.35,92.53 146.71,92.53 147.01,92.83 147.01,93.21 147.61,93.82 148.98,93.82 149.56,93.24 154.22,93.24 155.69,94.71 158.32,94.71 158.8,94.23 162.9,94.23 162.91,94.23 163.99,94.23 164.5,94.74 166.82,94.74 167.04,94.52 168.22,94.52 169.05,93.69 170.86,93.69 173.06,91.48 176.55,91.48 176.91,91.85 v2(180.05,91.85)
  L4 w0.102: v2(184.17,35.04) 184.17,36.25 183.78,36.64 183.78,38.67 184.17,39.06 184.17,40.15 183.51,40.81 183.51,43.33 183.29,43.54 183.29,45.04 184.08,45.82 184.08,54.46 184.38,54.76 184.38,54.81 184.43,54.86 184.43,55.55 184.43,55.55 184.43,55.91 184.43,59.36 185.64,60.57 185.64,61.87 185.85,62.08 186.16,62.39 186.16,65.31 185.13,66.34 185.13,67.99 185.14,68 185.14,69.88 184.73,70.29 184.73,71.34 183.5,72.57 183.5,73.74 183.5,73.74 183.5,74.03 183.2,74.33 183.2,75.17 182.56,75.81 182.56,78.25 181.67,79.14 181.67,84.21 180.49,85.4 180.49,91.41 v2(180.05,91.85)
  BOTTOM w0.102: v2(180.05,91.85) 180.05,91.91 179.86,92.09 179.86,92.89 v1(180,93.03) ; CPU1.J1 135.93,90.25 135.98,90.3 136.28,90.3 136.58,90.6 137.23,90.6 v2(137.97,91.33) ; v2(184.17,35.04) 184.3,34.91 R6007.1
HDD_DEVSLP_R: length 4.6
  BOTTOM w0.102: HDD1.20 186.49,33.52 v1(186.34,33.68) 185.27,33.68 184.91,33.32 R6007.2
HDD_FALL_INT: length 41.2
  L3 w0.152: v2(170.15,91.34) 170.07,91.34 169.69,91.72 160.5,91.72 160.01,91.24 156.41,91.24 155.9,90.73 155.09,90.73 154.86,90.96 154.35,90.96 153.79,90.4 151.48,90.4 151.3,90.23 150.49,90.23 150.08,90.63 150.08,90.66 149.88,90.86 145.84,90.86 145.54,91.17 144.22,91.17 142.69,89.64 141.19,89.64 140.79,89.23 138.83,89.23 v2(138.63,89.03)
  BOTTOM w0.089: CPU1.M3 134.64,88.7 134.88,88.7 134.96,88.66 135.16,88.66 135.25,88.7 135.53,88.7 135.61,88.66 136.17,88.66 136.22,88.71 136.87,88.71 136.95,88.79 137.89,88.79 138.02,88.93 138.53,88.93 v2(138.63,89.03)
  BOTTOM w0.152: v2(170.15,91.34) 170.48,91.01 170.8,91.01 R6702.2 170.92,91.13 170.92,92.41 171.19,92.68 U6701.12
HDD_PWR_EN: length 122.1
  TOP w0.14: R6004.2 177.18,27.44 v2(176.16,26.42) ; v2(176.27,92.64) 176.26,92.64 176.26,92.24 175.9,91.88 175.52,91.88 174.79,92.61 170.39,92.61 170.22,92.44 169.76,92.44 169.73,92.47 169.11,92.47 v2(169.04,92.4)
  L3 w0.127: v2(140.14,90.51) 140.74,91.11 141.8,91.11 142.77,92.09 145.74,92.09 146.09,91.73 151.18,91.73 151.96,90.95 153.57,90.95 155.61,92.98 155.61,93.22 155.87,93.48 158.06,93.48 158.26,93.28 164.45,93.28 164.84,93.66 166.38,93.66 166.48,93.56 167.71,93.56 168.87,92.4 v2(169.04,92.4)
  L4 w0.127: v2(176.16,26.42) 175.67,26.9 175.67,28.74 174.94,29.48 174.94,31.84 174.45,32.32 174.05,32.72 174.05,44.38 173.75,44.67 173.75,47.74 173.32,48.18 173.32,50.09 171.97,51.44 171.97,55.7 172.06,55.79 172.08,55.79 172.39,56.1 172.39,59.67 171.74,60.32 171.74,64.44 173.96,66.66 174.44,66.66 175,67.22 175,68.68 175.8,69.48 175.8,70.62 175.26,71.16 174.99,71.16 174.35,71.8 174.35,72.17 174.29,72.24 174.29,73.73 174.4,73.84 174.4,74.9 174.59,75.09 174.59,80.52 174.85,80.77 174.85,82.1 175.75,83 175.75,85.71 175.97,85.93 175.97,88.03 175.81,88.19 175.81,91.13 176.26,91.59 176.26,92.64 v2(176.27,92.64)
  BOTTOM w0.089: CPU1.J4 134.1,89.91 134.84,89.91 134.9,89.84 135.48,89.84 135.58,89.81 136.42,89.81 136.7,90.09
  BOTTOM w0.102: 138.13,90.16 136.77,90.16 136.7,90.09
  BOTTOM w0.14: 138.13,90.16 138.56,90.58 140.07,90.58 v2(140.14,90.51) ; v1(168.77,91.81) 168.77,92.13 v2(169.04,92.4)
HDD_PWR_EN_R: length 4.6
  TOP w0.127: Q6001.2 174.69,29.33 175.45,30.09 175.84,30.09 v1(175.86,30.07) 175.86,29.34 R6005.1 175.77,28.93 177.03,28.93 R6004.1
HDMI_CLK: length 101.1
  TOP w0.127: v2(20.77,64.46) 20.77,63.95 v1(20.72,63.89)
  L4 w0.114: v2(20.77,64.46) 20.88,64.57 24.47,64.57 26.81,66.91 58.59,66.91 84.94,93.26 87.71,93.26 88.53,94.08 90.95,94.08 92.24,95.36 95.84,95.36 96.73,94.48 101.67,94.48 103.78,92.37 103.78,91.86 v2(104.26,91.38)
  BOTTOM w0.127: v2(104.26,91.38) 104.11,91.38 CPU1.G56 ; C5403.1 19.69,64.74 20.49,64.74 v2(20.77,64.46)
HDMI_CLK#: length 101.1
  TOP w0.127: v2(20.77,65.27) v1(20.77,65.9)
  L4 w0.114: v2(104.26,92.03) 104,92.29 104,92.47 101.76,94.71 96.82,94.71 95.94,95.59 92.14,95.59 90.86,94.31 88.43,94.31 87.61,93.49 84.84,93.49 58.5,67.14 26.72,67.14 24.38,64.8 21.07,64.8 20.77,65.1 v2(20.77,65.27)
  BOTTOM w0.127: C5402.1 19.69,64.98 20.64,64.98 20.77,65.11 v2(20.77,65.27) ; v2(104.26,92.03) 103.94,91.71 CPU1.F56
HDMI_CLK#_R: length 4.3
  TOP w0.127: RN5403.7 17.87,65.67 v2(17.47,65.27) 17.45,65.27 v1(17.04,64.86)
  BOTTOM w0.127: C5402.2 18.15,64.98 17.75,64.98 v2(17.47,65.27) 17.19,64.98 16.77,64.98 R5401.1
HDMI_CLK#_R_C: length 8.7
  BOTTOM w0.127: R5401.2 14.74,65.31 R5414.1 14.42,65.02 14.1,65.02 13.88,65.24 13.66,65.24 13.53,65.37 EU5702.9 EU5702.2 11.55,65.37 11.42,65.24 10.25,65.24 10.03,65.45 10.03,66.85 9.72,67.17 9.5,67.17 HDMI1.12
HDMI_CLK_R: length 4.4
  TOP w0.127: v1(17.85,63.93) 17.47,64.31 v2(17.47,64.46) 18.02,65.02 RN5403.8
  BOTTOM w0.127: C5403.2 18.15,64.74 17.75,64.74 v2(17.47,64.46) 17.19,64.74 16.77,64.74 R5402.1
HDMI_CLK_R_C: length 8.6
  BOTTOM w0.127: HDMI1.10 9.26,66.93 9.62,66.93 9.79,66.75 9.79,65.35 10.15,65 11.44,65 11.57,64.87 EU5702.1 EU5702.10 13.53,64.87 13.66,65 13.78,65 14,64.78 14.38,64.78 R5414.2 14.74,64.42 R5402.2
HDMI_DATA0: length 104
  L4 w0.114: v2(106.08,91.37) 105.63,91.83 105.63,92.49 105.86,92.72 105.86,93.84 105.47,94.24 104.78,94.24 103.95,95.06 102.89,95.06 101.73,96.22 99.99,96.22 99.21,97 90.45,97 89.47,96.02 84.69,96.02 57.08,68.41 25.67,68.41 24.32,67.06 21.52,67.06 21.28,66.83 20.98,66.83 v2(20.77,66.62)
  BOTTOM w0.127: v2(106.08,91.37) 105.93,91.37 CPU1.G53 ; v2(20.77,66.62) 20.49,66.9 19.69,66.9 C5405.1
HDMI_DATA0#: length 103.9
  L4 w0.114: v2(106.04,92.01) 105.86,92.2 105.86,92.39 106.09,92.63 106.09,93.94 105.57,94.46 104.88,94.46 104.05,95.29 102.98,95.29 101.83,96.45 100.09,96.45 99.31,97.23 90.35,97.23 89.37,96.25 84.6,96.25 56.99,68.64 25.58,68.64 24.23,67.29 21.42,67.29 21.19,67.06 20.86,67.06 20.71,67.21 20.71,67.36 v2(20.77,67.43)
  BOTTOM w0.127: C5404.1 19.69,67.14 20.6,67.14 20.77,67.31 v2(20.77,67.43) ; v2(106.04,92.01) 105.74,91.71 CPU1.F53
HDMI_DATA0#_R: length 4.7
  TOP w0.127: v1(16.62,67.54) 16.74,67.43 v2(17.47,67.43) 18.08,66.82 RN5403.5
  BOTTOM w0.127: R5403.1 16.77,67.14 17.19,67.14 v2(17.47,67.43) 17.75,67.14 18.15,67.14 C5404.2
HDMI_DATA0#_R_C: length 18.4
  BOTTOM w0.089: HDMI1.9 7.94,65.73 8.07,65.73 8.15,65.82 8.15,71.24 8.64,71.73 8.92,71.73 8.95,71.76 8.96,71.76
  BOTTOM w0.127: R5403.2 14.74,67.47 R5417.1 14.4,67.13 14.07,67.13 13.68,66.74 13.55,66.74 13.43,66.87 EU5702.6 EU5702.5 11.46,66.87 11.33,66.74 11.1,66.74 10.93,66.91 10.93,69.03 9.94,70.01 9.94,71.36 9.54,71.76 8.96,71.76
HDMI_DATA0_R: length 4.7
  TOP w0.127: RN5403.6 17.92,66.17 v2(17.47,66.62) 16.93,66.62 16.63,66.32 v1(16.63,66.32)
  BOTTOM w0.127: R5404.1 16.77,66.9 17.19,66.9 v2(17.47,66.62) 17.75,66.9 18.15,66.9 C5405.2
HDMI_DATA0_R_C: length 18.4
  BOTTOM w0.089: 8.96,71.52 8.95,71.52 8.93,71.54 8.71,71.54 8.34,71.17 8.34,65.74 8.15,65.54 7.87,65.54 HDMI1.7
  BOTTOM w0.127: R5404.2 14.74,66.58 R5417.2 14.41,66.88 14.17,66.88 13.78,66.5 13.55,66.5 13.42,66.37 EU5702.7 EU5702.4 11.46,66.37 11.33,66.5 11,66.5 10.68,66.81 10.68,68.93 9.7,69.91 9.7,71.26 9.44,71.52 8.96,71.52
HDMI_DATA1: length 99.3
  L4 w0.114: v2(103.34,91.39) 102.88,91.84 102.88,92.42 101.43,93.87 91.88,93.87 90.39,92.38 85.12,92.38 58.9,66.16 27.44,66.16 23.74,62.47 20.94,62.47 v2(20.77,62.3)
  BOTTOM w0.127: v2(20.77,62.3) 20.49,62.58 19.69,62.58 C5407.1 ; CPU1.F58 103.01,91.71 v2(103.34,91.39)
HDMI_DATA1#: length 99
  L4 w0.114: v2(103.34,92.04) 103.11,92.26 103.11,92.51 101.53,94.1 91.78,94.1 90.3,92.61 85.03,92.61 58.81,66.39 27.34,66.39 23.65,62.7 21.18,62.7 v2(20.77,63.11)
  BOTTOM w0.127: v2(103.34,92.04) 103.01,92.36 CPU1.E58 ; C5406.1 19.69,62.83 20.49,62.83 v2(20.77,63.11)
HDMI_DATA1#_R: length 4.5
  TOP w0.127: RN5402.5 18.02,62.55 v2(17.47,63.11) 16.95,63.11 v1(16.76,63.3)
  BOTTOM w0.127: R5407.1 16.77,62.83 17.19,62.83 v2(17.47,63.11) 17.75,62.83 18.15,62.83 C5406.2
HDMI_DATA1#_R_C: length 8.2
  BOTTOM w0.127: R5407.2 15.54,63.16 R5416.1 14.72,63.16 14.39,62.83 13.97,62.83 13.71,62.58 13.53,62.58 13.4,62.71 EU5701.6 EU5701.5 11.33,62.71 11.2,62.58 10.93,62.58 10.64,62.87 10.64,63.45 9.92,64.17 9.38,64.17 9,64.55 HDMI1.6
HDMI_DATA1_R: length 4.5
  TOP w0.127: v1(16.72,62.08) 16.95,62.3 v2(17.47,62.3) 17.87,61.9 RN5402.6
  BOTTOM w0.127: C5407.2 18.15,62.58 17.75,62.58 v2(17.47,62.3) 17.19,62.58 16.77,62.58 R5408.1
HDMI_DATA1_R_C: length 8
  BOTTOM w0.127: HDMI1.4 9.26,63.93 9.82,63.93 10.4,63.35 10.4,62.77 10.83,62.34 11.2,62.34 11.33,62.21 EU5701.4 EU5701.7 13.4,62.21 13.53,62.34 13.81,62.34 14.07,62.59 14.39,62.59 14.71,62.27 R5416.2 15.54,62.27 R5408.2
HDMI_DATA2: length 113.7
  L4 w0.114: v2(105.16,91.98) 104.75,92.39 104.75,92.98 103.3,94.42 102.43,94.42 101.77,95.09 99.69,95.09 98.56,96.22 91.81,96.22 90.45,94.86 84.61,94.86 57.41,67.66 26.42,67.66 24.63,65.87 20.42,65.87 19.17,64.62 19.17,59.56 19.7,59.03 21.36,59.03 21.63,59.3 21.63,60.25 21.32,60.56 21,60.56 20.77,60.33 v2(20.77,60.14)
  BOTTOM w0.127: v2(105.16,91.98) 104.98,91.98 CPU1.F55 ; C5409.1 19.85,60.59 20.5,60.59 20.77,60.32 v2(20.77,60.14)
HDMI_DATA2#: length 114.3
  L4 w0.114: v2(105.17,92.64) 104.98,92.82 104.98,93.07 103.4,94.65 102.53,94.65 101.86,95.31 99.79,95.31 98.65,96.45 91.71,96.45 90.35,95.09 84.52,95.09 57.32,67.89 26.32,67.89 24.53,66.1 20.32,66.1 18.94,64.72 18.94,59.47 19.6,58.81 21.45,58.81 21.85,59.21 21.85,60.35 21.42,60.79 20.93,60.79 v2(20.77,60.95)
  BOTTOM w0.127: CPU1.E55 104.89,92.36 v2(105.17,92.64) ; v2(20.77,60.95) 20.65,60.83 19.52,60.83 C5408.1
HDMI_DATA2#_R: length 4.1
  TOP w0.127: v1(17.06,60.54) v2(17.47,60.95) 17.92,61.4 RN5402.7
  BOTTOM w0.127: R5405.1 16.67,60.76 17.28,60.76 v2(17.47,60.95) 17.65,60.76 18.24,60.76 C5408.2
HDMI_DATA2#_R_C: length 9.3
  BOTTOM w0.127: HDMI1.3 7.58,63.17 9.67,61.08 11.2,61.08 11.33,61.21 EU5701.2 EU5701.9 13.4,61.21 13.53,61.08 13.76,61.08 14.14,60.7 14.42,60.7 R5415.1 14.74,60.99 R5405.2
HDMI_DATA2_R: length 4.9
  TOP w0.127: RN5402.8 18.08,60.75 v2(17.47,60.14) 17.47,60.01 v1(17.86,59.62)
  BOTTOM w0.127: 17.47,60.19 17.47,60.3 17.68,60.52 18.21,60.52 18.47,60.26 C5409.2 ; 17.47,60.19 17.14,60.52 16.76,60.52 16.44,60.21 R5406.1 ; 17.47,60.19 v2(17.47,60.14)
HDMI_DATA2_R_C: length 9.4
  BOTTOM w0.127: R5406.2 14.74,60.1 R5415.2 14.38,60.46 14.04,60.46 13.66,60.84 13.53,60.84 13.4,60.71 EU5701.10 EU5701.1 11.33,60.71 11.2,60.84 9.57,60.84 7.92,62.49 7.6,62.49 7.5,62.38 HDMI1.1
HDMI_HPD_B: length 2.4
  BOTTOM w0.102: Q5401.B 19.1,77.42 R5411.2 v1(18.37,78.37)
HDMI_HPD_E: length 3.7
  BOTTOM w0.102: Q5401.E 20.89,77.6 R5412.1 R5419.2 v1(21.75,79.46)
HDMI_PLL_GND:
  vias: v1(19.86,67.89)
HOST_DEBUG_TX: length 105.2
  TOP w0.102: v2(176.01,73.63) 175.99,73.65 175.7,73.65 175.69,73.64 175.1,73.64 175.06,73.67 175.01,73.67 174.48,74.21 KBC24.81 173,74.21 172.72,74.5 172.72,75.35 R2478.1 ; R6115.1 172.04,52.31 v1(173.06,52.31) v2(174.56,52.31)
  L4 w0.102: v2(178.93,21.61) 178.93,23.7 178.18,24.44 178.18,29.54 177.94,29.79 177.94,32 176.48,33.45 176.48,35.7 176,36.18 176,49.9 174.56,51.34 v2(174.56,52.31) 174.77,52.51 174.77,53.41 174.3,53.89 174.3,56.7 174.6,57 174.6,58.31 174.3,58.62 174.3,64.84 174.6,65.15 174.71,65.15 176.78,67.22 176.78,72.19 176.06,72.91 176.06,73.59 v2(176.01,73.63)
  BOTTOM w0.102: v2(178.93,21.61) 176.97,19.66 174.88,19.66 173.44,18.22 173.44,11.27 169.39,7.22 164.29,7.22 161.17,10.34 161.17,18.08 160.02,19.22 158.19,19.22 R2466.2
HPD_HDMI_CON: length 21
  TOP w0.102: EU5703.2 EU5703.9 10.45,69.6 10.26,69.78 10.26,70.44 10.51,70.68 v2(10.51,71.22)
  BOTTOM w0.102: HDMI1.19 7.5,71.44 8.5,72.45 9.84,72.45 10.51,71.78 v2(10.51,71.22) 11.28,71.22 11.77,71.71 11.77,75.92 12.37,76.53 v1(15.69,76.53) R5410.1 R5411.1
I2C0_SCL: length 14.5
  TOP w0.14: v2(144.81,90.55) v1(144.25,90.55)
  L3 w0.127: v2(144.81,90.55) 144.2,90.55 142.88,89.23 141.47,89.23 140.99,88.74 v2(140.47,88.74)
  BOTTOM w0.089: CPU1.N3 134.49,87.86 135.17,87.86 135.25,87.81 135.52,87.81 135.68,87.88 137.14,87.88 137.25,87.99 138.7,87.99 138.76,88.04 139.34,88.04 139.39,87.99 139.72,87.99 v2(140.47,88.74)
  BOTTOM w0.14: RN2007.1 145.49,91.24 v2(144.81,90.55)
I2C0_SCL_TCH_PAD: length 338.4
  TOP w0.14: v2(55.76,72.94) 55.6,72.79 Q6503.1 ; R6518.1 50.14,75.74 50.05,75.66 EC6504.1 49.28,75.66 49.25,75.64 v2(48.87,75.64)
  L3 w0.127: v2(185.29,25.63) 185.29,26.01 183.73,27.57 183.36,27.57 182.61,28.33 181.35,28.33 176.3,33.38 176.3,35.43 175.14,36.59 170.67,36.59 167.87,33.79 145.61,33.79 v2(145.55,33.73) ; v2(185.72,97.64) 179.34,97.64 176.68,100.3 174.26,100.3 174.15,100.18 172.43,100.18 172.1,100.5 167.28,100.5 165.94,99.17 162.65,99.17 161.94,99.88 159.39,99.88 159.12,99.61 152.89,99.61 152.35,99.08 150.78,99.08 150.33,98.63 141.94,98.63 141.76,98.81 140.87,98.81 140.58,98.51 140.58,98.09 140.76,97.91 v2(140.76,97.74) ; v2(60.5,52.12) 60.5,52.31 59.79,53.03 59.79,59.95 54.58,65.16 51.41,65.16 46.77,69.8 46.77,74.33 48.07,75.64 v2(48.87,75.64) 50.47,77.23 53.35,77.23 54.5,76.08 54.5,74.2 v2(55.76,72.94)
  L4 w0.127: v2(132.76,85.51) 133.16,85.11 134.14,85.11 136.97,87.94 141.08,87.94 141.15,87.87 143.28,87.87 144.89,89.47 145.51,89.47 145.91,89.88 145.91,90.73 145.39,91.25 144.43,91.25 143.87,91.82 143.87,93.55 144.04,93.72 144.04,95.12 141.86,97.3 141.2,97.3 v2(140.76,97.74) ; v2(185.72,97.64) 186.24,97.12 186.24,96.2 185.82,95.78 185.82,91.45 188,89.27 188,87.43 188.87,86.56 188.87,81.32 189.02,81.17 189.02,80.33 188.7,80.01 188.7,73.42 188.89,73.23 188.89,71.56 189.16,71.29 189.16,67.79 188.87,67.5 188.87,67.02 189.23,66.66 189.23,60.44 188.56,59.78 188.56,58.1 187.69,57.23 187.69,54.27 187.47,54.06 187.47,43.88 188.1,43.25 188.1,27.8 185.93,25.63 v2(185.29,25.63)
  BOTTOM w0.14: v2(145.55,33.73) 145.44,33.84 145.33,33.84 144.39,34.78 144.39,35.51 144.09,35.82 134.55,35.82 v1(134.03,36.34) 128.58,41.78 123.37,41.78 120.45,44.69 82.07,44.69 74.98,51.78 60.84,51.78 v2(60.5,52.12) ; v2(132.76,85.51) 132.76,85.81 CPU1.U6
I2C0_SDA: length 14.2
  BOTTOM w0.089: CPU1.M4 134,88.68 134.23,88.68 134.44,88.47 134.54,88.47 134.64,88.52 134.84,88.52 134.92,88.48 135.2,88.48 135.29,88.52 135.49,88.52 135.58,88.48 136.98,88.48 137.12,88.61 138.54,88.61
  BOTTOM w0.14: 138.54,88.61 138.85,88.61 139.96,89.72 142.13,89.72 143.05,90.65 143.93,90.65 v1(144.48,91.19) 145.18,91.89 RN2007.2
I2C0_SDA_TCH_PAD: length 325.9
  TOP w0.14: v2(48.86,74.98) 49.07,74.77 EC6502.1 50.03,74.77 50.12,74.86 R6519.1 51.17,74.16 51.84,74.16 51.91,74.09 Q6503.4
  L3 w0.127: v2(48.86,74.98) 48.34,74.98 47.42,74.06 47.42,70.07 51.83,65.67 54.8,65.67 60.29,60.18 60.29,53.24 v2(60.74,52.79) ; v2(141.08,98.3) 141.55,98.3 141.73,98.12 150.54,98.12 150.99,98.57 152.56,98.57 153.1,99.1 159.33,99.1 159.6,99.37 161.67,99.37 162.39,98.66 166.16,98.66 167.49,100 171.89,100 172.22,99.67 174.36,99.67 174.47,99.79 176.47,99.79 179.13,97.13 185.48,97.13 v2(185.73,96.88) ; v2(185.8,26.22) 183.94,28.08 183.57,28.08 182.82,28.83 181.58,28.83 176.81,33.61 176.81,35.64 175.35,37.09 170.31,37.09 167.51,34.29 145.62,34.29 v2(145.55,34.36)
  L4 w0.127: v2(185.73,96.88) 185.73,96.41 185.32,95.99 185.32,91.24 187.46,89.1 187.46,87.25 188.36,86.35 188.36,81.11 188.51,80.96 188.51,80.54 188.19,80.22 188.19,73.21 188.38,73.02 188.38,71.35 188.65,71.08 188.65,68 188.35,67.7 188.35,66.82 188.72,66.45 188.72,60.66 188.06,59.99 188.06,58.31 187.18,57.44 187.18,54.48 186.85,54.16 186.85,43.78 187.6,43.04 187.6,28.01 v2(185.8,26.22) ; v2(141.08,98.3) 141.57,98.3 144.54,95.33 144.54,93.67 144.38,93.51 144.38,92.02 144.64,91.76 145.63,91.76 146.43,90.97 146.43,89.62 145.77,88.97 145.14,88.97 143.53,87.36 140.95,87.36 140.88,87.43 137.2,87.43 134.63,84.87 132.79,84.87 132.16,85.5 v2(132.12,85.5)
  BOTTOM w0.14: v2(132.12,85.5) 132.12,85.82 CPU1.U7 ; v2(60.74,52.79) 61.23,52.3 75.2,52.3 82.25,45.25 120.68,45.25 123.64,42.3 128.8,42.3 134.76,36.34 v1(135.59,36.34) 144.3,36.34 144.91,35.73 144.91,35 v2(145.55,34.36)
I2C1_SCL: length 12.4
  BOTTOM w0.089: 139.68,88.6 139.3,88.22 138.68,88.22 138.63,88.17 137.18,88.17 137.07,88.06 135.65,88.06 135.6,88.04 135.48,88 135.28,88 135.21,88.03 134.96,88.03 CPU1.N2
  BOTTOM w0.14: RN2008.1 145.99,89.2 145.76,89.43 v1(143.31,89.43) 142.63,89.43 142.37,89.16 140.24,89.16 139.68,88.6
I2C1_SCL_R: length 21.9
  TOP w0.14: Q6503.6 51.83,72.79 v2(51.54,72.5) ; v2(51.49,69.36) 51.49,69.36 R6515.2 51.68,70.44 RN6502.4 ; v2(51.89,76.29) 51.37,75.76 R6518.2 54.24,75.74 54.81,75.18 AFTP6237.1 59.11,75.77 TPAD1.6
  L3 w0.127: v2(51.49,69.36) 51.25,69.6 51.25,70.36 51.15,70.46 51.15,72.1 51.54,72.49 v2(51.54,72.5) 51.4,72.64 51.4,75.8 v2(51.89,76.29)
I2C1_SDA: length 11.6
  BOTTOM w0.089: CPU1.N1 137.02,88.26 137.1,88.35 138.55,88.35 138.6,88.4 139.05,88.4 139.5,88.84
  BOTTOM w0.14: 139.5,88.84 140.04,89.39 142.21,89.39 142.67,89.85 v1(144.68,89.85) RN2008.2
I2C1_SDA_R: length 16.9
  TOP w0.14: TPAD1.7 59.06,74.77 58.73,74.44 57.11,74.44 AFTP6240.1 55.61,74.04 55.56,74.09 Q6503.3 54.66,74.59 54.03,75.22 51.73,75.22 R6519.2 51.5,74.72 v2(52.16,74.72) ; RN6502.3 51.55,71.09 R6511.2 51.49,71.72 v2(51.61,71.84)
  L3 w0.127: v2(51.61,71.84) 52.38,72.6 52.38,73.86 52.16,74.07 v2(52.16,74.72)
I2CA_SCL: length 9
  BOTTOM w0.14: GPU1.B7 202.71,136.87 203.13,136.46 203.95,136.46 205.68,134.73 206.05,134.73 206.89,133.88 v1(207.91,133.88) 208.18,133.88 208.92,133.14 209.48,133.14 209.58,133.05 RN7603.3
I2CA_SDA: length 9
  BOTTOM w0.14: RN7603.4 210.23,133.2 209.85,133.58 209.09,133.58 208.32,134.35 206.92,134.35 206.19,135.08 205.94,135.08 v1(205.51,135.51) 204.15,136.87 GPU1.A7
I2CB_SCL: length 5.8
  TOP w0.14: v2(202.24,138.17) 203.35,137.06 204.57,137.06 204.67,137.16 v1(205.25,137.16) 205.51,137.16 205.56,137.11 206.07,137.11 206.44,137.49 RN7605.3
  BOTTOM w0.14: v2(202.24,138.17) 201.86,138.55 GPU1.C9
I2CB_SDA: length 5.6
  TOP w0.14: RN7605.4 206.83,136.83 206.13,136.83 205.85,136.55 v1(204.19,136.55) 203.88,136.55 203.63,136.81 202.7,136.81 v2(202.23,137.28)
  BOTTOM w0.14: GPU1.C8 201.85,137.66 v2(202.23,137.28)
I2CC_SCL: length 7.7
  BOTTOM w0.14: GPU1.A9 206.75,135.25 207.4,135.25 207.5,135.35 v1(208.24,135.35) 208.64,135.35 209.2,134.79 RN7604.4
I2CC_SDA: length 8.7
  BOTTOM w0.14: RN7604.3 209.16,134.14 208.49,134.8 v1(207.09,134.8) 206.86,134.8 203.78,137.88 203.58,138.08 203.12,138.08 GPU1.B9
I_ADP: length 16.4
  TOP w0.102: KBC24.110 180.48,67.58 180.92,68.02 180.92,68.83 v2(181.07,68.98) ; R2421.2 C2435.1 180.12,58.08 v2(180.24,58.21)
  BOTTOM w0.102: v2(180.24,58.21) 180.24,58.61 182.2,60.57 182.2,62.52 181.35,63.37 181.35,65.84 v1(181.03,66.16) 181.01,66.18 181.01,68.17 180.87,68.31 180.87,68.77 v2(181.07,68.98)
I_BATT: length 5.8
  TOP w0.203: 182.08,65.58 KBC24.114
  TOP w0.254: v2(183,64.84) 182.48,64.84 v1(182.3,65.03) 182.18,65.14 182.18,65.48 182.08,65.58
  BOTTOM w0.254: R2423.2 184.58,67.06 C2441.1 184.58,65.79 184.39,65.59 183.76,65.59 v2(183,64.84)
I_SYS: length 5.6
  TOP w0.203: 181.68,67.83 KBC24.113
  TOP w0.254: 181.68,67.83 181.68,68.25 v2(182.04,68.61)
  BOTTOM w0.254: C2427.1 181.98,66.41 182.4,66.83 R2422.2 181.72,67.06 v1(181.48,67.3) 181.48,68.06 v2(182.04,68.61)
ICSP_CLK_R: length 3.9
  BOTTOM w0.14: R2463.1 155.79,17.46 155.54,17.21 v1(155.54,16.8) 155.54,16.52 156.34,15.71 DB3.2
ICSP_CLOCK: length 91.3
  TOP w0.14: KBC24.101 176.88,65.76 176.74,65.62 173.98,65.62 172.91,64.56 v2(172.91,64.27)
  L4 w0.127: v2(172.91,64.27) 172.91,62.26 173.5,61.67 173.5,58.35 173.85,58 173.85,57.31 173.5,56.96 173.5,51.3 174.89,49.91 174.89,44.79 175.25,44.44 175.25,35.69 175.61,35.33 175.61,33.18 176.36,32.42 176.36,31.74 175.69,31.06 175.69,30.09 176.95,28.82 176.95,26.12 176.54,25.71 v2(176.54,21.92)
  BOTTOM w0.14: R2463.2 157.28,20.23 v1(158.64,20.23) 160.57,20.23 162.27,18.53 162.27,10.79 164.74,8.32 169.16,8.32 172.45,11.61 172.45,18.69 175.68,21.92 v2(176.54,21.92)
ICSP_CLR: length 97.5
  TOP w0.102: v2(176.59,72.99) 176.14,72.54 176.06,72.54 175.63,72.11 175,72.11 174.69,71.81 KBC24.87
  L4 w0.102: v2(176.59,72.99) 176.59,72.84 177.08,72.35 177.08,66.81 176.98,66.7 176.98,58.5 175.88,57.41 175.88,56.79 176.3,56.36 176.3,36.52 176.79,36.04 176.79,33.57 178.24,32.12 178.24,30.08 178.73,29.59 178.73,24.66 179.36,24.03 179.36,21.23 v2(178.99,20.86)
  BOTTOM w0.102: v2(178.99,20.86) v1(178.24,20.11) 177.48,19.35 175,19.35 173.75,18.1 173.75,11.15 169.44,6.84 163.95,6.84 160.66,10.13 160.66,18.11 160.02,18.75 R2414.1 R2465.2
ICSP_CLR_R: length 4.1
  BOTTOM w0.102: DB3.6 158.34,15.39 159.28,16.34 v1(159.28,16.81) 159.28,17.32 R2465.1
ICSP_DATA: length 92.5
  TOP w0.14: v2(176.28,68.6) 176.31,68.6 177.28,67.63 KBC24.102
  L4 w0.127: v2(176.55,21.14) 177.33,21.93 177.33,28.98 177.51,29.16 177.51,31.87 175.99,33.39 175.99,35.67 175.63,36.03 175.63,49.71 173.89,51.45 173.89,56.81 174.23,57.16 174.23,58.16 173.89,58.5 173.89,64.96 174.58,65.64 174.68,65.64 176.41,67.37 176.41,68.47 v2(176.28,68.6)
  BOTTOM w0.14: v2(176.55,21.14) 175.51,21.14 173.01,18.63 173.01,11.4 169.36,7.76 164.51,7.76 161.71,10.56 161.71,18.3 160.34,19.67 v1(159.81,19.67) 157.75,19.67 R2464.2
ICSP_DATA_R: length 3.4
  BOTTOM w0.14: DB3.3 v1(156.84,16.79) 156.84,17.83 R2464.1
IFPAB_IOVDD: length 9.9
  TOP w0.102: v2(189.03,135.59) 189.03,131.11 188.07,130.14 v1(187.76,130.14) 187.26,130.14 186.45,129.33 RN7402.3
  BOTTOM w0.102: v2(189.03,135.59) 189.03,135.61 GPU1.W6 GPU1.Y6
IFPAB_PLLVDD: length 10.2
  TOP w0.102: v2(189.03,136.41) 188.62,136 188.62,132.09 v1(186.53,130.01) 185.8,129.27 RN7402.4
  BOTTOM w0.102: GPU1.V7 v2(189.03,136.41) GPU1.W7
IFPC_IOVDD: length 8.6
  TOP w0.102: RN7401.3 188.5,129.58 v1(188.99,130.07) 190.32,131.4 190.32,134.43 v2(191.49,135.6)
  BOTTOM w0.102: GPU1.R6 191.9,136.01 v2(191.49,135.6)
IFPC_PLLVDD: length 11
  TOP w0.102: v1(191.98,136.94) 191.98,136.88 v2(191.51,136.41) 189.41,134.31 189.41,131.12 187.85,129.56 RN7401.4
  BOTTOM w0.102: GPU1.T7 v2(191.51,136.41) GPU1.R7
IFPD_IOVDD: length 8
  TOP w0.102: RN7404.3 191.44,129.42 v1(191.77,129.75) 191.77,134.98 v2(192.36,135.57)
  BOTTOM w0.102: v2(192.36,135.57) 192.75,135.96 GPU1.P6
IFPD_PLLVDD: length 10.9
  TOP w0.102: RN7404.4 189.95,130.37 191.22,131.64 191.22,134.74 191.92,135.44 191.92,136.01 v2(192.32,136.41) 192.78,136.41 v1(192.97,136.22)
  BOTTOM w0.102: GPU1.M7 GPU1.N7 192.71,136.81 v2(192.32,136.41)
IFPEF_IOVDD: length 3.2
  TOP w0.102: v2(197.3,136.4) 197,136.4 196.86,136.55 v1(196.86,136.79) 197.07,137 RN7403.4
  BOTTOM w0.102: GPU1.H6 197.32,136.4 v2(197.3,136.4) 197.28,136.38 197.24,136.38 GPU1.J6
IFPEF_PLLVDD: length 4.4
  TOP w0.102: v2(196.47,136.39) 196.47,137.83 196.65,138.01 v1(196.76,138.01) 197.21,138.01 197.57,137.65 RN7403.3
  BOTTOM w0.102: GPU1.K7 196.07,136.79 v2(196.47,136.39) 196.47,136.39 196.87,136.78 GPU1.J7
INT_TP#: length 282.8
  TOP w0.102: v2(55.79,75.87) 55.81,75.89 R6514.1 55.86,76.69 AFTP6241.1 58.42,77.77 TPAD1.4 ; R2431.1 189.25,84.78 189.54,85.07 v2(190.62,85.07)
  L3 w0.102: v2(55.79,75.87) 62.91,68.75 62.91,40.04 61.86,38.98 61.86,36.13 63.31,34.68 63.31,32.82 64.32,31.81 65.59,31.81 65.84,31.56 66.76,31.56 74.18,24.14 74.18,23.95 74.84,23.29 74.84,19.74 78.53,16.06 91.63,16.06 96.36,11.33 129.77,11.33 135.68,17.23 138.23,17.23 139.61,18.61 139.83,18.83 139.83,21.1 140.98,22.26 v2(140.98,23.06) ; v2(135.93,68.61) 136.06,68.49 137.96,68.49 139.01,67.44 139.11,67.44 139.23,67.32 140.93,67.32 141.1,67.16 146.11,67.16 147.03,68.08 151.23,68.08 151.76,68.61 153.39,68.61 153.92,68.08 160.14,68.08 161.9,69.83 164.47,69.83 164.82,70.18 168.09,70.18 169.39,68.89 170.01,68.89 170.27,68.63 170.27,67.32 171.45,66.13 172.94,66.13 173.51,66.71 177.93,66.71 178.05,66.59 187.16,66.59 187.73,67.16 189.22,67.16 v2(189.31,67.25)
  L4 w0.102: v2(140.98,23.06) 140.86,23.18 140.86,26.32 143.17,28.63 143.17,32.8 144.34,33.96 144.34,35.62 142.87,37.09 142.87,45.27 140.05,48.09 140.05,48.44 139.47,49.03 139.47,49.53 138.88,50.12 138.88,53.04 139.57,53.73 139.57,54.08 138.93,54.72 138.93,55.17 139.75,55.99 139.75,56.67 139.69,56.72 139.69,62.18 138.88,63 138.88,63.56 138.61,63.83 138.61,65.64 137.63,66.63 135.88,66.63 135.05,67.46 135.05,67.79 135.28,68.02 135.34,68.02 v2(135.93,68.61)
  BOTTOM w0.102: v2(189.31,67.25) 189.52,67.46 189.52,72.65 189.84,72.97 189.84,78.99 190.35,79.49 190.35,80.27 190.73,80.65 v1(190.73,81.92) 190.73,82.72 191.14,83.13 191.14,84.55 v2(190.62,85.07) ; v2(135.93,68.61) 136.61,69.29 R2045.1
IR_CAMERA_DET#: length 323.6
  TOP w0.127: v2(95.5,14.81) 87.55,14.81 87.19,14.46 v2(87.19,13.92)
  L3 w0.127: v2(95.5,14.81) 97.12,13.19 115.18,13.19 116.78,14.79 117.85,14.79 118.26,14.38 120.54,14.38 120.95,14.79 132.71,14.79 135.55,17.63 137.31,17.63 138.12,18.44 138.12,20.4 140.38,22.66 140.38,25.91 143.58,29.11 v2(143.58,34.02) ; v2(92.88,146.11) 92.83,146.11 89.89,143.16 89.89,137.65 90.83,136.71 90.83,133.66 94.28,130.2 94.28,127.56 93.44,126.73 93.44,124.01 94.13,123.32 94.13,118.93 87.27,112.07 87.27,103.33 65.55,81.61 64.92,81.61 63.19,79.89 63.19,76.69 63.75,76.13 v2(63.75,61.02)
  L4 w0.127: v2(87.19,13.92) 86.74,14.38 78,14.38 76.58,15.8 73.99,15.8 72.99,16.79 71.88,16.79 69.95,18.72 69.95,21.87 66.37,25.46 66.37,25.56 64,27.92 62.78,27.92 61.31,29.39 57.68,29.39 56.23,30.84 56.23,32.08 56.79,32.64 56.79,35.59 57.17,35.97 57.17,36.86 56.64,37.39 54.6,37.39 53.11,35.89 52.57,35.89 52.01,36.45 52.01,57.54 53.84,59.36 62.1,59.36 v2(63.75,61.02) ; v2(143.58,34.02) 143.4,34.19 143.4,34.47 142.62,35.26 142.62,45.09 142.57,45.14 142.57,45.22 139.8,47.99 139.8,48.29 139.21,48.87 139.21,49.38 138.63,49.97 138.63,55.38 139.01,55.76 139.16,55.76 139.49,56.09 139.49,56.57 139.42,56.65 139.42,62.11 138.63,62.89 138.63,63.35 137.33,64.65 135.25,64.65 134.03,65.87 134.03,66.12 133.22,66.93 133.22,68.28 131.49,70.01 131.49,70.46 131.14,70.82 131.14,71.91 131.47,72.24 131.95,72.24 133.42,70.77 v2(134.69,70.77)
  BOTTOM w0.089: CPU1.AY7 131.96,73.76 132.3,73.41 132.3,72.09 133.4,71
  BOTTOM w0.127: v2(134.69,70.77) 134.46,71 133.4,71 ; R5540.2 R2051.2 89.72,150.12 EC5504.1 91.03,148.81 91.03,146.74 v1(91.66,146.11) v2(92.88,146.11)
IR_CAMERA_DET#_R: length 3
  TOP w0.127: v2(92.48,151.16) 92.69,151.37 IRCCD1.4
  BOTTOM w0.127: R5540.1 92.25,150.93 v2(92.48,151.16) v1(92.96,151.64)
ISOLATE#: length 4
  TOP w0.102: LOM31.20 49.81,168.77 50.18,168.4 v1(50.36,168.4) 50.98,168.4 R3106.2 51.41,167.97 R3107.1
ITP_PMODE: length 1.7
  TOP w0.102: v2(130.77,92.04) 131.29,91.51 TP9922.1
  BOTTOM w0.102: CPU1.E8 131.09,92.36 v2(130.77,92.04)
JACK_PLUG: length 12.1
  TOP w0.254: R2923.1 17.52,13.03 17.52,14.34 ED305.1 16.75,14.11 16.75,13.54 16.6,13.39 v1(16.6,12.95) 16.6,12.72 16.23,12.35 11.79,12.35 11.23,12.91 9.74,12.91 HPMIC1.5
JACK_PLUG_DET: length 13.5
  TOP w0.254: R307.1 14.66,13.11 15.05,13.5 15.05,13.68 15.45,14.08 ED301.1 14.73,14.61 13.86,13.75 13.86,13.27 v1(13.7,13.11) 13.45,12.86 12,12.86 11.44,13.42 10.32,13.42 9.91,13.83 6.81,13.83 6.55,13.57 HPMIC1.6
JDREF: length 4.2
  TOP w0.102: HDA27.15 28.75,19.42 29.12,19.78 29.12,20.92 v1(28.32,21.72) 28.32,22.55 R2707.1
KB_BL_CTRL#: length 19.1
  TOP w0.508: 194.32,97.13 194.32,99.66 192.99,100.99 192.99,103.92 AFTP6247.1 v1(194.12,109.1) 194.12,110.74 196.88,113.5 Q6501.D
KB_DET#: length 104.6
  TOP w0.102: v2(189.7,87.88) 189.7,88.18 187.92,89.97 186.24,89.97 186.08,89.8 181.53,89.8 181.39,89.66 177.73,89.66 AFTP6202.1 ; KB1.30 190.1,93.52 v2(190.05,93.48)
  L3 w0.102: v2(184.44,68.7) 183.98,68.24 183.98,67.36 183.53,66.91 173.43,66.91 172.85,66.33 171.56,66.33 170.71,67.18 170.71,68.7 170.3,69.12 169.45,69.12 168.18,70.38 164.74,70.38 164.39,70.03 161.78,70.03 160.05,68.31 153.98,68.31 153.47,68.81 151.66,68.81 151.15,68.31 148.81,68.31 148.81,68.31 146.98,68.31 146.03,67.36 141.18,67.36 141.01,67.53 139.79,67.53 138.82,68.5 138.82,68.85 138.56,69.11 135.74,69.11 v2(135.27,68.63)
  BOTTOM w0.089: 133.03,71.07 133.03,71.09 132.01,72.1 CPU1.BB7
  BOTTOM w0.102: 133.03,71.07 133.41,70.69 134.08,70.69 135.07,69.7 135.28,69.7 135.35,69.63 135.35,69.55 135.62,69.28 R2009.1 135.27,68.74 v2(135.27,68.63) ; v2(184.44,68.7) 183.98,69.17 183.98,70.14 184.25,70.42 184.25,74.15 184.77,74.68 184.77,75.95 185.11,76.29 185.11,79.01 186.37,80.28 186.37,80.59 189.36,83.57 189.36,87.53 v2(189.7,87.88) 189.7,93.13 v2(190.05,93.48)
KB_LED_BL_DET: length 110.7
  TOP w0.102: v2(138.51,86.54) 138.85,86.89 141.72,86.89 142.07,86.54 147.47,86.54 148.29,87.37 151.38,87.37 152.55,88.54 162.01,88.54 163.37,89.9 165.81,89.9 166.26,90.34 167.48,90.34 169.45,88.38 174.68,88.38 175.79,87.27 176.42,87.27 v2(176.43,87.27) ; R6503.1 196.26,110.34 R6507.1 196.26,110.79 v1(197.46,111.99) 199.98,114.52 199.98,117.07 198.32,118.72 196.85,118.72 196.1,119.47 190.63,119.47 188.9,117.73 188.9,114.55 184.46,110.12 179.74,110.12 179.55,109.93 v2(179.55,109.93)
  L4 w0.102: v2(131.35,84.43) 131.85,83.93 133.07,83.93 133.42,84.28 135.04,84.28 136.44,85.69 137.65,85.69 v2(138.51,86.54) ; v2(176.43,87.27) 176.7,87.27 177.32,87.89 177.32,90.67 177.47,90.81 177.47,94.93 179.03,96.49 179.03,102.05 179.66,102.68 179.66,109.82 v2(179.55,109.93)
  BOTTOM w0.102: v2(131.35,84.43) 131.68,84.77 CPU1.W8
KB_LED_DET_C: length 17
  TOP w0.102: KBLIT1.2 194.8,94.42 195.01,94.62 195.01,100.36 AFTP6246.1 193.55,101.82 193.55,103.65 194.69,104.79 194.69,107.96 195.36,108.62 C6502.1 R6503.2
KBC_BEEP_R: length 3.6
  TOP w0.254: D2701.1 37.26,21.63 37.72,22.08 RN2701.4 38,23.05 v1(37.67,23.38)
KBC_PWRBTN#: length 115.9
  TOP w0.102: R6403.1 217.77,149.89 212.67,144.78 212.67,140.87 215.79,137.75 215.79,135.06 215.04,134.31 215.04,133.61 214.69,133.25 214.69,132.56 212.86,130.72 v1(212.54,130.72) 212.15,130.72 207.95,126.52 207.19,126.52 206.78,126.11 206.78,125.67 206.46,125.35 203.47,125.35 202.62,126.21 201.09,126.21 199.92,125.04 199.92,121.53 198.97,120.58 197.66,120.58 196.46,121.78 196.46,122.48 195.96,122.99 v2(195.22,122.99) ; R2432.1 189.73,63.34 v2(189.81,63.26)
  L4 w0.102: v2(187.23,114.95) 187.75,114.43 187.75,90.95 188.98,89.71 188.98,87.62 189.37,87.24 189.37,81.44 189.45,81.35 189.45,77.69 189.39,77.63 189.39,77.28 189.19,77.08 189.19,73.63 189.4,73.42 189.4,72.22 189.39,72.2 189.39,71.76 189.7,71.45 189.7,67.91 189.69,67.9 189.69,67.54 189.77,67.46 189.77,66.85 189.7,66.78 189.7,65.82 189.81,65.71 v2(189.81,63.26)
  BOTTOM w0.102: v2(195.22,122.99) 194.9,122.99 193.33,121.42 192.41,121.42 187.23,116.23 v2(187.23,114.95)
KBC_PWRBTN#_C: length 31.7
  TOP w0.127: v2(214.14,149.79) 214.17,149.76 216.77,149.76 R6403.2 216.91,149.9 G6402.2 216.91,152.32 EC6401.1 ED6401.1 216.92,154.65 AFTP6101.1 216.91,165.96 216.2,166.67 PWR1.2 216.2,169.29 218.45,171.53 PWSW2.4 PWSW2.3
  BOTTOM w0.127: v2(214.14,149.79) G6401.2
KSI0: length 54.8
  TOP w0.102: KB1.22 190.75,100.65 192.08,99.31 v2(192.08,99.29) ; v2(188.44,88.52) 188.44,88.71 187.6,89.56 186.41,89.56 186.25,89.39 181.7,89.39 181,88.69 AFTP6228.1 ; v2(182.39,74.17) 181.96,73.74 180.53,73.74 175.36,68.57 175.36,67.77 175.68,67.45 KBC24.98
  BOTTOM w0.102: RN2412.8 192.72,98.99 192.41,99.29 v2(192.08,99.29) 190.7,97.92 190.7,97.25 188.66,95.2 188.66,88.73 v2(188.44,88.52) 187.98,88.06 187.98,85.22 188.54,84.66 188.54,83.91 185.56,80.93 185.56,80.62 184.29,79.35 184.29,76.64 183.94,76.29 183.94,75.73 v2(182.39,74.17)
KSI1: length 44.1
  TOP w0.102: KBC24.99 176.08,67.48 175.93,67.62 175.8,67.62 175.56,67.86 175.56,68.49 180.11,73.04 v2(182.82,73.04) ; v2(192.28,97.16) 192.28,97.96 AFTP6227.1 191.19,99.05 KB1.24
  BOTTOM w0.102: RN2412.6 192.59,97.84 192.28,97.52 v2(192.28,97.16) 189.08,93.96 189.08,88.26 188.95,88.13 188.95,83.74 185.97,80.76 185.97,80.45 184.7,79.18 184.7,76.46 184.36,76.12 184.36,74.84 183.43,73.92 183.43,73.65 v2(182.82,73.04)
KSI2: length 41.2
  TOP w0.102: KBC24.6 188.45,70.21 187.93,70.73 187.46,70.73 185.58,72.62 v2(184.79,72.62) ; KB1.26 190.88,97.45 191.82,96.5 191.82,94.34 AFTP6218.1 192.61,94.32 192.61,95.22 v2(192.52,95.3)
  BOTTOM w0.102: v2(184.79,72.62) 184.73,72.68 184.73,74.27 184.97,74.51 184.97,75.87 185.31,76.2 185.31,78.93 186.61,80.23 187.24,80.23 187.53,80.51 187.53,81.46 189.56,83.49 189.56,87.11 190.22,87.77 190.22,92.3 190.63,92.71 190.63,94.08 191.86,95.31 192.52,95.31 v2(192.52,95.3) 194.19,93.64 RN2411.8
KSI3: length 52.8
  TOP w0.102: KB1.23 190.91,99.85 192.12,98.63 v2(192.35,98.63) ; v2(182.8,73.68) 184.89,73.68 187.63,70.94 188.01,70.94 188.34,70.61 KBC24.7 ; v2(188.47,87.61) 188.2,87.89 188.18,87.89 187.78,88.29 187.78,88.71 187.34,89.15 186.58,89.15 186.42,88.99 182,88.99 181.56,88.55 181.56,86.82 180.09,85.35 180.04,85.35 AFTP6234.1
  BOTTOM w0.102: RN2412.7 192.64,98.34 v2(192.35,98.63) 191.2,97.48 191.2,96.81 188.87,94.48 188.87,88.34 188.47,87.94 v2(188.47,87.61) 188.75,87.34 188.75,83.83 185.76,80.84 185.76,80.53 184.5,79.27 184.5,76.56 184.14,76.2 184.14,75.03 v2(182.8,73.68)
KSI4: length 49.7
  TOP w0.102: KBC24.104 178.08,67.99 178.16,68.08 178.16,69.19 179.89,70.92 181.3,70.92 181.98,71.61 183.12,71.61 183.45,71.94 183.95,71.94 184.73,71.16 185.33,71.16 186.26,70.23 v2(186.54,70.23) ; v2(192.22,93.22) 191.96,93.22 191.37,92.62 AFTP6230.1 190.82,93.01 191.33,93.51 191.33,96.2 190.88,96.65 KB1.27
  BOTTOM w0.102: v2(186.54,70.23) 186.54,70.23 186.73,70.42 186.73,71.19 186.34,71.59 186.34,74.08 185.35,75.07 185.35,75.92 185.51,76.09 185.51,78.85 186.69,80.03 187.96,80.03 188.54,80.61 188.54,82.18 189.76,83.41 189.76,87.02 190.43,87.68 190.43,92.02 191.63,93.22 v2(192.22,93.22) 192.37,93.37 193.11,93.37 193.49,92.99 RN2411.7
KSI5: length 43.3
  TOP w0.102: KBC24.105 178.48,69.22 179.98,70.72 181.38,70.72 182.07,71.4 v2(183.7,71.4) ; v2(192.68,96.48) 192.68,95.96 192.57,95.85 AFTP6214.1 192.09,95.99 192.09,96.62 191.5,97.21 191.5,97.65 190.9,98.25 KB1.25
  BOTTOM w0.102: v2(183.7,71.4) 183.7,72.3 183.64,72.36 183.64,73.84 184.57,74.76 184.57,76.03 184.9,76.37 184.9,79.1 186.17,80.36 186.17,80.68 189.15,83.66 189.15,88.05 189.28,88.17 189.28,93.32 192.45,96.48 v2(192.68,96.48) 193.18,96.98 RN2412.5
KSI6: length 65.7
  TOP w0.102: AFTP6222.1 178.61,86.3 179.32,85.59 180.04,85.59 181.36,86.91 181.36,88.76 181.79,89.19 186.33,89.19 186.5,89.36 187.42,89.36 187.98,88.79 187.98,88.37 188.26,88.09 188.67,88.09 188.91,87.85 188.91,87.55 189.78,86.67 v2(190.27,86.67) ; v2(187.88,68.44) 186.56,68.44 184.95,70.05 184.16,70.05 183.73,69.62 180.79,69.62 180.35,69.18 179.95,69.18 179.28,68.51 KBC24.107 ; v2(192.42,92.3) 191.41,92.3 191.38,92.27 190.68,92.27 190.47,92.48 190.47,92.95 191.13,93.62 191.13,95.62 190.9,95.85 KB1.28
  BOTTOM w0.102: RN2411.6 192.61,92.49 v2(192.42,92.3) 192.41,92.29 191.39,92.29 190.63,91.54 190.63,87.6 190.27,87.23 v2(190.27,86.67) 189.97,86.38 189.97,83.32 188.77,82.13 188.77,80.45 187.44,79.12 186.57,79.12 185.72,78.27 185.72,76.01 185.55,75.84 185.55,75.16 186.54,74.16 186.54,74 186.54,74 186.54,71.72 187.01,71.26 187.01,69.31 v2(187.88,68.44)
KSI7: length 66.5
  TOP w0.102: v2(191.61,91.75) 190.91,91.75 190.26,92.39 190.26,93.07 190.93,93.73 190.93,94.84 190.72,95.05 KB1.29 ; AFTP6221.1 177.32,85.22 177.32,88.56 178.21,89.46 181.47,89.46 181.61,89.6 186.16,89.6 186.33,89.76 187.84,89.76 189.24,88.36 189.24,87.72 189.6,87.36 190.47,87.36 v2(190.74,87.1) ; v2(187.9,67.8) 187.89,67.81 186.9,67.81 184.86,69.85 184.25,69.85 183.81,69.41 180.87,69.41 180.4,68.95 180.24,68.95 179.68,68.39 KBC24.108
  BOTTOM w0.102: RN2411.5 193.24,91.84 193.15,91.75 v2(191.61,91.75) 191.29,91.75 190.88,91.33 190.88,87.23 v2(190.74,87.1) 190.74,87.06 190.7,87.01 190.7,86.41 190.17,85.88 190.17,83.24 188.98,82.04 188.98,79.93 187.29,78.24 186.86,78.24 185.92,77.3 185.92,75.92 185.75,75.76 185.75,75.24 186.74,74.25 186.74,73.91 186.74,73.91 186.74,71.83 188.31,70.26 188.31,68.21 v2(187.9,67.8)
KSO0: length 57.3
  TOP w0.102: KBC24.2 188.32,68.61 188.06,68.87 186.42,68.87 185.02,70.26 183.3,70.26 183.29,70.27 183.09,70.27 v2(183.04,70.22) ; KB1.13 191.53,107.85 AFTP6207.1 192.58,108.91 v2(192.58,109.45)
  BOTTOM w0.102: v2(183.04,70.22) 183.04,72.2 181.95,73.29 181.95,74.37 182.54,74.95 182.54,77.48 182.39,77.63 182.39,78.44 181.67,79.16 181.67,83.73 182.16,84.22 182.16,84.6 182.16,86.35 182.89,87.07 182.89,88.91 185.02,91.04 185.02,94.23 187.49,96.7 187.49,100.65 190.24,103.4 190.24,107.1 v2(192.58,109.45) 193.17,110.03 193.69,110.03 193.92,110.26 RN2404.5
KSO1: length 49.2
  TOP w0.102: v2(183.5,76.23) 184.48,76.23 186.68,74.02 186.71,74.02 187.32,73.41 KBC24.14 ; KB1.15 190.97,106.25 191.21,106.01 v2(192.61,106.01) ; AFTP6206.1 181.99,85.42 183.58,87.02 183.58,87.78 v2(183.61,87.78)
  BOTTOM w0.102: v2(183.5,76.23) 183.93,76.66 183.93,77.04 183.68,77.3 183.31,77.3 183.05,77.55 183.05,78.35 182.08,79.33 182.08,83.56 182.57,84.05 182.57,84.76 182.57,84.77 182.57,86.18 183.61,87.22 v2(183.61,87.78) 183.61,88.84 185.52,90.75 185.52,94.16 187.89,96.53 187.89,100.43 190.65,103.18 190.65,104.28 192.38,106.01 v2(192.61,106.01) 192.81,106.21 RN2409.7
KSO2: length 46.8
  TOP w0.102: v2(192.43,107.29) 192.43,106.82 AFTP6226.1 191.27,106.62 190.84,107.05 KB1.14 ; v2(183.5,76.86) 184.15,76.86 187.21,73.81 KBC24.15
  BOTTOM w0.102: RN2409.8 192.86,106.86 v2(192.43,107.29) 190.44,105.31 190.44,103.32 187.69,100.56 187.69,96.62 185.22,94.15 185.22,90.95 183.09,88.82 183.09,86.99 182.37,86.26 182.37,84.68 182.37,84.14 181.88,83.65 181.88,79.24 182.6,78.52 182.6,77.72 183.45,76.86 v2(183.5,76.86)
KSO3: length 43.9
  TOP w0.102: KB1.16 191.12,105.45 191.87,104.7 AFTP6208.1 192.34,104.8 v2(192.34,105.35) ; KBC24.16 187.18,74.21 183.66,77.73 v2(183.5,77.73)
  BOTTOM w0.102: RN2409.6 193.07,105.71 192.71,105.35 v2(192.34,105.35) 190.85,103.87 190.85,103.1 188.1,100.34 188.1,96.45 187.44,95.79 187.44,91.76 184.07,88.39 184.07,87.35 182.77,86.05 182.77,83.97 182.28,83.48 182.28,79.41 183.27,78.42 183.27,77.96 v2(183.5,77.73)
KSO4: length 42
  TOP w0.102: KB1.20 191.01,102.25 191.53,101.73 191.53,101.08 191.79,100.82 v2(192.33,100.82) ; v2(183.21,79.15) 183.64,78.72 184.04,78.72 186.08,80.75 KBC24.37 ; AFTP6224.1 183.61,86.38 184.06,86.83 184.06,88.09 184.47,88.5 185.29,88.5 186.62,88.5 186.96,88.5 v2(187.01,88.45)
  BOTTOM w0.102: 187.03,88.45 187.03,89.04 188.25,90.26 188.25,95.45 188.91,96.11 188.91,96.74 188.91,96.74 188.91,97.4 v2(192.33,100.82) 192.67,101.16 192.67,102.28 192.77,102.38 RN2410.6 ; 187.03,88.45 187.45,88.03 187.45,83.4 185.16,81.1 185.16,80.79 183.97,79.6 183.53,79.6 183.21,79.27 v2(183.21,79.15) ; 187.03,88.45 v2(187.01,88.45)
KSO5: length 35
  TOP w0.102: KBC24.38 185.68,80.99 v2(183.84,79.15) ; KB1.21 191,101.45 191.21,101.23 191.21,100.56 191.88,99.89 AFTP6215.1 192.66,99.89 v2(192.9,100.13)
  BOTTOM w0.102: v2(183.84,79.15) 183.84,79.18 185.36,80.7 185.36,81.02 188.33,83.99 188.33,84.58 187.76,85.16 187.76,88.82 188.45,89.51 188.45,95.37 189.11,96.03 189.11,96.35 190.42,97.66 190.42,98.24 192.18,100.01 192.77,100.01 v2(192.9,100.13) 193.28,100.52 RN2410.5
KSO6: length 36.4
  TOP w0.102: v2(185.31,87.19) 185.31,87.18 185.32,87.18 185.32,87.05 185.69,86.68 AFTP6223.1 ; KBC24.39 185.28,80.92 183.95,79.6 183.59,79.6 182.9,80.29 v2(182.79,80.29) ; KB1.18 191.19,103.85 191.58,103.46 v2(192.16,103.46)
  BOTTOM w0.102: RN2410.8 192.24,103.53 v2(192.16,103.46) 188.5,99.8 188.5,96.28 187.84,95.62 187.84,91.23 185.03,88.42 185.03,87.68 185.31,87.39 v2(185.31,87.19) 185.31,87.18 185.32,87.18 185.32,86.58 184.27,85.53 184.12,85.53 184.02,85.42 184.02,84.1 184.09,84.03 184.09,83.21 184.02,83.14 184.02,81.53 182.79,80.3 v2(182.79,80.29)
KSO7: length 35.9
  TOP w0.102: v2(191.98,101.35) 191.99,101.35 191.99,101.36 192.25,101.62 AFTP6213.1 192.25,102.18 191.37,103.05 KB1.19 ; KBC24.50 180.88,81.3 182.51,79.66 v2(182.81,79.66)
  BOTTOM w0.102: v2(182.81,79.66) 183.35,80.2 183.35,80.22 183.59,80.46 184.34,80.46 184.89,81.01 184.89,81.13 187.24,83.48 187.24,87.56 186.55,88.25 186.55,89.03 188.05,90.53 188.05,95.53 188.71,96.19 188.71,96.82 188.71,96.82 188.71,97.16 188.71,97.16 188.71,98.07 191.98,101.34 v2(191.98,101.35) 192.28,101.65 192.28,102.51 192.65,102.88 RN2410.7
KSO8: length 36.2
  TOP w0.102: v2(192.02,104.17) 191.64,104.17 191.16,104.65 KB1.17 ; v2(184.5,87.7) 184.59,87.62 185.49,87.62 185.94,87.17 185.94,86.94 186.68,86.19 AFTP6231.1 ; v2(182.8,80.93) 182.48,81.25 KBC24.46
  BOTTOM w0.102: RN2409.5 192.91,105.06 v2(192.02,104.17) 191.05,103.21 191.05,102.98 188.3,100.22 188.3,96.36 187.64,95.7 187.64,91.67 184.5,88.53 v2(184.5,87.7) 184.5,87.28 183.15,85.94 183.15,81.28 v2(182.8,80.93)
KSO9: length 61.4
  TOP w0.102: v2(180.13,79.76) 180.13,79.76 179.71,79.76 177.9,77.96 176.45,77.96 176.09,78.32 176.09,78.54 175.97,78.67 175.97,79.32 175.71,79.58 174.84,79.58 174.67,79.41 KBC24.68 172.73,79.41 172.36,79.04 172.29,79.04 172.16,78.91 R2449.2 171.75,78.1 R2450.1 ; v2(192.89,115.37) 193.74,115.37 193.94,115.56 AFTP6219.1 193.94,116.06 193.68,116.32 192.49,116.32 192.08,115.91 192.08,115.27 191.86,115.05 191.86,113.58 190.92,112.65 KB1.7
  BOTTOM w0.102: v2(180.13,79.76) 180.23,79.76 180.44,79.96 180.44,82 179.53,82.91 179.53,84.21 180.92,85.6 180.92,86.86 181.67,87.61 181.67,89.41 183.8,91.55 183.8,94.74 184.41,95.34 184.41,101.57 189.02,106.19 189.02,111.49 v2(192.89,115.37)
KSO10: length 62.9
  TOP w0.102: v2(194.65,117.29) 194.65,117.29 194.65,118.21 AFTP6232.1 193.21,118.28 191.67,116.75 191.67,115.44 191.45,115.22 191.45,114.76 190.94,114.25 KB1.5 ; v2(179.52,78.14) 178.86,77.47 175.15,77.47 174.82,77.81 KBC24.72
  BOTTOM w0.102: v2(179.52,78.14) 179.37,78.29 179.37,80.75 179.65,81.03 179.65,82.06 179.12,82.59 179.12,84.38 180.51,85.77 180.51,87.04 181.26,87.79 181.26,89.58 183.39,91.71 183.39,101.32 188.61,106.54 188.61,112.61 193.31,117.3 194.63,117.3 v2(194.65,117.29) 194.65,117.3 194.83,117.12 RN2403.8
KSO11: length 61.6
  TOP w0.102: KB1.6 190.9,113.45 191.66,114.2 191.66,115.14 191.88,115.36 191.88,116.45 AFTP6220.1 v2(193.95,116.83) ; v2(179.62,77.35) 179.5,77.22 175.2,77.22 174.99,77.01 KBC24.74
  BOTTOM w0.102: v2(179.62,77.35) 179.95,77.68 179.95,78.32 179.57,78.7 179.57,80.65 179.92,81 179.92,82.11 179.33,82.71 179.33,84.29 180.72,85.68 180.72,86.96 181.46,87.7 181.46,89.5 183.6,91.63 183.6,94.82 184.2,95.43 184.2,101.73 188.82,106.34 188.82,112.52 193.12,116.83 v2(193.95,116.83) 193.95,115.45 194.31,115.09 RN2403.7
KSO12: length 51.7
  TOP w0.102: KB1.12 190.99,108.65 191.35,109.01 191.35,109.58 AFTP6233.1 192.24,110.48 v2(192.83,110.48) ; v2(181.96,78.23) 180.86,78.23 180.41,77.78 180.41,77.52 179.8,76.92 175.29,76.92 174.99,76.61 KBC24.75
  BOTTOM w0.102: RN2404.6 193.92,110.91 193.49,110.48 v2(192.83,110.48) 190.04,107.68 190.04,103.48 187.28,100.73 187.28,96.79 184.82,94.32 184.82,91.12 182.68,88.99 182.68,87.16 181.96,86.43 181.96,84.51 181.96,84.51 181.96,84.31 181.47,83.82 181.47,79.07 181.96,78.59 v2(181.96,78.23)
KSO13: length 56.2
  TOP w0.102: KB1.9 190.88,111.05 192.21,112.38 AFTP6203.1 192.21,113.36 v2(192.79,113.94) ; KBC24.76 174.96,76.21 175.46,76.71 179.95,76.71 v2(180.84,77.6)
  BOTTOM w0.102: v2(180.84,77.6) 181.1,77.85 181.1,78.58 180.86,78.82 180.86,83.24 180.22,83.88 180.22,84.32 181.33,85.43 181.33,86.67 182.07,87.42 182.07,89.24 184.21,91.38 184.21,94.57 184.86,95.22 184.86,101.45 189.43,106.02 189.43,110.57 v2(192.79,113.94) RN2403.5
KSO14: length 59.8
  TOP w0.102: KBC24.77 174.86,75.81 175.56,76.51 180.65,76.51 v2(181.32,77.18) ; KB1.8 191.01,111.85 191.67,112.52 191.67,113.11 192.23,113.67 AFTP6216.1 192.96,114.88 v2(193.13,114.72)
  BOTTOM w0.102: RN2403.6 193.93,114.59 193.8,114.72 v2(193.13,114.72) 192.96,114.72 189.22,110.98 189.22,106.1 184.65,101.53 184.65,95.31 184,94.65 184,91.46 181.87,89.33 181.87,87.51 181.12,86.76 181.12,85.52 179.75,84.15 179.75,83.05 180.66,82.15 180.66,78.03 180.41,77.78 180.41,77.42 180.66,77.17 181.29,77.17 181.3,77.18 v2(181.32,77.18)
KSO15: length 60.7
  TOP w0.102: KBC24.86 174.61,72.21 174.84,72.44 175.51,72.44 176.16,73.09 176.16,73.17 176.42,73.42 178.92,73.42 v2(180.75,75.25) ; KB1.10 190.93,110.25 192.76,112.09 192.76,113.22 193.46,113.92 AFTP6229.1 193.88,113.18 v2(193.39,112.69)
  BOTTOM w0.102: v2(180.75,75.25) 181.04,75.54 181.22,75.54 182.13,76.45 182.13,77.16 181.32,77.96 181.32,78.65 181.06,78.9 181.06,83.98 181.55,84.47 181.55,86.6 182.28,87.32 182.28,89.16 184.41,91.29 184.41,94.49 185.06,95.14 185.06,99.12 189.63,103.69 189.63,108.93 v2(193.39,112.69) 193.93,112.69 194.36,112.26 RN2404.8
KSO16: length 59.1
  TOP w0.102: v2(193.51,111.16) 193.55,111.16 193.94,111.55 AFTP6225.1 193.67,112.19 193.46,112.19 190.71,109.45 KB1.11 ; v2(180.73,74.62) 175.92,69.8 174.52,69.8 174.51,69.81 KBC24.92
  BOTTOM w0.102: RN2404.7 193.76,111.41 v2(193.51,111.16) 192.91,111.16 189.83,108.09 189.83,103.59 185.26,99.02 185.26,95.05 184.61,94.4 184.61,91.21 182.48,89.07 182.48,87.24 181.76,86.52 181.76,84.39 181.27,83.9 181.27,78.99 181.52,78.73 181.52,78.05 182.33,77.24 182.33,76.21 v2(180.73,74.62)
L_BKLT_CTRL: length 211.9
  L3 w0.127: v2(162.85,161.46) 159.77,161.46 158.26,162.98 158.26,163.91 156.33,165.85 154.96,165.85 153.65,167.16 152.68,167.16 148.02,171.82 137.46,171.82 134.8,169.16 131.3,169.16 131.16,169.3 131.05,169.3 131.04,169.31 128.65,169.31 128.65,169.31 126.93,169.31 126.92,169.31 126.64,169.31 124.7,171.25 121.41,171.25 121.24,171.42 120.46,171.42 120.22,171.17 114.74,171.17 113.5,172.41 109.75,172.41 108.48,173.68 106.15,173.68 105.98,173.5 101.99,173.5 101.82,173.68 91.25,173.68 88.48,170.91 87.94,170.91 81.27,164.23 v2(76.26,164.23) ; v2(164.74,104.68) 164.7,104.72 164.66,104.68 159.29,104.68 158.52,103.9 156.07,103.9 153.54,101.38 151.64,101.38 151,100.74 146.64,100.74 146.26,101.12 139.73,101.12 138.15,99.54 137.9,99.54 136.22,97.86 136.22,97.76 135.36,96.9 134.96,96.9 132.77,94.7 132.3,94.7 130.74,93.14 130.74,92.81 130.32,92.39 130.32,90.2 129.4,89.27 128.51,89.27 128.28,89.04 127.95,89.04 127.72,88.81 127.72,88.47 127.99,88.19 128.82,88.19 v2(129.4,87.61)
  L4 w0.127: v2(164.74,104.68) 165.08,105.02 165.08,108.42 164.64,108.85 164.64,116.9 166.26,118.52 166.26,120.67 165.73,121.2 165.73,127.11 165.34,127.5 165.34,127.86 165.34,129.73 166.02,130.41 166.02,134.11 165.62,134.52 163.74,136.39 163.74,136.99 161.28,139.45 161.28,147.28 165.52,151.52 165.52,152.3 165.52,156.49 163.09,158.91 163.09,161.22 v2(162.85,161.46)
  BOTTOM w0.14: CPU1.R11 129.4,87.44 v2(129.4,87.61) ; R5530.1 v2(76.26,164.23) ; v2(162.85,161.46) v1(163.43,161.46)
