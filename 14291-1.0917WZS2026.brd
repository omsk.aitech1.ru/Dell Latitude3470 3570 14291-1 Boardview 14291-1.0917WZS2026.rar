# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VCCSA_CSP: length 57.1
  TOP w0.254: v2(134.49,122.28) v1(134.49,123.27) ; PR4612.2 115.71,151.6 v2(115.71,150.62)
  L4 w0.254: v2(134.49,122.28) 134.56,122.2 138.81,122.2 139.43,122.83 139.43,124.3 140,124.87 140,126.15 140.71,126.85 140.71,132.62 139.82,133.51 139.82,137.64 134.86,142.6 134.86,145.08 133.42,146.53 126.58,146.53 124.3,148.81 115.45,148.81 115.12,149.13 115.12,150.32 115.42,150.62 v2(115.71,150.62)
  BOTTOM w0.254: PG5021.1 134.87,122.66 v2(134.49,122.28)
PWR_VCCSA_CSP1B: length 8.1
  TOP w0.203: 114.91,147.24 PU4601.40
  TOP w0.254: 114.91,147.24 114.91,147.57 115.32,147.98 116.15,147.98 PC4606.2 117.29,149.11 PC4607.2 PR4609.1 117.29,151.86 PR4612.1 118.21,152.78 v1(118.36,152.78)
PWR_VCCSA_DRVH: length 11
  TOP w0.305: PU5001.8 135.61,136.65 v3(136.36,135.9)
  TOP w0.356: v3(135.48,127.54) v1(136.17,127.54)
  L4 w1.016: v3(136.36,135.9) 136.65,135.61 136.65,128.71 v3(135.48,127.54)
PWR_VCCSA_DRVL: length 7
  TOP w0.305: v3(133.32,135.97) 133.32,136.44 133.78,136.91 PU5001.5
  TOP w0.356: v3(133.7,131.84) v1(134.56,130.99)
  L4 w1.016: v3(133.7,131.84) 133.7,134.8 133.3,135.2 133.3,135.95 v3(133.32,135.97)
PWR_VCCSA_ICCMAX: length 4.2
  TOP w0.203: PU4601.20 114.51,139.35 v2(114.62,139.24)
  TOP w0.254: v2(114.62,139.24) 114.7,139.16 v1(114.7,138.49)
  BOTTOM w0.254: PR4660.1 115.36,140.1 114.62,139.36 v2(114.62,139.24)
PWR_VCCSA_ILIM: length 4.8
  TOP w0.203: PU4601.42 114.11,148.06 v2(114.19,148.14)
  TOP w0.254: PR4611.1 114.52,148.47 v2(114.19,148.14)
  BOTTOM w0.254: v2(114.19,148.14) v1(114.19,147.56) 114.19,146.49 114.24,146.44 PC4632.1
PWR_VCCSA_IOUT: length 3.5
  TOP w0.203: v2(115.46,147.38) 115.31,147.23 PU4601.39
  BOTTOM w0.254: PC4609.1 115.07,145.83 PR4613.1 115.07,146.07 115.72,146.71 v1(115.72,146.87) 115.72,147.13 v2(115.46,147.38)
PWR_VCCSA_PWM: length 25
  TOP w0.203: PU4601.36 116.77,146.62 116.95,146.8 117.82,146.8 v1(118.06,147.03) 118.89,147.87 v2(118.89,148.01)
  TOP w0.254: PU5001.2 135.11,138.73 v2(135.11,139.59)
  L4 w0.508: v2(135.11,139.59) 135.11,141.07 133.28,142.89 129.62,142.89 127.66,144.85 126.37,144.85 123.05,148.18 119.06,148.18 v2(118.89,148.01)
PWR_VCCSA_SNUB: length 2.4
  TOP w0.508: PR5014.2 PC5031.1 v1(133.73,129.63)
PWR_VCCSA_SW: length 15.2
  TOP w0.305: v3(135.07,135.9) 135.11,135.94 PU5001.7
  TOP w0.356: v1(133.44,134.9) PC5008.2
  TOP w0.508: PC5008.2 134.97,135.8 v3(135.07,135.9) ; PR5014.1 134.13,126.57 134.14,126.56 v3(134.3,126.56)
  L4 w1.016: v3(135.07,135.9) 135.07,135.16 135.38,134.85 135.38,129.32 134.2,128.14 134.2,126.66 v3(134.3,126.56)
PWR_VCCSA_VSN: length 3.6
  TOP w0.203: PU4601.44 113.31,147.39 113.02,147.68
  TOP w0.254: PC4603.2 112.22,149.15 112.69,149.15 PR4605.2 112.9,148.53 112.77,148.4 v1(112.77,148.03) 112.77,147.93 113.02,147.68
PWR_VCCSA_VSN_R: length 4.4
  TOP w0.254: PR4605.1 PC4603.1 112.01,150.21 PC4605.2 112.48,151.02 112.34,151.16 PR4604.2 112.61,151.5 113.36,152.26 v1(113.36,152.49)
PWR_VCCSA_VSP: length 5.1
  TOP w0.203: 112.65,147.5 112.91,147.23 PU4601.45
  TOP w0.254: v1(109.23,148.83) 109.35,148.94 PC4608.2 111.07,148.94 111.08,148.93 PR4608.2 111.15,148.83 111.6,148.38 111.83,148.38 112.31,147.9 112.31,147.84 112.65,147.5
PWR_VCCSA_VSP_R: length 3.9
  TOP w0.254: PR4608.1 111.15,150.24 PC4605.1 111.59,151.38 PR4607.2 110.79,151.5 PR4616.1 109.93,151.65 v1(109.64,151.37)
PWR_VCCSA_VSP_RC: length 2.1
  TOP w0.254: v1(109.38,150.07) 109.63,149.83 PC4608.1 110.31,150.43 PR4616.2
PWR_VCORE_ADDR_BOOT: length 3.3
  TOP w0.203: PU4601.21 114.91,139.85 v1(115.07,139.69) 115.31,139.45 v2(115.31,139.17)
  BOTTOM w0.254: PR4663.1 116.19,140.05 v2(115.31,139.17)
PWR_VCORE_ALERT#: length 3.9
  TOP w0.14: PR4666.2 119.62,146.97 v1(118.54,145.89) 118.54,145.72 117.61,144.79 PU4601.33
PWR_VCORE_BOOT: length 1
  TOP w0.508: v3(126.49,133.38) 126.69,133.18 PR4701.1
  vias: v1(126.39,132.06)
PWR_VCORE_BOOT_RC: length 3
  TOP w0.356: v1(128.24,131.01) 127.97,131.29 126.86,131.29 PR4701.2
  TOP w0.508: PR4701.2 PC4706.1
PWR_VCORE_COMP: length 3.9
  TOP w0.203: PU4601.26 117.19,141.99 117.55,141.63 v2(117.85,141.63)
  BOTTOM w0.254: PC4601.1 118.73,141.25 118.32,141.25 v1(118.3,141.27) 117.94,141.63 v2(117.85,141.63) 117.59,141.9 PC4619.1
PWR_VCORE_COMP_R: length 2.2
  BOTTOM w0.254: PR4636.1 121.2,141.46 v1(120.75,141) 120.25,141.5 PC4601.2
PWR_VCORE_CSN: length 42.3
  TOP w0.203: PU4601.28 117.53,142.79 117.7,142.62 118.56,142.62 118.56,142.63 v1(118.69,142.63)
  TOP w0.254: v2(121.69,143.44) 120.94,142.69 PC4634.2 PC4616.2 119.57,142.63 v1(118.69,142.63)
  L4 w0.254: v2(121.69,143.44) 121.99,143.74 127.33,143.74 129.66,141.41 129.66,128.74 129.02,128.09 129.02,127.2 129.66,126.55 129.66,123.73 v2(128.65,122.71) 128.42,122.71 127.15,121.44 122.83,121.44 v2(122.68,121.29)
  BOTTOM w0.254: PG4708.1 123.11,120.86 v2(122.68,121.29) ; v2(128.65,122.71) 127.95,122.71 PR4633.1
PWR_VCORE_CSNNTC: length 30.1
  TOP w0.254: PR4629.2 123.75,145.19 v2(123.92,145.02)
  L4 w0.254: v2(123.92,145.02) 124.72,144.22 127.4,144.22 130.07,141.55 130.07,123.41 128.68,122.03 v2(128.68,122.01)
  BOTTOM w0.254: v1(124.51,144.47) 123.96,145.02 v2(123.92,145.02) ; v2(128.68,122.01) 128.56,121.89 PR4633.2
PWR_VCORE_CSP: length 34
  TOP w0.254: PR4627.2 124.67,144.53 125.55,144.53 125.73,144.35 v1(125.73,143.97) 125.73,143.57 v2(125.4,143.24)
  L4 w0.254: v2(125.4,143.24) 127.3,143.24 129.28,141.25 129.28,128.89 128.6,128.21 128.6,127.07 129.28,126.39 129.28,124.11 126.99,121.82 122.75,121.82 v2(122.65,121.92)
  BOTTOM w0.254: v2(122.65,121.92) 123.13,122.41 PG4707.1
PWR_VCORE_CSP_1A: length 8
  TOP w0.203: PU4601.29 117.69,143.19 117.84,143.05 118.44,143.05 118.81,143.42
  TOP w0.254: 118.81,143.42 118.97,143.58 PC4616.1 PC4634.1 121.01,143.58 121.56,144.12 v1(121.81,144.12) 121.84,144.09 PR4627.1 122.91,144.64 PR4629.1
PWR_VCORE_DISB#: length 2.4
  BOTTOM w0.203: 127.59,129.85 127.4,129.66 PU4701.2
  BOTTOM w0.254: v1(129.23,130.29) 129.11,130.17 PR4704.2 127.99,130.17 127.82,130 127.74,130 127.59,129.85
PWR_VCORE_DRVON: length 58.5
  TOP w0.203: v2(117.59,145.93) 117.51,145.93 117.18,145.59 PU4601.35
  TOP w0.254: v2(128.74,132.78) 128.74,132.79 129.46,133.51 129.46,137.49 130.5,138.54 v1(130.52,138.54) 130.52,139.04 131.08,139.6 134.03,139.6 134.61,139.03 PU5001.3
  L3 w0.254: v2(114.89,130.09) 117.89,133.1 117.89,135.65 118.73,136.48 127.52,136.48 128.26,135.73 128.26,133.17 128.53,132.9 128.61,132.9 v2(128.74,132.78)
  L4 w0.254: v2(117.59,145.93) 117.61,145.93 120.81,142.73 127.27,142.73 128.74,141.25 v2(128.74,132.78)
  BOTTOM w0.254: PR4704.1 128.17,131.19 128.17,132.37 128.57,132.78 v2(128.74,132.78) ; v2(114.89,130.09) 114.89,130.11 115.2,130.42 PR4808.1
PWR_VCORE_EN: length 4.4
  TOP w0.127: PR4630.1 118.29,148.47 v1(118.29,148.24) 118.29,147.86 117.66,147.23 116.46,147.23 116.11,146.88 PU4601.37
PWR_VCORE_ICCMAX: length 4.3
  TOP w0.203: PU4601.19 114.11,138.78 v2(114.09,138.76)
  BOTTOM w0.254: PR4658.1 114.54,140.21 113.99,139.66 v1(113.99,139.32) 113.99,138.86 v2(114.09,138.76)
PWR_VCORE_ILIM: length 5.2
  TOP w0.203: PU4601.27 117.37,142.39 117.57,142.19 118.38,142.19 118.61,141.97 v2(118.61,141.91)
  BOTTOM w0.254: 118.61,141.97 118.61,142.01 PR4635.1 ; 118.61,141.97 v2(118.61,141.91) ; 118.61,141.97 118.23,142.35 118.23,142.73 v1(118.18,142.78) 118.17,142.79 PC4633.1
PWR_VCORE_IOUT: length 4.2
  TOP w0.203: PU4601.30 117.9,143.59 117.93,143.57 118.26,143.57 v2(118.26,143.56)
  BOTTOM w0.254: v1(118.66,144.53) PR4628.1 PC4613.1 118.19,143.64 v2(118.26,143.56)
PWR_VCORE_NTC: length 20.8
  TOP w0.254: PR4650.1 PR4652.1 126.57,137.96 128.22,136.32 v1(128.22,135.72) 128.22,132.56 v2(128.74,132.04)
  BOTTOM w0.254: PR4653.2 129.78,128.96 129.78,131 v2(128.74,132.04)
PWR_VCORE_PHASED: length 1
  TOP w0.508: v3(125.4,133.38) 125.42,133.36 PC4706.2
  vias: v1(125.12,132.06)
PWR_VCORE_PWM: length 25.1
  TOP w0.203: PU4601.22 115.31,140.16 115.69,139.78
  TOP w0.254: 115.69,139.78 115.92,139.55 115.92,138.09 116.66,137.35 118.14,137.35 118.24,137.46 126.36,137.46 127.71,136.11 v1(127.71,133.99) 127.71,132.34 128.75,131.31 128.75,129.14 v2(128.43,128.82)
  BOTTOM w0.203: PU4701.4 127.62,128.86 127.77,129.01 128.24,129.01 v2(128.43,128.82)
PWR_VCORE_ROSC_COREGT: length 2.4
  TOP w0.203: v2(111.9,140.02) 112.11,140.23 PU4601.14
  BOTTOM w0.254: v1(111.41,139.52) v2(111.9,140.02) 111.98,140.1 PR4664.1
PWR_VCORE_ROSC_SAUS: length 3.6
  TOP w0.203: v2(111.98,139.35) 111.98,139.42 112.47,139.9 112.47,140.28 112.51,140.33 PU4601.15
  BOTTOM w0.254: v2(111.98,139.35) 112.2,139.35 v1(112.6,139.76) 112.87,140.03 PR4659.1
PWR_VCORE_SCLK: length 6.6
  TOP w0.14: v1(121.49,148.11) 121.19,148.41 119.99,148.41 119.69,148.11 PR4665.2 118.11,146.27 118.11,145.76 117.54,145.19 PU4601.34
PWR_VCORE_SDIO: length 4.2
  TOP w0.14: PU4601.32 117.64,144.39 118.59,145.34 v1(119.63,145.34) 120.45,145.34 PR4667.2
PWR_VCORE_SNUB: length 2.4
  TOP w0.508: PC4709.1 121.25,126.99 PR4703.2 122.66,126.14 v1(122.66,126.14)
PWR_VCORE_SW: length 2.1
  TOP w0.356: v1(121.18,122.38) v3(121.18,123.3)
  TOP w0.508: v3(121.18,123.3) 121.25,123.37 PR4703.1
PWR_VCORE_TSENSE: length 4
  TOP w0.203: PU4601.23 115.71,140.45 116.56,139.61 v2(116.56,139.53)
  TOP w0.254: PR4650.2 116.91,139.17 v2(116.56,139.53)
  BOTTOM w0.254: PC4628.1 117.01,139.98 v2(116.56,139.53) v1(116.56,138.94)
PWR_VCORE_VCC: length 5.2
  TOP w0.254: v2(129.54,127.54) v1(129.54,128.26)
  TOP w0.508: PR4702.1 128.59,127.53 PC4708.1 v2(129.54,127.54)
  BOTTOM w0.203: 127.89,127.8 127.63,128.06 PU4701.6
  BOTTOM w0.508: 127.89,127.8 128.16,127.54 v2(129.54,127.54)
PWR_VCORE_VCC_R: length 3.9
  TOP w0.203: v2(111.1,140.01) 111.1,140.15 111.71,140.76 PU4601.13
  TOP w0.254: v2(111.1,140.01) 111.28,139.84 111.28,139.2 v1(111.38,139.1) 111.38,138.17 PR4657.2
  BOTTOM w0.254: v2(111.1,140.01) 110.95,140.16 110.95,140.52 PC4631.1
PWR_VCORE_VR_RDY: length 3.7
  TOP w0.203: 116.02,147.29 115.71,146.98 PU4601.38
  TOP w0.254: 116.02,147.29 116.28,147.55 116.61,147.55 v1(116.83,147.77) 118.1,149.05 PR4670.1
PWR_VCORE_VRHOT#: length 3
  TOP w0.203: v1(118.13,144.3) 117.82,143.99 PU4601.31
  TOP w0.254: v1(118.13,144.3) 118.23,144.4 PR4668.1
PWR_VCORE_VRMP: length 4.5
  TOP w0.254: PU4601.12 111.06,140.98 110.56,140.48 110.56,139.95 v2(110.36,139.74) 110.3,139.69 PR4601.2 109.6,139.07 v1(109.38,139.3)
  BOTTOM w0.254: PC4629.1 110.27,139.83 v2(110.36,139.74)
PWR_VCORE_VSN: length 4.1
  TOP w0.203: PU4601.25 116.77,141.22 116.83,141.16
  TOP w0.254: 116.83,141.16 116.99,141 v1(117.9,141) 119.57,141 PR4644.1 PC4622.2
PWR_VCORE_VSN_R: length 3.6
  TOP w0.254: v1(121.66,141.1) 121.66,140.75 121.3,140.38 PR4645.2 120.92,140.16 120.88,140.2 PC4625.1 120.51,140.21 PR4644.2 PC4622.1
PWR_VCORE_VSP: length 5
  TOP w0.203: 116.64,140.68 116.39,140.94 PU4601.24
  TOP w0.254: PR4649.1 PR4647.1 118.8,139.79 118.99,139.98 v1(118.99,140.29) 118.82,140.47 116.86,140.47 116.64,140.68
PWR_VCORE_VSP_R: length 4.2
  TOP w0.254: v1(123.07,138.51) PC4627.2 121.37,139.27 PR4648.2 120.53,139.34 PC4625.2 120.43,139.37 PR4647.2
PWR_VCORE_VSP_RC: length 0.8
  TOP w0.254: PR4649.2 120.43,138.56 PC4627.1
PWR_VGA_CORE_BOOT1: length 2.6
  BOTTOM w0.203: PU8201.1 211.21,99.13 211.46,99.39
  BOTTOM w0.508: PR8210.1 212.38,99.48 v1(211.78,99.48) 211.56,99.48 211.46,99.39
PWR_VGA_CORE_BOOT1_1: length 3.2
  BOTTOM w0.508: PR8210.2 214.68,99.05 214.93,99.3 214.93,99.81 v1(214.56,100.18) 214.31,100.43 213.82,100.43 PC8211.1
PWR_VGA_CORE_BOOT2: length 3.6
  BOTTOM w0.203: PU8201.15 207.09,99.13 206.88,99.34 206.37,99.34
  BOTTOM w0.508: 206.37,99.34 206.12,99.34 v1(205.91,99.14) 204.82,98.05 PR8211.1
PWR_VGA_CORE_BOOT2_1: length 2.4
  BOTTOM w0.508: v1(202.17,98.05) PR8211.2 PC8216.1
PWR_VGA_CORE_EN: length 8.1
  BOTTOM w0.203: 211.28,98.25 211.2,98.33 PU8201.3
  BOTTOM w0.254: 211.28,98.25 211.78,97.75 211.78,97.28 212.39,96.66 PC8225.2 212.73,96.68 PR8256.2 PR8260.2 214.49,98.28 v1(215.16,98.28) 215.5,97.95 PQ8305.2
PWR_VGA_CORE_EN#: length 5
  BOTTOM w0.127: PQ8305.5 219.17,97.95 219.32,97.79 219.32,97.41 219.21,97.3 PQ8305.6 217.89,96.83 PR8315.1 217.89,95.22 v1(217.64,94.97)
PWR_VGA_CORE_LGATE1: length 14.8
  TOP w0.356: v3(209.93,101.12) v1(209.93,100.32)
  L4 w1.016: v3(209.93,101.12) 209.93,102.52 212.72,105.31 v3(212.72,105.57) v3(212.72,111.28)
  BOTTOM w0.203: v3(209.93,101.12) 209.93,100.9 209.44,100.41 PU8201.19
  BOTTOM w0.508: PR8224.1 210.31,101.5 v3(209.93,101.12)
PWR_VGA_CORE_LGATE2: length 13.5
  TOP w0.356: v3(208.53,100.99) v1(208.53,101.75)
  L4 w1.016: v3(208.53,100.99) 208.53,102.9 205.99,105.44 v3(205.99,105.95) v3(205.99,111.54)
  BOTTOM w0.203: PU8201.17 208.64,100.89 v3(208.53,100.99)
PWR_VGA_CORE_PHASE1: length 18.3
  L4 w1.016: v3(217.75,112.5) 217.42,112.17 217.42,106.09 215.49,104.16 215.49,103.45 212.27,100.23 v3(211.2,100.23)
  BOTTOM w0.203: PU8201.20 210.84,99.88 v3(211.2,100.23)
  BOTTOM w0.508: PC8211.2 211.72,100.75 v3(211.2,100.23)
  vias: v1(211.78,114.38) v3(213.2,115.3) v3(213.2,114.41) v3(213.2,113.52) v3(213.18,112.53) v3(214.14,115.35) v3(215.03,115.35) v3(215.92,115.35) v3(216.81,115.35) v3(217.72,115.35) v3(217.79,114.44) v3(217.79,113.55)
PWR_VGA_CORE_PHASE2: length 19.6
  L4 w1.016: v3(201.16,112.88) 201.16,106.47 202.89,104.75 202.89,103.86 206.64,100.11 v3(207.13,100.11)
  BOTTOM w0.203: PU8201.16 207.36,99.88 v3(207.13,100.11)
  BOTTOM w0.508: v3(207.13,100.11) 205.64,100.11 204.98,99.45 PC8216.2
  vias: v1(207.26,114.25) v3(201.19,115.65) v3(201.19,114.76) v3(201.19,113.87) v3(202.13,115.7) v3(203.02,115.7) v3(203.91,115.7) v3(204.8,115.7) v3(205.71,115.7) v3(205.71,114.81) v3(205.71,113.92) v3(205.71,113.03)
PWR_VGA_CORE_PSI: length 7.1
  BOTTOM w0.203: 211.34,97.44 211.34,97.68 211.09,97.93 PU8201.4
  BOTTOM w0.254: v1(215.78,94.71) 215.31,95.18 PR8257.2 215.12,95.85 PR8258.2 PC8226.2 PR8259.1 212.61,95.85 211.34,97.12 211.34,97.44
PWR_VGA_CORE_REFADJ: length 2.8
  BOTTOM w0.203: PU8201.6 209.84,96.31 210.1,96.04
  BOTTOM w0.254: PR8222.1 211.14,95.22 v1(210.83,95.53) 210.46,95.9 210.25,95.9 210.1,96.04
PWR_VGA_CORE_REFIN: length 4
  BOTTOM w0.203: PU8201.7 209.44,96.16
  BOTTOM w0.254: PR8209.1 PC8204.1 209.39,94.58 PR8208.1 209.54,94.75 v1(209.54,95.52) 209.54,95.86 209.44,95.97 209.44,96.16
PWR_VGA_CORE_RGND: length 17.8
  L4 w0.254: v2(207.25,95.71) 207.82,95.14 207.82,94.21 209.89,92.14 v2(210.14,92.14)
  BOTTOM w0.203: PU8201.10 208.11,96.78 207.54,96.21
  BOTTOM w0.254: 205.68,93.99 206.24,93.99 206.8,94.55 206.8,95.12 207.11,95.43 207.11,95.57 v2(207.25,95.71) 207.25,95.93 207.54,96.21 ; 205.68,93.99 204.63,93.99 PC8219.2 204.31,94.3 PC8217.1 PR8213.1 202.68,94.24 PR8220.1 ; 205.68,93.99 v1(205.68,93.75) ; PC8201.1 208.55,93.72 PC8204.2 PR8209.2 210.32,92.88 PC8223.2 210.23,92.06 v2(210.14,92.14)
PWR_VGA_CORE_SS: length 2.6
  BOTTOM w0.203: PU8201.11 207.49,97.27 207.26,97.05 207.1,97.05 v1(206.5,96.45)
  BOTTOM w0.254: PC8205.1 206.41,95.92 206.41,96.37 v1(206.5,96.45)
PWR_VGA_CORE_TON: length 2.5
  BOTTOM w0.203: 208.64,96.16 PU8201.9
  BOTTOM w0.254: PR8201.2 207.56,94.73 208.03,95.19 v1(208.03,95.55) 208.64,96.16
PWR_VGA_CORE_TON_1: length 2.8
  BOTTOM w0.254: v1(206.52,92.75) 206.7,92.93 PR8202.2 ; PR8202.2 PC8202.2 ; PR8202.2 207.51,93.74 PR8201.1
PWR_VGA_CORE_UGATE1: length 17.8
  TOP w0.356: v3(211.83,98.71) v1(212.52,98.71)
  L4 w1.016: v3(218.69,111.28) v3(218.69,105.57) 216.76,103.64 216.76,102.93 212.54,98.71 v3(211.83,98.71)
  BOTTOM w0.203: v3(211.83,98.71) 211.81,98.73 PU8201.2
PWR_VGA_CORE_UGATE2: length 17.7
  TOP w0.356: v3(206.37,98.58) v1(207.22,98.58)
  L4 w1.016: v3(206.37,98.58) 201.62,103.33 201.62,104.22 v3(199.89,105.95) v3(199.89,111.54)
  BOTTOM w0.203: v3(206.37,98.58) 206.52,98.73 PU8201.14
PWR_VGA_CORE_VID: length 7.3
  BOTTOM w0.203: 210.9,96.51 210.59,96.82 PU8201.5
  BOTTOM w0.254: v1(214.37,92.61) 213.45,92.61 212.78,93.27 PR8207.2 PC8203.2 212.29,94.16 211.98,94.47 211.98,95.43 210.9,96.51
PWR_VGA_CORE_VREF: length 8.9
  TOP w0.254: v2(208.96,95.53) v1(209.54,95.53)
  L4 w0.254: v2(208.96,95.53) 208.96,94.26 210.27,92.95 210.5,92.95 v2(211.95,91.51)
  BOTTOM w0.203: 209.04,96.09 PU8201.8
  BOTTOM w0.254: PC8201.2 208.55,95.13 v2(208.96,95.53) 208.96,95.69 209.04,95.76 209.04,96.09 ; PR8206.1 v2(211.95,91.51)
PWR_VGA_CORE_VSNS: length 7.3
  BOTTOM w0.203: 206.43,97.47 206.88,97.93 PU8201.12
  BOTTOM w0.254: PR8221.1 201.98,95.19 PR8212.2 PC8222.1 204.31,95.19 PC8219.1 204.78,95.02 205.28,95.52 205.28,96.17 v1(205.28,96.17) 205.28,96.32 206.43,97.47
PWR_VGA_SNUB1: length 1.3
  BOTTOM w0.508: PR8216.2 209.93,110.7 PC8206.1
PWR_VGA_SNUB2: length 1.2
  BOTTOM w0.508: PR8215.2 208.66,110.82 PC8218.1
Q402_1: length 4.1
  TOP w0.102: RN3101.4 57.48,162.91 57.82,163.25 v1(57.82,163.5) 57.82,163.93 57.3,164.45 Q3103.B
Q4009_G: length 4.1
  BOTTOM w0.102: R2728.2 51.42,13.39 Q4009.G ; R2728.2 R2729.2 ; R2728.2 52.34,13.39 52.51,13.56 53.03,13.56 v1(53.51,13.08)
Q6204_G: length 4.6
  TOP w0.254: Q6503.2 Q6503.5 52.06,73.44 51.93,73.56 R6512.1 50.72,72.79 v1(50.72,72.53)
Q6205_Q: length 8.5
  TOP w0.381: Q6505.D 42.03,72.65 42.77,71.91 v1(45.11,71.91) 46.31,71.91 46.58,72.18 R6522.2
Q7601_G: length 5.3
  BOTTOM w0.102: Q7601.5 Q7601.2 217.63,147.26 217.3,146.94 217.3,146.33 217.58,146.05 218.05,146.05 218.45,146.45 R7657.2
Q9101.G: length 2.4
  BOTTOM w0.127: Q9101.G 156.1,24.29 v1(156.2,24.19) 156.47,23.92 R9115.1
REFIN_VREF: length 4.3
  BOTTOM w0.254: v1(213.11,92.29) 212.71,92.29 211.96,93.04 PR8206.2 211.85,92.94 PC8223.1 211.14,92.94 PR8222.2 211.13,93.73 PR8208.2
RESET_OUT#: length 273.6
  TOP w0.127: R1706.1 139.87,57.18 140.74,56.32 v2(142.57,56.32) ; KBC24.73 172.78,77.41 172.74,77.37 172.23,77.37 v2(172.03,77.17) 171.48,77.17 EC1704.1
  L3 w0.127: v2(163.48,94.73) 164.15,94.73 164.44,95.02 166.88,95.02 167.15,94.76 168.3,94.76 168.3,94.76 168.61,94.76 169.29,94.08 171.1,94.08 v2(173.01,92.16) ; v2(142.57,56.32) 143.66,55.22 143.66,55.1 143.68,55.09 143.68,53.66 145.19,52.15 145.19,52.06 146.18,51.07 146.78,51.07 146.83,51.01 150.63,51.01 150.68,51.06 159.09,51.06 161.82,48.33 165.39,48.33 165.43,48.37 171.41,48.37 v2(172.2,49.16)
  L4 w0.127: v2(172.03,77.17) 171.38,77.82 171.38,80.12 171.41,80.14 171.41,82.22 171.94,82.75 171.94,84.1 172.7,84.86 172.7,85.07 172.7,86.62 172.75,86.68 172.75,87.31 172.75,87.31 172.75,88.41 173.3,88.95 173.3,91.38 173.01,91.66 v2(173.01,92.16) ; v2(146.24,15.38) 146.24,41.15 145.02,42.36 145.02,44.96 143.47,46.51 143.33,46.51 142.48,47.36 142.48,47.9 143.01,48.42 143.01,50.13 141.95,51.19 141.95,52.22 142.36,52.63 142.36,56.11 v2(142.57,56.32)
  BOTTOM w0.127: v2(163.48,94.73) 163.47,94.73 163.47,95.05 163.09,95.42 162.15,95.42 161.96,95.24 Q2602.G ; v2(172.2,49.16) 171.3,50.06 171.3,58.27 171.82,58.79 171.82,59.16 171.65,59.33 171.65,65.44 171.39,65.7 171.39,71.48 171.18,71.7 171.18,72.29 171.18,72.29 v1(171.18,73.05) 171.18,73.64 171.65,74.12 171.65,75.49 171.81,75.65 171.81,76.5 171.8,76.51 171.8,76.95 v2(172.03,77.17) ; v2(146.24,15.38) 144.9,15.38 143.35,13.82 140.44,13.82 138.01,11.4 74.8,11.4 74.5,11.09 63.99,11.09 62.23,12.85 54.3,12.85 52.19,14.96 46.46,14.96 45.8,15.62 45.8,16.6 43.58,18.83 42.57,18.83 41.79,19.61 41.79,23.37 42.82,24.4 42.82,26.06 43.34,26.57 47.13,26.57 48,27.44 48,28.48 48.54,29.02 49.77,29.02 50.98,30.22 51.71,30.22 52.09,30.6 52.09,31.87 51.9,32.05 Q4001.3
RING2: length 22.9
  TOP w0.203: HDA27.17 27.95,20.2 v1(28.01,20.25) 28.34,20.58 v3(28.34,20.88)
  TOP w0.305: RN2901.4 27.64,21.43 27.8,21.43 v3(28.34,20.88)
  L3 w1.016: v3(28.34,20.88) 28.34,21.33 28.32,21.35 28.32,21.37 27.55,22.13 23.59,22.13 20.37,18.9 20.37,17.42 17.09,14.14 17.09,13.65 15.44,12 v3(15.44,11.69)
RING2_HPMIC1: length 20.1
  L4 w1.016: HPMIC1.4 1.5,3.07 2.83,1.74 10.9,1.74 11.98,2.82 11.98,8.46 12.92,9.4 14.27,9.4 v3(14.45,9.22)
RISING TIME: length 5
  BOTTOM w0.102: v1(158.3,111.9) D4005.K 158.91,114.03 C4008.1 159.22,114.86 159.86,114.23 U4006.1
RISING TIME2: length 7.6
  BOTTOM w0.102: U4002.1 163.75,122.88 164.02,123.16 164.71,123.16 C4006.1 165.62,122.9 v1(166.06,122.46) 166.32,122.2 166.32,119.55 D4004.K
ROM_CS#: length 4.1
  TOP w0.127: v2(200.65,140.64) 201.11,141.1 202.37,141.1 R7626.1 v1(202.86,142.52)
  BOTTOM w0.127: v2(200.65,140.64) 200.67,140.64 201.05,141.03 GPU1.D12
ROM_SCLK: length 9.9
  BOTTOM w0.127: GPU1.C12 202.15,141.03 202.5,140.67 202.94,140.67 203.49,140.12 203.79,140.12 203.86,140.06 v1(206.55,140.06) 206.87,140.06 207.56,140.75 209.56,140.75 R7614.1 R7608.2
ROM_SI: length 10.8
  BOTTOM w0.127: GPU1.B12 202.91,141.03 203.58,140.36 203.91,140.36 203.96,140.31 205.04,140.31 205.14,140.4 205.14,140.41 205.43,140.7 205.43,140.9 v1(205.61,141.08) 205.81,141.28 206.17,141.28 206.23,141.22 R7655.1 R7642.1 R7618.1 R7619.1 R7640.2 R7639.2 211.7,141.22 R7616.2 R7638.2
ROM_SO: length 8.2
  BOTTOM w0.127: R7611.2 R7620.1 206.69,143.81 v1(205.86,142.98) 205.31,142.43 205.31,141.64 205.2,141.53 205.2,140.8 204.94,140.54 204.06,140.54 203.56,141.03 GPU1.A12
RSET: length 3.7
  TOP w0.203: 44.39,172.2 44.65,171.94 45.19,171.94 45.53,171.6 LOM31.31
  TOP w0.305: 44.39,172.2 v1(44.22,172.37) 43.69,172.91 R3112.2
RSMRST_PWRGD#: length 6.8
  TOP w0.127: D4002.3 125.79,150.27 R4032.2 R4031.2 R4030.2 R4029.2 R4033.2 129.78,150.08 130.58,149.28 v1(130.58,149.08)
RSVD_F65: length 1.4
  TOP w0.102: v2(98.57,91.45) 98.46,91.34 TP612.1
  BOTTOM w0.102: v2(98.57,91.45) 98.58,91.45 98.67,91.45 98.99,91.77 CPU1.F65
RSVD_G65: length 1.3
  TOP w0.102: TP613.1 99.61,90.88 v2(99.61,91.42)
  BOTTOM w0.102: v2(99.61,91.42) 99.55,91.42 99.25,91.12 CPU1.G65
RSVD_TP_AK12: length 1.3
  TOP w0.102: v2(129.39,80.23) 129.45,80.29 TP606.1
  BOTTOM w0.102: CPU1.AK12 129.39,80.07 v2(129.39,80.23)
RSVD_TP_AK13: length 3.3
  TOP w0.102: TP605.1 127.57,79.35 127.85,79.64 128.16,79.64 v2(128.76,80.23)
  BOTTOM w0.102: v2(128.76,80.23) 128.76,80.09 CPU1.AK13
RSVD_TP_AW70: length 8.3
  TOP w0.102: TP615.1 94.67,73.47 94.03,73.47 93.46,72.9 92.43,72.9 v2(92.03,73.3)
  BOTTOM w0.089: CPU1.AW70 95.57,73.88 94.93,73.88 94.49,73.44 93.84,73.44
  BOTTOM w0.102: 93.84,73.44 93.32,72.93 92.41,72.93 v2(92.03,73.3)
RSVD_TP_AW71: length 4.5
  TOP w0.102: v2(92.69,73.33) 93.35,73.33 TP614.1
  BOTTOM w0.089: CPU1.AW71 94.99,74.22 94.4,73.64 93.75,73.64 93.45,73.33 93.24,73.33
  BOTTOM w0.102: 93.24,73.33 v2(92.69,73.33)
RSVD_TP_BA68: length 9.5
  BOTTOM w0.089: 93.25,71.72 93.65,72.12 94.74,72.12 95.4,72.78
  BOTTOM w0.102: 93.25,71.72 92.17,70.64 92.17,67.23 TP602.1 ; 95.4,72.78 95.87,72.78 96.17,73.08 CPU1.BA68
RSVD_TP_BA70: length 8
  BOTTOM w0.102: TP601.1 91.98,68.32 91.98,70.88 94.04,72.95 94.65,72.95 94.94,73.24 95.56,73.24 CPU1.BA70
RSVD_TP_BB68: length 8.3
  BOTTOM w0.102: TP603.1 93.25,67.06 93.25,67.26 93.25,67.26 93.25,67.58 93.25,67.58 93.25,67.91 93.25,67.91 93.25,68.23 93.25,68.23 93.25,68.56 93.25,68.56 93.25,68.88 93.25,68.88 93.25,69.21 93.25,69.21 93.25,69.53 93.25,69.53 93.25,69.86 93.25,69.86 93.25,70.07 94.62,71.44 95.2,71.44 95.71,71.95 96.01,71.95 96.22,72.15 96.32,72.15 96.63,72.46 CPU1.BB68
RSVD_TP_BB69: length 6.6
  BOTTOM w0.102: TP604.1 92.85,67.94 92.85,70.01 94.52,71.68 95.17,71.68 95.62,72.14 95.88,72.14 CPU1.BB69
RT8812_PVCC: length 3.8
  BOTTOM w0.203: PC8207.1 209.19,102.21 v1(209.19,101.17) 209.19,100.69 209.04,100.54 PU8201.18
  BOTTOM w0.508: PC8207.1 PR8223.2
RTC_AUX_S5: length 273.7
  TOP w0.508: R2473.2 180.53,53.42 v2(179.2,54.74) ; R1730.1 152.55,65.77 155.64,62.69 155.64,59.25 153.16,56.77 v2(153.16,55.59) ; v2(139.9,49.28) 139.62,49.56 138.51,49.56 138.51,49.57 135.26,49.57 130.83,54 130.83,58.18 132.11,59.46 v1(132.11,62.34) 132.11,62.99 131.26,63.84 R2106.1
  L3 w0.508: v2(136.33,58.55) 136.79,58.08 140.62,58.08 v2(140.69,58.02) 141.2,58.02 141.6,57.62 142.64,57.62 143.4,58.39 146.95,58.39 147.48,57.85 147.48,57.12 148.56,56.04 149.03,56.04 149.47,55.59 v2(153.16,55.59) 154.45,55.59 155.58,54.46 162.89,54.46 163.72,53.63 169.07,53.63 169.37,53.93 170.46,53.93 172.01,55.49 173.71,55.49 174.45,54.74 v2(179.2,54.74)
  L4 w0.508: v2(139.9,49.28) 139.9,53.42 140,53.52 140,54.28 139.76,54.52 139.76,55.34 140.69,56.26 v2(140.69,58.02) ; v2(178.19,18.8) 179.76,20.36 179.76,20.91 179.9,21.05 179.9,24.21 179.24,24.87 179.24,27.75 180.05,28.56 180.05,30.24 179.18,31.11 179.18,32.72 177.74,34.17 177.74,37.37 179.19,38.82 v2(179.19,42.16)
  BOTTOM w0.508: v2(178.19,18.8) 175.52,18.8 174.28,17.56 174.28,10.96 169.57,6.25 160.62,6.25 159.58,5.21 75.65,5.21 71.11,9.74 66.77,9.74 65.97,8.95 56.72,8.95 54.79,10.88 C2503.1 51.62,10.88 D2501.3 ; v2(179.2,54.74) 180.39,53.55 180.39,47.49 179.19,46.29 v2(179.19,42.16)
RTC_DET#: length 229.8
  L3 w0.102: v2(150.62,88.54) 151.17,88.54 152.04,89.41 153.92,89.41 154.06,89.27 155.88,89.27 156.79,90.18 157.63,90.18 159.26,90.18 159.98,90.18 160.52,89.64 161.6,89.64 161.9,89.94 161.9,90.81 162.1,91.01 164.45,91.01 164.72,90.74 164.72,89.77 v2(165.03,89.45)
  L4 w0.102: v2(165.03,89.45) 165.74,88.75 165.74,86.07 166.4,85.41 166.4,85.21 166.53,85.07 166.53,83.98 166.69,83.83 166.69,82.15 167.4,81.43 167.4,79.36 167.14,79.11 167.14,79 167.1,78.95 167.1,74.05 167.48,73.67 167.48,72.97 167.18,72.68 167.18,71.78 167.6,71.36 167.6,69.06 167.54,69 167.54,68.12 167.56,68.1 167.56,66.53 166.59,65.56 166.36,65.56 164.96,64.16 164.96,63.3 166.42,61.84 166.42,52.63 167.05,52 167.05,44.1 167.08,44.07 167.08,42.6 166.58,42.1 166.58,38.39 172.44,32.54 172.44,32.05 173.13,31.36 173.13,28.58 173.77,27.94 173.77,25.06 174.44,24.39 174.44,23.95 174.45,23.93 174.45,22.66 174.26,22.46 174.26,19.89 v2(176.08,18.07)
  BOTTOM w0.102: CPU1.P1 135.75,87.63 137.16,87.63 137.32,87.8 138.79,87.8 138.83,87.84 139.26,87.84 139.35,87.75 141.9,87.75 141.99,87.83 145.32,87.83 146.13,87.01 148.15,87.01 R2040.2 149.26,87.23 150.57,88.54 v2(150.62,88.54) ; Q2505.D 73.48,5.01 73.71,4.78 159.95,4.78 160.99,5.82 169.75,5.82 174.71,10.78 174.71,10.79 174.93,11.01 174.93,16.93 v1(175.38,17.38) v2(176.08,18.07)
RTC_PWR: length 24.8
  BOTTOM w0.508: R2502.1 69.45,7.34 v1(70.29,7.34) 70.65,6.98 70.65,6.2 Q2505.G 67.38,5.99 65.22,8.16 53.53,8.16 R2504.1 53.18,8.31 52.31,9.18 50.84,9.18 50.05,8.39 D2501.2
RTC_RST#: length 36.3
  TOP w0.127: RN1901.3 135.68,60.86 EC1807.1 136.4,61.58 G1901.2 138.16,61.58 C1901.1 138.61,61.12 140.54,61.12 140.8,61.38 Q1901.D 140.1,62.21 139.83,61.93 v2(138.96,61.93) 138.91,61.98 138.91,63.32 v1(138.55,63.68)
  L4 w0.127: v2(138.96,61.93) 138.76,62.12 138.04,62.12 137.49,62.67 137.49,63.36 136.97,63.88 136.48,63.88 136.02,64.34 134.38,64.34 133.34,65.38 133.34,66.48 132.88,66.94 132.88,67.73 132.58,68.03 132.25,68.03 132,68.28 132,69.17 131.26,69.91 131.26,70.36 130.91,70.72 130.91,71.18 128.68,73.41 127.86,73.41 127.33,73.94 127.33,74.56 127.61,74.85 127.61,78 v2(127.11,78.5)
  BOTTOM w0.127: v2(127.11,78.5) 126.79,78.82 CPU1.AM16
RTC_X1: length 25.6
  TOP w0.14: v2(143.96,76.8) 143.96,76.62 v1(144.26,76.32)
  L4 w0.127: v2(126.2,78.5) 127.29,79.59 131.93,79.59 132.17,79.34 132.17,78.9 133.95,77.12 140.06,77.12 140.21,76.96 143.63,76.96 143.79,76.8 v2(143.96,76.8)
  BOTTOM w0.14: v2(143.96,76.8) 144.5,76.26 144.98,76.26 145.46,76.74 R1815.1 145.73,76.71 C1804.1 146.82,76.9 X1802.4 ; CPU1.AM18 125.87,78.82 v2(126.2,78.5)
RTC_X2: length 26.5
  TOP w0.14: v1(145.23,77.18) 144.86,76.81 v2(144.65,76.81)
  L4 w0.127: v2(125.28,78.5) 126.58,79.8 132.56,79.8 134.66,77.69 140.29,77.69 140.45,77.54 143.92,77.54 v2(144.65,76.81)
  BOTTOM w0.14: v2(125.28,78.5) 125.15,78.5 CPU1.AM20 ; X1802.1 147.1,77.77 146.87,77.54 C1803.1 145.8,77.54 R1815.2 145.46,77.62 v2(144.65,76.81)
RTCRST_ON: length 78.5
  TOP w0.127: v2(190.28,80.98) 190.28,80.37 190.12,80.21 KBC24.31 ; R1902.1 138.59,60.58 EC1808.1 138.87,60.3 Q1901.G v2(140.86,60.3)
  L3 w0.127: v2(188.28,60.84) 187.83,60.4 180.71,60.4 180.39,60.72 179.08,60.72 178.13,59.78 174.27,59.78 172.43,61.62 165.78,61.62 164.81,62.59 161.98,62.59 160.04,60.66 155.69,60.66 153.25,58.22 150.41,58.22 148.09,60.54 143.47,60.54 143.17,60.23 141.9,60.23 141.83,60.3 v2(140.86,60.3)
  BOTTOM w0.127: v2(188.28,60.84) 189.3,61.87 v1(189.3,66.25) 189.3,66.6 188.87,67.03 188.87,67.06 188.87,67.07 188.87,67.43 189.28,67.85 189.28,72.55 189.28,72.55 189.28,72.75 189.6,73.07 189.6,79.19 190.04,79.63 190.04,80.75 v2(190.28,80.98)
RUNPWROK: length 7.4
  TOP w0.127: R2481.1 182.92,87.95 182.92,87.14 182.34,86.57 182.33,86.57 181.33,85.56 181.33,84.14 v1(181.51,83.96) 181.68,83.8 KBC24.48
SA0_DIMA: length 4.5
  TOP w0.102: v2(125.47,36.06) 125.32,36.06 v1(125,36.38) 124.78,36.6 124.78,37.18 124.71,37.24 R1201.1
  BOTTOM w0.102: DM1.197 124.45,37.07 125.46,36.06 v2(125.47,36.06)
SA0_DIMB: length 3.8
  TOP w0.102: R1301.1 137.52,26.42 v2(137.96,26.86) v1(137.96,27.44)
  BOTTOM w0.102: v2(137.96,26.86) 138.26,26.86 138.95,26.16 DM2.197
SA1_DIMA: length 7.1
  TOP w0.102: v2(125.45,35.37) 124.57,36.25 124.57,36.87 123.83,37.61 R1202.1 123.19,37.63 v1(122.89,37.33)
  BOTTOM w0.102: DM1.201 125.65,38.17 125.65,37.35 125.93,37.06 125.93,35.86 v2(125.45,35.37)
SA1_DIMB: length 4
  TOP w0.102: v1(140.09,27.72) v2(140.09,27.14) 139.52,26.56 R1302.2
  BOTTOM w0.102: DM2.201 140.15,27.09 v2(140.09,27.14)
SATA_LED: length 4
  BOTTOM w0.508: Q6401.C 182.78,121.93 EC6407.1 183.54,122.02 183.54,122.89 v1(183.46,122.96) 183.46,122.98 183.9,123.42 R6401.1
SATA_LED#: length 58.7
  TOP w0.102: v2(176.61,115.32) 176.21,114.92 175.09,114.92 174.74,114.57 174.73,114.57 174.48,114.31 174.48,114.31 172.14,111.97 171.26,111.97 169.07,109.78 167.32,109.78 163.97,106.42 163.97,105.87 162.6,104.51 162.6,102.69 159.33,99.42 153.68,99.42 152.99,98.73 151.15,98.73 148.89,96.47 v1(145.49,96.47) 144.87,96.47 143.22,94.81 140.63,94.81 138.71,92.89 v2(138.71,92.35)
  BOTTOM w0.102: CPU1.H1 136.1,90.91 137.12,91.93 138.29,91.93 v2(138.71,92.35) 139.23,92.88 R1606.2 ; Q6408.1 178.44,112.81 176.61,114.64 v2(176.61,115.32)
SATA_LED#_B: length 3.7
  BOTTOM w0.102: Q6402.D 179.23,117.47 180.66,118.91 v1(180.66,118.99) 180.66,119.46 Q6401.B
SATA_LED#_M: length 9.4
  BOTTOM w0.381: 178.52,114.35 179.24,114.35 179.48,114.11 Q6408.3 180.81,114.11 181.03,113.89 181.03,113.01 181.23,112.81 Q6408.6
  BOTTOM w0.508: 178.52,114.35 178.13,114.74 v1(178.13,115) 178.13,116.93 177.99,117.08 177.99,117.86 177.38,118.46 Q6402.S
SATA_LED_R: length 8.6
  TOP w0.305: LEDBD1.3 190.9,124.12 190.65,124.36 190.07,124.36
  TOP w0.508: 190.07,124.36 188.57,124.36 187.52,123.31 AFTP6306.1 185.98,123.31 v2(185.07,122.4)
  BOTTOM w0.508: R6401.2 185.2,122.53 v2(185.07,122.4)
SATA_RX_CON_N0: length 10.9
  BOTTOM w0.127: 183.28,24.77 182.23,24.77 182.14,24.68 U6001.7 U6001.4 180.17,24.68 180.12,24.74 178.95,24.74 C6004.2 ; 183.28,24.77 185.64,24.77 187.02,26.15 187.72,26.15 187.85,26.02 HDD1.5 ; 183.28,24.77 v1(183.28,24.57)
SATA_RX_CON_P0: length 11.1
  BOTTOM w0.127: 184.33,25.01 182.28,25.01 182.13,25.16 U6001.6 U6001.5 180.18,25.16 180,24.98 179.2,24.98 C6003.2 ; 184.33,25.01 185.54,25.01 186.92,26.39 187.72,26.39 187.85,26.52 HDD1.6 ; 184.33,25.01 v1(184.33,25.21)
SATA_RX_CPU_N0: length 128.8
  L4 w0.114: v2(124.37,92.03) 124.69,92.36 124.69,96.41 128.53,100.25 130,100.25 133.78,104.03 136.29,104.03 136.75,103.57 138.05,103.57 138.39,103.23 141.92,103.23 144.09,101.06 145.8,101.06 147.32,99.54 147.32,97.29 150.32,94.28 150.32,92.13 151.95,90.5 151.95,89.21 152.2,88.96 152.2,85.4 158.58,79.02 158.58,76.94 159.56,75.97 159.56,75.01 161.87,72.7 161.87,67.9 161.65,67.68 161.65,66.14 161.33,65.82 161.33,61.19 162.85,59.68 162.85,55.37 164.15,54.06 164.15,51.6 163.37,50.81 163.37,48.94 162.44,48.01 161.84,48.01 161.58,47.75 161.58,43.93 162.15,43.36 162.15,40.15 171.38,30.92 171.38,26.91 172.25,26.04 172.25,24.71 171.99,24.45 171.64,24.45 171.52,24.32 v2(171.52,24.15)
  BOTTOM w0.127: v2(171.52,24.15) 171.74,24.37 173.21,24.37 173.7,24.86 176.1,24.86 ; CPU1.F20 124.5,92.03 v2(124.37,92.03) ; 176.1,24.86 v1(176.1,24.7) ; 176.1,24.86 177.11,24.86 177.44,24.54 C6004.1
SATA_RX_CPU_P0: length 128.5
  L4 w0.114: v2(125.28,92.04) 125.02,92.04 124.92,92.14 124.92,96.32 128.62,100.02 130.09,100.02 133.88,103.8 136.19,103.8 136.65,103.34 137.95,103.34 138.29,103 141.82,103 143.99,100.83 145.7,100.83 147.09,99.45 147.09,97.19 150.09,94.18 150.09,92.04 151.73,90.41 151.73,89.11 151.97,88.87 151.97,85.3 158.35,78.92 158.35,76.85 159.33,75.87 159.33,74.92 161.64,72.61 161.64,67.99 161.42,67.77 161.42,66.23 161.1,65.92 161.1,61.1 162.62,59.58 162.62,55.27 163.93,53.97 163.93,51.7 163.14,50.91 163.14,49.03 162.35,48.24 161.75,48.24 161.35,47.84 161.35,43.84 161.92,43.27 161.92,40.05 171.15,30.82 171.15,26.81 172.02,25.94 172.02,24.8 171.89,24.68 171.55,24.68 171.48,24.74 v2(171.48,25.12)
  BOTTOM w0.127: CPU1.E20 124.82,92.21 125,92.04 v2(125.28,92.04) ; 173.83,25.11 177.11,25.11 177.44,25.43 C6003.1 ; 173.83,25.11 173.6,25.11 173.11,24.61 171.61,24.61 171.48,24.74 v2(171.48,25.12) ; 173.83,25.11 v1(173.83,25.24)
SATA_TX_CON_N0: length 11
  BOTTOM w0.127: C6006.1 179.01,23.4 179.18,23.22 179.83,23.22 180.25,23.64 U6001.2 U6001.9 182.27,23.64 182.39,23.52 185.42,23.52 ; 185.42,23.52 v1(185.42,23.72) ; 185.42,23.52 186.19,23.52 187.57,24.9 187.87,24.9 187.99,25.02 HDD1.3
SATA_TX_CON_P0: length 11.1
  BOTTOM w0.127: 183.96,23.28 v1(183.96,23.08) ; 183.96,23.28 182.39,23.28 182.27,23.16 U6001.10 U6001.1 180.11,23.16 179.93,22.98 179.45,22.98 178.98,22.51 C6005.1 ; 183.96,23.28 186.29,23.28 187.67,24.66 187.85,24.66 187.98,24.52 HDD1.2
SATA_TX_CPU_N0: length 129
  L4 w0.114: v2(122.06,96.74) 122.06,97.03 121.88,97.21 121.88,97.61 122.55,98.27 125.48,98.27 128.21,101 129.69,101 133.49,104.79 138.07,104.79 138.88,103.98 142.31,103.98 144.41,101.88 146.05,101.88 148.99,98.95 148.99,96.68 151.07,94.59 151.07,92.44 152.7,90.81 152.7,89.52 153.55,88.67 153.55,85.21 159.46,79.3 159.46,77.17 162.62,74.01 162.62,67.59 162.4,67.37 162.4,65.18 162.08,64.87 162.08,61.56 163.6,60.04 163.6,55.68 164.9,54.37 164.9,51.17 164.12,50.39 164.12,48.61 163.08,47.57 163.08,42.2 164.82,40.45 164.82,38.58 172.19,31.22 172.19,27.58 173,26.77 173,24.74 173.64,24.1 v2(173.64,23.3)
  BOTTOM w0.127: 176.43,23.09 177.56,23.09 C6006.2 ; 176.43,23.09 173.84,23.09 v2(173.64,23.3) ; 176.43,23.09 v1(176.43,23.26) ; v2(122.06,96.74) 122.34,96.74 122.41,96.67 122.41,95.96 123.31,95.06 123.31,94.75 CPU1.B21
SATA_TX_CPU_P0: length 128.8
  L4 w0.114: v2(172.86,23.27) 172.98,23.27 173.41,23.69 173.41,24.01 172.77,24.64 172.77,26.68 171.96,27.49 171.96,31.12 164.59,38.49 164.59,40.36 162.85,42.11 162.85,47.66 163.89,48.7 163.89,50.48 164.68,51.27 164.68,54.28 163.37,55.58 163.37,59.94 161.85,61.46 161.85,64.96 162.17,65.28 162.17,67.46 162.39,67.68 162.39,73.91 159.23,77.07 159.23,79.21 153.33,85.11 153.33,88.57 152.47,89.42 152.47,90.72 150.84,92.35 150.84,94.5 148.76,96.58 148.76,98.85 145.96,101.66 144.31,101.66 142.21,103.75 138.79,103.75 137.97,104.57 133.58,104.57 129.78,100.77 128.31,100.77 125.58,98.04 122.64,98.04 122.11,97.51 122.11,97.3 122.27,97.14 122.48,97.14 v2(122.53,97.19)
  BOTTOM w0.127: 173.79,22.85 177.67,22.85 177.86,22.66 C6005.2 ; 173.79,22.85 173.28,22.85 v2(172.86,23.27) ; 173.79,22.85 v1(173.79,22.72) ; v2(122.53,97.19) 122.53,96.89 122.66,96.77 122.66,96.06 CPU1.A21
SD_RCOMP: length 3.5
  TOP w0.254: 134.66,84.2 134.4,83.95 132.72,83.95 132.14,83.37 v2(132.14,83.37)
  BOTTOM w0.305: CPU1.AB7 132.14,83.7 v2(132.14,83.37)
  vias: v1(135.45,85.02)
SD_READ_MODE#: length 111.1
  TOP w0.127: v2(179.29,29.35) 179.29,29.47 v1(180.31,30.48) 183.09,30.48 183.8,31.19 184.58,31.19 185.43,32.05 185.43,32.92 185.65,33.14 186.27,33.14 186.63,32.77 IOBD1.9
  L3 w0.127: v2(151.39,28.01) 152.08,28.01 152.66,28.6 152.67,28.6 154.06,29.99 161.52,29.99 161.52,29.99 168.76,29.99 168.84,30.07 170.09,30.07 171.49,28.67 175.87,28.67 176.22,29.03 178.96,29.03 v2(179.29,29.35)
  L4 w0.127: v2(142.32,76.1) 142.61,76.39 143.27,76.39 144.98,74.68 146.63,74.68 146.91,74.95 148,74.95 148.78,74.18 149.57,74.18 149.88,73.86 149.88,73.49 148.76,72.37 148.76,68.84 149.58,68.02 149.58,65.48 150.13,64.94 152.39,64.94 154.86,62.47 154.86,59.54 151.66,56.34 151.66,28.46 151.39,28.19 v2(151.39,28.01)
  BOTTOM w0.089: CPU1.AN5 133.05,78.04 133.72,77.37 133.89,77.37 133.98,77.28 135.35,77.28
  BOTTOM w0.127: v2(142.32,76.1) 142.25,76.18 R2050.2 142.24,77.28 135.35,77.28
SERIRQ: length 83.6
  TOP w0.127: v2(176.55,79.61) 176.73,79.61 176.85,79.48 178.76,79.48 179.02,79.74 179.02,79.88 179.02,79.88 179.02,81.27 178.88,81.42 KBC24.55
  L3 w0.127: v2(180.44,65.31) 178.42,65.31 177.66,66.06 173.78,66.06 173.2,65.48 169.47,65.48 168.46,66.5 166.82,66.5 166.45,66.87 165.1,66.87 163.23,65 161.89,65 161.59,64.7 158.52,64.7 158.11,65.1 156.69,65.1 155.7,64.11 154.58,64.11 153.52,65.17 152.48,65.17 152.22,64.9 148.96,64.9 148.36,64.3 147.62,64.3 146.95,64.97 145.85,64.97 145.77,64.88 144.01,64.88 143.84,64.7 141.37,64.7 141.19,64.88 140.1,64.88 139.95,65.03 138.4,65.03 138.37,65 137.99,65 137.97,65.03 136.32,65.03 135.93,65.42 v2(135.89,65.42)
  BOTTOM w0.089: 130.21,71.55 129.86,71.9 129.86,73.31 129.53,73.64 CPU1.AY11
  BOTTOM w0.114: 131.39,69.5 130.21,70.69 130.21,71.55
  BOTTOM w0.127: 131.39,69.5 131.39,68.41 132.13,67.68 133.83,67.68 134.99,66.52 135.34,66.52 135.67,66.18 135.67,65.64 v2(135.89,65.42) 136.62,64.7 R2032.2 ; v2(176.55,79.61) 176.73,79.61 176.92,79.42 176.92,79.39 177.36,78.95 177.36,78.02 177.24,77.9 v1(177.24,77.6) 177.24,77.29 178.07,76.46 178.07,74.62 178.19,74.5 178.19,74.43 178.83,73.79 178.83,72.49 179.55,71.77 179.55,66.62 179.37,66.44 179.37,65.85 179.91,65.31 v2(180.44,65.31)
SERIRQ_TPM: length 2.6
  BOTTOM w0.102: R9102.1 162.02,25.41 v1(162.25,25.18) 162.25,25.16 162.73,24.68 U9101.27
SIO_EXT_SCI#: length 4.6
  TOP w0.127: v1(169.71,80.03) 169.9,80.22 171.39,80.22 171.75,79.86 R2411.1 172.24,80.21 KBC24.66
SIO_EXT_SCI#_R: length 58
  TOP w0.127: R2411.2 170.63,79.73 170.34,79.44 v2(169.68,79.44)
  L3 w0.127: v2(171.39,92.09) 171.03,92.45 169.76,92.45 169.26,92.95 169.04,92.95 167.92,94.07 166.69,94.07 166.59,94.17 164.62,94.17 164.24,93.79 164.14,93.79 164.14,93.79 158.54,93.79 158.49,93.83 158.46,93.83 158.09,94.2 155.87,94.2 155.1,93.43 155.1,93.19 153.7,91.79 153.7,91.79 153.39,91.48 152.54,91.48 152.52,91.46 152.18,91.46 151.39,92.24 146.3,92.24 145.25,93.29 144.27,93.29 144.03,93.05 141.89,93.05 141.24,92.4 140.22,92.4 138.97,91.15 v2(138.62,91.15)
  L4 w0.127: v2(169.68,79.44) 169.55,79.57 169.55,81.77 169.78,82 169.78,82.21 170.79,83.22 170.79,84.2 170.8,84.2 170.8,84.57 170.82,84.59 170.82,84.84 170.82,84.85 170.82,87.42 170.17,88.07 170.17,89.63 171.58,91.04 171.58,91.9 v2(171.39,92.09)
  BOTTOM w0.089: CPU1.J2 135.61,89.99 135.82,89.99 136.02,90.08 136.05,90.11 136.45,90.11
  BOTTOM w0.127: R1608.2 138.64,91.17 v2(138.62,91.15) 138.59,91.13 138.48,91.13 v1(138.07,90.71) 137.75,90.39 136.71,90.39 136.5,90.17 136.5,90.16 136.45,90.11
SIO_EXT_SMI#: length 4.8
  TOP w0.127: KBC24.10 190.14,71.81 190.47,71.48 190.47,70.84 191.02,70.29 R2412.1 191,70.2 v1(191,69.3) 191.85,69.3 R2457.1
SIO_EXT_SMI#_R: length 88.3
  TOP w0.127: v2(192.02,85.68) 192.04,85.7 192.04,86.45 188.29,90.21 186.14,90.21 185.98,90.04 168.98,90.04 167.84,91.18 166.17,91.18 165.61,91.74 160.65,91.74 159.64,90.74 v1(158.9,90.74) 155.46,90.74 154.89,91.31 154.89,94.38 154.57,94.7 152.76,94.7 152.51,94.45 151.55,94.45 148.8,91.7 144.15,91.7 143.37,92.48 142.95,92.48 142.95,92.48 142.15,92.48 R802.1 141.92,92.71 141.3,93.34 v2(140.74,93.34) ; R2412.2 v2(192.69,70.22)
  L3 w0.127: v2(140.74,93.34) 139.6,93.34 139.15,92.88 138.55,92.88 137.7,92.03 137.68,92.03 137.46,91.81 136.07,91.81 133.08,88.83 132.87,88.83 v2(132.68,88.64)
  BOTTOM w0.127: v2(192.69,70.22) 193.16,70.69 193.16,71.3 193.62,71.76 193.62,72.72 193.91,73.02 193.91,76.65 193.51,77.05 193.51,82.03 192.39,83.16 192.39,85.31 v2(192.02,85.68) ; CPU1.L6 132.68,88.8 v2(132.68,88.64)
SIO_EXT_WAKE#: length 65.8
  TOP w0.14: v2(183.76,68.77) 183.76,68.77 183.35,68.77 182.88,68.29 KBC24.116
  L3 w0.127: v2(137.66,80.8) 139.16,80.8 140.34,79.62 144.63,79.62 144.82,79.81 146.82,79.81 146.93,79.7 150.09,79.7 150.61,80.22 158.95,80.22 159.45,79.72 162.91,79.72 164.45,81.25 166.53,81.25 167.66,80.12 170.58,80.12 171.31,79.4 172.5,79.4 174.44,77.46 178.87,77.46 179.58,76.75 180.94,76.75 181.06,76.63 v2(181.7,76.63)
  L4 w0.127: v2(183.76,68.77) 183.96,68.96 183.96,70.5 183.09,71.37 183.09,72.07 182.19,72.96 182.19,73.23 181.92,73.5 181.92,76.41 v2(181.7,76.63)
  BOTTOM w0.089: CPU1.AD3 134.77,81.93 136,81.93 136.13,81.81 137.47,81.81 137.64,81.64
  BOTTOM w0.14: 137.64,81.64 137.71,81.58 137.71,80.85 v2(137.66,80.8) 138.48,79.98 R2041.2 ; v2(181.7,76.63) 181.7,76.62 v1(181.23,76.16)
SIO_PWRBTN#: length 107.1
  TOP w0.102: v2(173.89,49.34) v1(172.24,47.69) 171.75,47.2 162.52,47.2 162.42,47.09 147.72,47.09 144.94,49.88 143.27,49.88 142.52,50.63 141.45,50.63 141.09,50.99 135.73,50.99 132.16,54.55 132.16,57.26 v2(133.16,58.25) ; KBC24.52 180.08,81.35 179.46,80.74 179.46,79.84 178.65,79.03 176.72,79.03 176.67,78.97 176.5,78.97 v2(176.4,78.87)
  BOTTOM w0.089: 127.57,70.37 127.57,71.1 127.24,71.42 127.24,72.08 127.43,72.27 127.43,72.72 127.29,72.86 CPU1.BA15
  BOTTOM w0.102: v2(133.16,58.25) 133.03,58.25 130.53,60.75 130.53,62.99 130.02,63.5 130.02,65.18 R9926.1 129.56,66.01 129,66.58 129,68.23 127.57,69.66 127.57,70.37 ; v2(173.89,49.34) 173.89,50.46 177.44,54.01 177.44,57.73 179.42,59.72 179.42,64.64 179.09,64.97 179.09,66.51 179.31,66.72 179.31,71.65 178.59,72.36 178.59,73.69 177.95,74.33 177.95,74.4 177.83,74.52 177.83,76.36 176.88,77.31 176.88,77.88 177.12,78.12 177.12,78.54 176.77,78.89 176.42,78.89 v2(176.4,78.87)
SIO_RCIN#: length 101.3
  TOP w0.102: v2(180.19,83.3) 180.14,83.25 180.05,83.25 179.68,82.88 KBC24.53 ; v2(128.34,75.01) 128.83,74.52 128.83,73.33 129.67,72.49 v1(129.67,72.14) 129.67,71.33 131.97,69.02 132.65,69.02 132.98,68.69 132.98,67.83 133.42,67.39 133.42,66.15 133.85,65.72 133.85,65.45 v2(133.85,65.44)
  L3 w0.102: v2(183.23,59.9) 182.73,59.41 180.84,59.41 179.81,58.38 179.81,57.88 179.67,57.74 178.98,57.74 178.45,58.28 177.97,58.28 177.81,58.43 173.67,58.43 173.66,58.43 173.49,58.61 173.04,58.61 173.04,58.61 173.03,58.61 171.6,60.03 169.81,60.03 169.81,60.03 161.86,60.03 161.14,59.31 156.28,59.31 153.84,56.88 149.7,56.88 147.49,59.08 143.28,59.08 142.9,59.46 140.66,59.46 139.93,60.2 v2(136.25,60.2)
  L4 w0.102: v2(183.23,59.9) 183.24,59.91 183.87,59.91 184.91,60.95 184.91,63.81 185.13,64.03 185.13,65.08 182.95,67.26 182.95,68.75 183.55,69.35 183.55,70.39 182.72,71.22 182.72,71.91 181.82,72.81 181.82,73.07 181.49,73.4 181.49,76.22 180.41,77.3 180.41,77.93 180.89,78.42 180.89,82.59 v2(180.19,83.3)
  BOTTOM w0.102: v2(133.85,65.44) 133.85,65.43 134.18,65.11 R2021.2 133.28,63.77 133.28,63.06 133.15,62.94 133.15,62.23 135.18,60.2 v2(136.25,60.2) ; v2(128.34,75.01) 128.39,74.96 CPU1.AW13
SIO_SLP_A#: length 2.4
  TOP w0.127: v2(127.11,77.85) 127.57,77.39 127.57,76.44 127.57,76.25 TP1706.1
  BOTTOM w0.127: CPU1.AN16 126.79,78.17 v2(127.11,77.85)
SIO_SLP_S0#: length 124
  TOP w0.127: v2(133.88,67.05) 133.66,67.27 133.66,67.58 133.22,68.02 133.22,68.79 132.75,69.26 132.07,69.26 130.53,70.81 v1(130.53,71.25) 130.53,72.12 129.18,73.46 129.18,75.5 129.38,75.71 129.38,76.1 v2(128.94,76.55)
  L3 w0.127: v2(133.88,67.05) 135.82,67.05 136.06,67.29 138.27,67.29 139.43,66.13 140.88,66.13 141.02,66.27 146.2,66.27 146.68,66.76 154.45,66.76 154.54,66.84 158.42,66.84 158.95,66.31 160.3,66.31 161.02,67.04 161.02,67.86 162.28,69.11 164.86,69.11 165.14,69.4 166.87,69.4 167.13,69.13 v2(167.13,69.13) ; v2(172.62,116.22) 172.61,116.21 170.96,116.21 169.02,118.15 167.99,118.15 165.39,120.75 164.27,120.75 162.55,122.47 162.55,123.19 159.3,126.44 v2(159.01,126.44)
  L4 w0.127: v2(172.62,116.22) 172.62,114.8 174.74,112.69 174.74,110.45 173.08,108.79 173.08,102.86 173.77,102.17 173.77,100.57 172.5,99.3 172.5,96.97 171.86,96.33 171.86,94.65 171.83,94.63 171.83,90.93 170.43,89.52 170.43,88.48 v2(171,87.91)
  BOTTOM w0.127: v2(128.94,76.55) 129.26,76.22 CPU1.AT11 ; v2(159.01,126.44) 158.36,125.8 R4028.1 ; v2(167.13,69.13) 167.16,69.13 167.27,69.25 169.88,69.25 170.22,69.59 170.22,70.04 170.16,70.1 170.16,70.38 169.78,70.76 169.78,71.15 168.7,72.23 168.7,75.54 169.23,76.08 169.23,76.8 170.61,78.18 170.61,81.5 171.13,82.01 171.13,84.96 171.03,85.06 171.03,87.16 171.19,87.33 171.19,87.71 v2(171,87.91)
SIO_SLP_S3#: length 371.4
  TOP w0.127: D1701.K 149.88,43.64 v2(150.57,42.96) 151.58,42.96 151.94,42.6 U1702.2 ; v2(132.09,66.83) 131.96,66.83 129.25,69.55 v1(129.25,70.44) 129.25,72.46 128.49,73.22 128.49,74.23 127.9,74.83 127.9,75.19 128.16,75.45 128.24,75.45 128.49,75.71 128.49,76.73 v2(128.03,77.2) ; PR5110.2 48.8,27.22 47.57,28.44 v2(47.57,28.67) ; KBC24.70 172.57,78.61 v2(172.56,78.61) ; v2(43.24,18.38) 42.79,18.82 PR5405.1
  L3 w0.127: v2(142.95,34.29) 142.95,39.25 143.76,40.06 147.67,40.06 v2(150.57,42.96) ; v2(132.09,66.83) 132.74,66.18 133.74,66.18 134.56,65.37 134.56,65.17 135.89,63.83 137.64,63.83 137.84,63.63 140.81,63.63 140.91,63.53 144.29,63.53 144.39,63.63 146.56,63.63 147.03,63.15 148.83,63.15 149.36,63.68 152.62,63.68 153.39,62.92 157.7,62.92 158.22,63.43 164.57,63.43 165.18,62.82 167.82,62.82 168.65,63.65 170.68,63.65 v2(170.74,63.72) ; v2(47.57,28.67) 47.92,29.02 49.03,29.02 49.22,28.83 50.63,28.83 51.36,29.56 61.96,29.56 62.97,28.55 64.23,28.55 70.54,22.24 70.54,18.76 76.82,12.48 85.43,12.48 87.22,10.69 87.55,10.35 90.95,10.35 94.13,7.18 134.58,7.18 138.41,11 139.71,11 v2(141.9,13.19) ; v2(176.49,107.71) 176.26,107.93 176.26,109.05 175.31,110 174.23,110 173.24,109.01 166.9,109.01 166.6,109.31 166.1,109.31 160.14,109.31 159.05,108.22 v2(158.62,108.22)
  L4 w0.127: v2(141.9,13.19) 141.9,13.68 140.28,15.3 140.28,26.47 142.46,28.66 142.46,32.92 142.95,33.41 v2(142.95,34.29) 142.95,34.5 142.31,35.13 142.31,45.09 138.96,48.44 138.96,49.26 138.36,49.85 138.36,57.44 134.61,61.2 134.61,62.74 134.31,63.04 134.31,63.66 133.61,64.36 133.61,64.42 132.09,65.93 v2(132.09,66.83) ; v2(158.62,108.22) 157.93,108.9 157.93,113.19 157.28,113.84 157.28,115.19 156.18,116.29 156.18,121.51 152.4,125.28 152.4,126.03 v2(152.39,126.04) ; v2(170.74,63.72) 170.74,64.05 170.74,64.05 170.74,65.25 171.96,66.47 172.66,66.47 173.52,67.33 173.52,68.13 172.88,68.77 172.88,71.56 172.81,71.63 172.81,74.34 172.93,74.45 172.93,75.51 173.03,75.61 173.03,78.14 v2(172.56,78.61) 172.56,78.96 172.95,79.35 172.95,83.35 173.83,84.22 173.83,87.65 174.3,88.12 174.3,96.77 176.68,99.15 176.68,103.03 177.09,103.44 177.09,106.67 176.64,107.12 176.64,107.55 v2(176.49,107.71)
  BOTTOM w0.127: v2(152.39,126.04) 152.38,126.02 R4021.1 151.57,125.38 PR5216.1 ; v2(128.03,77.2) 127.7,77.52 CPU1.AP15 ; Q4001.2 50.57,31.4 50.44,31.27 R4010.1 49.94,31.27 47.57,28.9 v2(47.57,28.67) 47.57,27.37 47.22,27.02 45.92,27.02 45.45,27.49 43.78,27.49 42.57,26.28 42.57,24.51 41.53,23.48 41.53,19.5 42.66,18.38 v2(43.24,18.38) 43.66,18.38 45.55,16.49 45.55,15.51 46.41,14.65 51.73,14.65 R2728.1
SIO_SLP_S4#: length 353.2
  TOP w0.127: PR5107.1 50.79,27.12 49.8,28.11 v2(49.36,28.11) ; v2(172.28,48.46) v1(170.15,48.46) 168.45,48.46 167.44,47.44 164.26,47.44 163.74,47.97 161.16,47.97 160.63,48.5 146.95,48.5 145.12,50.32 143.52,50.32 142.77,51.07 141.64,51.07 141.28,51.43 136,51.43 135.7,51.73 132.62,54.81 132.62,56.78 132.78,56.94 v2(133.17,56.94) ; KBC24.67 174.54,79.81 174.72,79.99 174.72,80.93 174.42,81.23 173.66,81.23 173.64,81.25 v2(173.64,81.25)
  L3 w0.127: v2(175.68,20.65) 174.71,19.69 169.34,19.69 168.77,20.26 149.33,20.26 143.16,14.09 143.16,13.4 140.26,10.49 138.62,10.49 134.8,6.67 93.92,6.67 90.74,9.85 87.11,9.85 84.99,11.97 76.61,11.97 69.94,18.64 69.94,22.08 64.14,27.88 62.48,27.88 61.31,29.05 51.57,29.05 50.63,28.11 v2(49.36,28.11) ; v2(158.97,108.79) 161.27,111.09 163.01,111.09 164.53,109.56 165.99,109.56 166.71,109.56 167.01,109.27 173.14,109.27 174.13,110.26 175.49,110.26 176.99,108.76 v2(176.99,108.61)
  L4 w0.127: v2(175.68,20.65) 175.68,25.75 175.06,26.37 175.06,28.44 174.23,29.27 174.23,31.82 173.54,32.51 173.54,41.19 172.67,42.06 172.67,42.43 173.54,43.3 173.54,44.17 173.25,44.46 173.25,44.88 173.25,47.48 v2(172.28,48.46) 172.64,48.82 172.64,49.44 171.44,50.63 171.44,57.29 171.82,57.67 171.82,59.52 171.23,60.11 171.23,64.65 173.75,67.17 174.23,67.17 174.49,67.43 174.49,68.02 173.36,69.15 173.36,71.76 173.3,71.83 173.3,74.14 173.41,74.25 173.41,75.31 173.6,75.5 173.6,81.21 v2(173.64,81.25) 173.69,81.3 173.69,83.4 174.43,84.14 174.43,85.15 174.43,85.88 174.98,86.43 174.98,87.5 174.78,87.7 174.78,95.46 175.82,96.5 175.82,96.87 176.4,97.45 176.88,97.45 177.16,97.73 177.16,100.63 177.16,100.63 177.16,102.83 177.79,103.46 177.79,107.91 177.09,108.61 v2(176.99,108.61) ; v2(157.12,126.65) 157.12,125.44 157.2,125.35 157.2,124.98 157.08,124.86 157.08,121.48 158.78,119.78 158.78,108.99 v2(158.97,108.79)
  BOTTOM w0.127: v2(133.17,56.94) 129.07,61.04 129.07,63.77 128.59,64.25 128.59,65.69 128.31,65.97 128.31,67.73 126.89,69.15 126.89,70.82 126.45,71.26 126.45,73.34 CPU1.BA16 ; R4023.1 157.38,126.39 v2(157.12,126.65) 156.84,126.93 U4005.2
SIO_SLP_S5#: length 13.7
  BOTTOM w0.089: CPU1.AY16 126.57,74.08 126.88,73.55 126.88,73.31 126.75,72.93 126.75,71.3 127.12,70.93 127.12,69.97
  BOTTOM w0.102: 127.55,68.91 127.12,69.34 127.12,69.97
  BOTTOM w0.127: TP1703.1 129.33,62.05 129.33,63.88 128.84,64.36 128.84,65.96 128.58,66.23 128.58,67.88 127.55,68.91
SIO_SLP_SUS#: length 150.2
  TOP w0.102: KBC24.96 173.73,68.21 173.73,67.94 174.05,67.63 v2(174.05,67.61) ; v2(147.6,71.43) 145.77,71.43 143.75,73.45 141.49,73.45 139.96,71.92 139.96,71.83 139.36,71.23 v2(139.36,71.13)
  L3 w0.102: v2(147.6,71.43) 149.42,71.43 149.94,70.91 149.94,70.75 150.81,69.88 151.4,69.88 151.64,70.12 152.82,70.12 153.16,69.78 154.14,69.78 154.7,70.34 157.78,70.34 159.31,68.8 160.26,68.8 161.78,70.33 164.4,70.33 164.66,70.59 168.35,70.59 169.6,69.33 170.72,69.33 172.76,67.29 173.73,67.29 v2(174.05,67.61) ; v2(154.91,132.98) 154.91,132.85 155.17,132.59 155.17,131.8 156.08,130.89 156.08,129.93 157.85,128.16 158.5,127.51 159.6,127.51 163.19,123.92 163.55,123.92 166.33,121.15 166.33,120.89 166.79,120.43 166.79,120.41 167.01,120.19 v2(167.01,119.91)
  L4 w0.102: v2(128.03,77.85) 128.49,77.39 128.49,75.71 127.95,75.17 127.95,74.77 127.96,74.75 128.05,74.63 128.33,74.35 129.25,73.43 132.43,73.43 132.9,73.91 132.9,74.09 133.87,75.07 137.55,75.07 137.83,74.78 138.46,74.78 138.73,74.51 138.73,72.46 139.09,72.11 139.09,71.41 v2(139.36,71.13) ; v2(174.05,67.61) 174.05,67.95 173.12,68.87 173.12,71.66 173.06,71.73 173.06,74.24 173.17,74.35 173.17,75.41 173.27,75.51 173.27,80.71 173.21,80.77 173.21,83.27 174.19,84.24 174.19,85.98 174.71,86.5 174.71,87.43 174.54,87.6 174.54,96.67 176.92,99.05 176.92,102.93 177.55,103.56 177.55,107.81 177.22,108.14 176.85,108.14 176.51,108.48 176.51,112.16 175.23,113.44 v2(175.23,113.83)
  BOTTOM w0.102: v2(147.6,71.43) 147.71,71.54 147.71,72.85 148.14,73.27 149.23,73.27 149.26,73.25 149.62,73.25 149.64,73.27 150.31,73.27 R1729.2 ; v2(154.91,132.98) 154.33,132.98 PR5309.1 ; v2(128.03,77.85) 127.7,78.17 CPU1.AN15 ; v2(175.23,113.83) 175.23,113.98 174.48,114.73 PR5407.1 174.48,116.25 174.39,116.34 v1(173.49,117.24) 172.31,118.42 172.31,120.79 172.07,121.03 170.4,121.03 169.54,120.16 Q4004.G 167.05,119.86 v2(167.01,119.91)
