# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDO2-: length 9.9
  TOP w0.089: 12.86,172.39 12.36,171.89 10.47,171.89 10.31,171.73 RJ45.5 ; 12.86,172.39 13.87,173.4 15.3,173.4 v2(15.59,173.68) ; 12.86,172.39 AFTP3104.1
  BOTTOM w0.089: v2(15.59,173.68) 15.9,173.38 16.2,173.38 16.59,173.77 XF3103.20
MDO3+: length 10.4
  TOP w0.089: 14.75,176.19 15.26,176.19 v2(15.59,175.86) ; 14.75,176.19 AFTP3105.1 ; 14.75,176.19 14.34,176.19 11.73,173.58 10.24,173.58 10.05,173.77 RJ45.7
  BOTTOM w0.089: XF3103.22 16.57,175.77 16.18,176.16 15.9,176.16 v2(15.59,175.86)
MDO3-: length 10.5
  TOP w0.089: 13.04,175.19 11.64,173.79 10.33,173.79 10.16,173.96 10.16,174.53 RJ45.8 ; 13.04,175.19 AFTP3108.1 ; 13.04,175.19 14.25,176.41 15.32,176.41 v2(15.59,176.68)
  BOTTOM w0.089: v2(15.59,176.68) 15.9,176.38 16.2,176.38 16.59,176.77 XF3103.23
ME_FWP_EC: length 147.8
  TOP w0.102: v2(179.15,75.4) 177.91,74.15 175.77,74.15 175.56,73.94 175.2,73.94 174.53,74.61 KBC24.80
  L3 w0.102: v2(147.06,16.31) 147.06,16.33 150.38,19.65 168.1,19.65 168.51,19.24 169.08,19.24 169.13,19.19 174.92,19.19 174.97,19.24 179.25,19.24 180.5,20.49 v2(180.68,20.49)
  L4 w0.102: v2(180.68,20.49) 180.68,24.52 180.02,25.18 180.02,27.3 180.93,28.21 180.93,31.66 180.61,31.98 180.61,35.41 180.14,35.88 180.14,41.08 182.29,43.23 182.29,51.24 181.69,51.84 181.69,56.53 182.72,57.56 182.72,59.01 182.04,59.69 182.04,60.86 181.4,61.5 181.33,61.5 181,61.83 181,64.19 181.15,64.34 181.15,67.57 181.02,67.7 181.02,68.41 180.63,68.79 180.63,69.85 180,70.48 180,73.72 179.7,74.02 179.7,74.73 179.15,75.28 v2(179.15,75.4)
  BOTTOM w0.102: v2(147.06,16.31) 146.82,16.56 146.82,35.34 146.32,35.84 146.32,37.01 143.99,39.34 142.89,39.34 v1(142.56,39.67) 142.25,39.98 140.16,39.98 R1909.1 ; v2(180.68,20.49) 180.68,15.81 179.96,15.09 MESW1.C 179.96,10.37 179.73,10.13 178.74,10.13 178.46,10.41 MESW1.C1
ME_SUS_PWR_ACK: length 44.6
  TOP w0.127: v2(184.23,80.96) 184.23,81.08 184.08,81.24 KBC24.42 ; v2(170.09,62.93) 170.27,62.93 170.44,63.1 R2401.1
  L3 w0.127: v2(186.28,70.82) 185.55,70.82 185.45,70.72 183.44,70.72 183.16,70.99 176.95,70.99 175.33,69.36 175.33,69.19 175.07,68.93 174.62,68.93 174.6,68.94 173.2,68.94 171.93,70.22 169.97,70.22 169.32,70.86 v2(169.32,70.97)
  L4 w0.127: v2(170.09,62.93) 169.91,63.11 169.91,66.27 170.33,66.69 170.33,69.92 169.32,70.93 v2(169.32,70.97) ; v2(184.23,80.96) 184.46,80.72 184.46,74.85 184.76,74.55 184.76,73.81 185.99,72.58 185.99,71.23 186.28,70.94 v2(186.28,70.82)
  BOTTOM w0.127: v1(168.12,71.43) 168.43,71.12 169.17,71.12 v2(169.32,70.97) 169.32,70.96 168.98,70.62 RN1702.1
ME_SUS_PWR_ACK_R: length 60.6
  TOP w0.127: v2(139.53,72.01) 141.21,73.69 143.85,73.69 145.85,71.69 146.78,71.69 147.04,71.96 147.85,71.96 148.5,71.31 R2039.2
  L3 w0.127: v2(157.65,69.27) 157.6,69.32 156.84,69.32 156.07,70.09 154.79,70.09 153.87,69.17 151.18,69.17 149.7,70.65 149.7,70.81 149.44,71.07 147.87,71.07 147.79,70.98 146.26,70.98 143.97,73.27 140.79,73.27 v2(139.53,72.01)
  L4 w0.127: v2(139.53,72.01) 138.97,72.56 138.97,74.66 138.61,75.02 137.93,75.02 137.42,75.53 135.65,75.53 135.61,75.5 133.75,75.5 133.06,74.81 132.4,74.81 132.08,74.49 130.69,74.49 129.34,75.83 129.34,76.79 v2(128.94,77.2)
  BOTTOM w0.127: CPU1.AR13 128.61,76.87 v2(128.94,77.2) ; RN1702.4 166.98,70.27 166.2,71.04 R1708.1 166.01,71.02 v1(164.82,71.02) 164.54,71.02 163.8,70.28 161.52,70.28 160.99,70.81 160.03,70.81 159.74,71.1 159.38,71.1 158.69,70.41 158.39,70.41 158.11,70.13 158.11,69.73 v2(157.65,69.27)
MEM_SMBCLK: length 26.1
  TOP w0.14: v2(138.97,97.01) 141.3,97.01 142.97,98.69 v1(144.44,98.69) RN1811.3 147.61,99.51 147.53,99.58 Q1801.3
  L4 w0.127: v2(138.97,97.01) 138.04,96.08 138.04,95.53 137.39,94.88 136.69,94.88 134.85,93.04 134.85,87.85 133.97,86.97 132.61,86.97 132.22,86.58 v2(132.11,86.58)
  BOTTOM w0.14: v2(132.11,86.58) 132.34,86.8 CPU1.R7
MEM_SMBDATA: length 29.9
  TOP w0.14: Q1801.6 148.7,101.59 148.28,101.16 148.28,98.44 147.88,98.04 RN1811.4 143.15,98.04 v1(142.24,97.13) 139.91,94.79 v2(138.66,94.79)
  L4 w0.127: v2(131.44,86.56) 131.84,86.16 133.87,86.16 135.41,87.69 135.41,92.88 136.18,93.65 137.71,93.65 138.65,94.59 138.65,94.78 v2(138.66,94.79)
  BOTTOM w0.14: v2(131.44,86.56) 131.44,86.86 CPU1.R8
MESW1_B: length 3.1
  BOTTOM w0.102: MESW1.B 176.96,12.64 176.97,12.64 R9804.1 v1(176.97,13.97)
MIC2_VREFO: length 13.5
  TOP w0.203: 23.55,16.47 HDA27.29
  TOP w0.254: 23.55,16.47 22.92,16.47 v2(22.6,16.79) ; RN2901.1 27.27,23.47 27,23.74 v2(26.82,23.74) 26.62,23.55 RN2901.2
  BOTTOM w0.254: v2(26.82,23.74) 26.42,23.34 24.65,23.34 v1(23.94,22.63) 22.6,21.29 v2(22.6,16.79)
MIC_CAP: length 4.5
  TOP w0.203: HDA27.19 27.15,19.89 26.44,20.61 26.44,20.62 25.63,21.43 v1(25.53,21.43)
  TOP w0.254: C2713.1 25.25,21.71 v1(25.53,21.43)
MIC_GND: length 1.2
  TOP w0.305: LCD1.26 78.74,164.82 v2(79.13,165.2)
  vias: v1(78.62,166.01)
MODEL_ID: length 26.7
  TOP w0.102: KBC24.109 180.08,68 180.21,68.13 v2(180.21,68.21) ; v2(175.81,50.79) 176.59,51.57 177.34,51.57 177.6,51.83 R2497.1 177.6,53.28 U2401.4
  BOTTOM w0.102: v2(180.21,68.21) 180.21,66.82 179.75,66.35 v1(179.75,66) 179.75,65.9 179.9,65.74 180.62,65.74 180.95,65.42 180.95,59.94 179.79,58.79 179.07,58.79 178.58,58.3 178.58,53.56 v2(175.81,50.79)
MODEL_ID_C: length 14.8
  TOP w0.102: U2401.3 176.72,52.77 R2497.2 175.51,52.23 175.38,52.1 v1(175.38,51.85) 175.39,51.84 v2(175.39,51.26) ; v2(183.27,53.04) R2442.2 184.09,53.73 R2441.1 184.12,52.93 C2407.2
  L3 w0.102: v2(175.39,51.26) 175.6,51.48 180.41,51.48 181.33,52.41 182.64,52.41 v2(183.27,53.04)
MSM#: length 1.6
  TOP w0.102: TP617.1 103.98,78.15 v2(104.28,77.84)
  BOTTOM w0.102: CPU1.AP56 103.94,77.52 v2(104.28,77.84)
N12P_JTAG_TCK: length 8.2
  BOTTOM w0.102: RN7602.3 v1(178.86,133.19) 179.9,133.19 180.59,133.88 181.08,133.88 181.91,134.71 182.29,134.71 182.51,134.5 182.51,134.23 182.71,134.03 182.99,134.03 183.27,134.31 183.27,134.52 183.65,134.9 GPU1.AE5
N12P_JTAG_TDI: length 7
  BOTTOM w0.102: TP7605.1 177.8,135.01 180.31,135.01 180.61,135.31 181.01,135.31 181.22,135.53 181.82,135.53 181.82,135.52 182.28,135.52 182.42,135.67 183.25,135.67 GPU1.AE6
N12P_JTAG_TDO: length 7.5
  BOTTOM w0.102: GPU1.AF6 182.54,136.07 182.19,135.73 181.91,135.73 181.91,135.73 181.14,135.73 180.93,135.52 180.53,135.52 180.27,135.26 176.82,135.26 TP7601.1
N12P_JTAG_TMS: length 6.9
  BOTTOM w0.102: TP7602.1 178.75,134.26 181.17,134.26 181.82,134.92 182.66,134.92 182.7,134.88 182.99,134.88 183.19,135.08 183.19,135.25 183.59,135.65 184.03,135.65 GPU1.AD6
N12P_JTAG_TRST: length 5.9
  BOTTOM w0.102: GPU1.AG4 181.26,133.58 180.61,133.58 178.99,131.96 v1(178.68,131.96) 178.44,131.96 177.85,132.54 RN7602.4
N12P_XTAL_OUTBUFF: length 4.2
  TOP w0.102: v2(200.65,139.81) 200.73,139.88 R7602.1 201.33,139.59 v1(200.79,139.05) 200.57,138.83 200.1,138.83 R7617.2
  BOTTOM w0.102: v2(200.65,139.81) 201.26,139.81 201.72,139.35 GPU1.C10
NCT7718_ALERT#: length 3.4
  BOTTOM w0.102: R2603.2 149.81,95.32 v1(150.73,95.32) 151.44,95.32 152.13,96.01 THM26.6
NCT7718_DXN: length 244.7
  TOP w0.254: v2(154.64,78.6) 154.57,78.66 154.57,80.81 153.02,82.36 151.22,82.36 150.16,83.42 v2(150.16,83.87)
  L3 w0.254: v2(50.66,60.93) 50.49,60.75 50.49,59.76 54.34,55.92 54.34,36.11 58.01,32.44 59.02,32.44 60.81,30.65 62.39,30.65 63.42,29.63 64.68,29.63 71.62,22.68 71.62,19.2 77.27,13.56 85.88,13.56 88,11.43 91.4,11.43 94.58,8.26 131.39,8.26 135.21,12.08 139.25,12.08 149.39,22.22 153.63,22.22 v2(153.91,22.5)
  L4 w0.254: v2(150.16,83.87) 150.08,83.95 150.08,88.92 149.63,89.37 149.63,89.99 v2(149.72,90.08)
  BOTTOM w0.254: v2(149.72,90.08) 149.72,90.47 150.77,91.53 150.77,92.87 151.38,93.48 154.23,93.48 155.84,95.08 155.84,95.65 156.2,96.01 THM26.3 158.34,96.01 C2606.2 ; v2(154.64,78.6) 156.06,78.6 157.67,77 157.67,72.92 157.34,72.59 157.34,71.48 156.86,71 155,71 153.69,69.69 153.69,67.95 154.3,67.34 155.32,67.34 155.57,67.09 155.57,61.86 157.18,60.25 157.18,57.28 158.03,56.43 158.03,55.34 157.47,54.78 157.47,52.34 158.03,51.79 158.03,49.36 158.72,48.67 158.72,46.61 157.85,45.74 157.85,40.31 154.45,36.91 154.45,26.01 154.7,25.76 154.7,24.69 ; v2(153.91,22.5) 154.2,22.22 154.45,22.22 154.7,22.47 154.7,24.69 ; 154.7,24.69 v1(154.5,24.69) ; v2(50.66,60.93) 50.67,60.93 C2607.2 52.22,60.26 Q2603.E
NCT7718_DXP: length 250.8
  TOP w0.254: v2(154,78.6) 154.06,78.66 154.06,80.59 152.8,81.85 151.01,81.85 149.65,83.21 149.51,83.35 v2(149.51,83.83)
  L3 w0.254: v2(49.75,60.96) 49.98,60.73 49.98,59.55 53.83,55.71 53.83,35.9 57.8,31.93 58.81,31.93 60.6,30.14 62.18,30.14 63.2,29.12 64.47,29.12 71.12,22.47 71.12,18.99 77.06,13.05 85.67,13.05 87.79,10.93 91.19,10.93 94.37,7.75 131.6,7.75 135.42,11.57 139.46,11.57 149.6,21.71 153.63,21.71 v2(153.91,21.43)
  L4 w0.254: v2(149.51,83.83) 149.57,83.89 149.57,88.71 149.12,89.16 149.12,90.04 v2(149.09,90.08)
  BOTTOM w0.254: Q2603.B 54,62.23 Q2603.C 52.13,61.24 C2607.1 50.61,61.82 v2(49.75,60.96) ; 155.21,23.07 155.21,25.97 154.96,26.22 154.96,36.69 158.36,40.1 158.36,45.53 159.23,46.4 159.23,48.88 158.53,49.57 158.53,52 157.98,52.55 157.98,54.57 158.53,55.13 158.53,56.64 157.69,57.49 157.69,60.46 156.08,62.07 156.08,67.3 155.53,67.85 154.51,67.85 154.2,68.16 154.2,69.48 155.21,70.49 157.07,70.49 157.85,71.27 157.85,72.38 158.18,72.71 158.18,77.21 156.28,79.11 154.43,79.11 154,78.68 v2(154,78.6) ; 155.21,23.07 v1(155.39,23.07) ; 155.21,23.07 155.21,22.26 154.66,21.71 154.2,21.71 v2(153.91,21.43) ; v2(149.09,90.08) 149.21,90.21 149.21,90.69 150.26,91.74 150.26,93.08 151.17,93.98 154.02,93.98 155.33,95.29 155.33,95.86 156.14,96.66 THM26.2 158.1,96.66 C2606.1
NCTF_A5: length 2.6
  TOP w0.102: v2(134.77,96.04) 135.11,96.38 TP2307.1
  BOTTOM w0.102: CPU1.A5 133.45,95.37 134.09,96.02 134.74,96.02 v2(134.77,96.04)
NCTF_A70: length 1.7
  TOP w0.102: v2(94.46,94.92) TP2301.1
  BOTTOM w0.102: CPU1.A70 94.62,95.08 v2(94.46,94.92)
NCTF_B71: length 1.9
  TOP w0.102: v2(93.9,94.54) 93.49,94.14 TP2302.1
  BOTTOM w0.102: CPU1.B71 94.79,94.62 94.58,94.42 94.03,94.42 v2(93.9,94.54)
NCTF_BA1: length 1.2
  TOP w0.102: v2(136.16,72.62) 136.57,72.22 TP2305.1
  BOTTOM w0.102: v2(136.16,72.62) 135.87,72.92 CPU1.BA1
NCTF_BA2: length 2.3
  TOP w0.102: TP2306.1 135.35,72.42 v2(135.76,72.01)
  BOTTOM w0.102: CPU1.BA2 135.08,73.07 135.76,72.4 v2(135.76,72.01)
NCTF_BA71: length 1.8
  TOP w0.102: TP2303.1 v2(94.18,72.52)
  BOTTOM w0.102: CPU1.BA71 95.08,72.92 94.69,72.52 v2(94.18,72.52)
NCTF_BB70: length 5.7
  TOP w0.102: TP2304.1 94.84,70.83 92.97,70.83 92.86,70.73 92.85,70.73 v2(92.84,70.72)
  BOTTOM w0.102: v2(92.84,70.72) 92.85,70.73 92.86,70.73 94.07,71.94 94.86,71.94 95.38,72.46 CPU1.BB70
NCTF_C1: length 1.6
  TOP w0.102: v2(135.72,94.99) 135.72,94.35 TP2308.1
  BOTTOM w0.102: v2(135.72,94.99) 135.71,94.98 CPU1.C1
OVER_CURRENT_P8#: length 91.6
  TOP w0.102: v2(187.36,75.73) 187.83,76.21 KBC24.21 ; D7602.K 206.48,130.54 v1(206.3,130.36) 205.95,130.01 205.74,130.01 204.75,129.02 201.17,129.02 198.69,126.55 197.26,126.55 196.24,125.53 194.44,125.53 193.15,124.25 193.15,123.73 192.03,122.6 189.4,122.6 188.23,121.43 187.8,121.43 187.57,121.43 186.22,120.09 186.22,119.29 185.21,118.28 v2(184.86,118.28)
  L3 w0.102: v2(185.77,101.67) 185.77,101.03 186.06,100.74 186.29,100.74 188.81,98.22 188.81,96.88 191.7,93.98 192.66,93.98 196.86,89.78 196.86,89.52 196.86,87.42 195.87,86.43 195.87,83.94 196.83,82.98 196.83,79.69 196.27,79.12 186.32,79.12 186.1,78.9 186.1,76.1 186.51,75.69 187.32,75.69 v2(187.36,75.73)
  L4 w0.102: v2(185.77,101.67) 185.88,101.67 186.38,102.17 186.38,110.63 185.8,111.21 185.8,114.93 184.86,115.87 v2(184.86,118.28)
OVERT#: length 6.2
  BOTTOM w0.127: Q7602.4 190.19,126.22 R7613.2 189.98,125.18 C7609.1 189.97,124.33 R7645.2 189.97,123.26 190.16,123.08 v1(190.53,123.08) 190.84,123.08 191.02,123.26 R7656.1
OVERT_GPU#: length 22.4
  TOP w0.127: v2(198.3,127.74) 199.02,127.74 200.95,129.67 200.95,133.06 201.49,133.6 201.49,133.98 202.31,134.8 v2(204.54,134.8)
  BOTTOM w0.127: R7656.2 191.91,123.35 v1(192.15,123.12) 192.94,123.12 197.56,127.74 v2(198.3,127.74) ; v2(204.54,134.8) 204.54,135.44 203.91,136.07 GPU1.A6
P2800_VGA_DXN: length 2.5
  TOP w0.102: TP7603.1 201.14,141.84 200.22,141.84 v2(199.82,141.43)
  BOTTOM w0.102: GPU1.E12 200.24,141.03 199.83,141.43 v2(199.82,141.43)
P2800_VGA_DXP: length 1.2
  TOP w0.102: TP7604.1 199.03,141.71 v2(199.03,141.43)
  BOTTOM w0.102: GPU1.F12 199.38,141.03 199.03,141.39 v2(199.03,141.43)
P_H_S#: length 2.6
  BOTTOM w0.102: v1(193.1,123.95) 193.61,124.46 R7653.1 193.61,125.88 Q7602.3
P_SYS: length 208.6
  TOP w0.102: v2(148.56,141.56) 148.56,142.88 147.09,144.36 145.76,144.36 v1(145.32,144.8) 144.72,145.39 138.24,145.39 130.02,153.61 120.41,153.61 119.24,154.78 112.4,154.78 111.07,156.11 109.66,156.11 107.45,158.32 101.09,158.32 v2(100.78,158.02)
  L3 w0.102: v2(177.12,107.63) 176.76,107.28 176.31,107.28 176.02,107.57 176.02,108.95 175.21,109.76 174.33,109.76 173.34,108.77 166.8,108.77 166.5,109.07 166.2,109.07 160.35,109.07 158.94,107.67 v2(158.31,107.67) ; v2(148.56,141.56) 145.76,141.56 144.49,142.83 127.94,142.83 126.79,143.99 118.38,143.99 116.33,146.04 111.16,146.04 v2(110.71,146.48)
  L4 w0.102: v2(148.56,141.56) 149.67,141.56 151.17,140.05 151.39,140.05 154.14,137.3 154.14,134.78 153.73,134.37 153.73,128.74 151.86,126.87 151.86,123.38 151.88,123.36 151.88,119.89 151.86,119.88 151.86,118.39 155.1,115.16 156.44,115.16 156.95,114.65 156.95,113.83 157.68,113.1 157.68,108.27 158.32,107.63 158.32,107.67 v2(158.31,107.67)
  BOTTOM w0.102: v2(177.12,107.63) 177.12,107.21 177.21,107.12 177.21,100.54 181.02,96.74 181.02,92.17 180.74,91.9 180.74,91.16 180.33,90.75 180.33,89.6 179.56,88.83 179.56,88.21 176.4,85.05 176.4,82.47 177.68,81.19 177.68,80.44 177.67,80.44 177.67,79.56 178.01,79.22 178.01,77.44 178.72,76.73 178.72,74.89 178.84,74.77 178.84,74.7 179.48,74.06 179.48,73.03 180.41,72.1 181.58,72.1 181.83,71.84 181.83,71.49 181.34,70.99 181.34,70.14 182.47,69.01 182.47,68.02 R2422.1 ; PR4671.1 110.9,146.3 v2(110.71,146.48) ; PR4425.1 99.71,158.02 v2(100.78,158.02) PG4415.2
PANEL_BKEN_EC: length 218.1
  TOP w0.102: KBC24.117 183.28,67.54 v2(183.54,67.8)
  L3 w0.102: v2(162.82,162.14) 162.82,162.49 161.65,163.66 160.65,163.66 160.15,164.16 159.25,164.16 155.38,168.03 153.05,168.03 148.38,172.7 136.8,172.7 134.97,170.87 134.81,170.87 134.8,170.87 129.38,170.87 128.77,170.26 126.93,170.26 125.06,172.12 123.82,172.12 121.77,172.12 121.61,172.29 120.1,172.29 119.85,172.05 119.54,172.05 119.54,172.05 119.12,172.05 119.12,172.05 118.16,172.05 117.21,172.99 115.96,172.99 115.51,172.55 114.6,172.55 113.86,173.29 110.11,173.29 108.8,174.59 105.83,174.59 105.62,174.38 102.36,174.38 102.12,174.62 90.93,174.62 88.09,171.78 87.5,171.78 82.57,166.86 80.68,166.86 80.19,166.37 76.34,166.37 76.04,166.68 v2(73.7,166.68) ; v2(180.13,79.13) 180.11,79.15 179.96,79.15 179.53,79.59 179.53,80.05 179.21,80.37 178.71,80.37 178.68,80.4 178.08,80.4 177.02,81.46 174.87,81.46 174.23,80.82 172.81,80.82 172.09,81.54 171.42,81.54 170.39,82.57 v2(168.04,82.57)
  L4 w0.102: v2(168.04,82.57) 168.17,82.7 168.17,82.83 168.34,83 168.34,83.68 167.6,84.42 167.6,85.52 167.46,85.65 167.46,86.58 167.02,87.02 167.02,87.05 167.02,87.05 167.02,87.45 167.02,89.37 167.47,89.82 167.47,90.28 167.31,90.44 167.31,91.33 166.22,92.43 166.22,93.87 166.23,93.88 166.23,96.81 166.22,96.82 166.22,101.53 166.21,101.54 166.21,102.77 165.44,103.55 165.44,103.99 166.5,105.05 166.5,109.28 166.12,109.66 166.12,114.39 167.57,115.84 167.57,117.97 168.33,118.73 168.33,121.41 167.1,122.64 167.1,127.59 166.69,128 166.69,134.39 166.29,134.8 164.41,136.67 164.41,137.27 163.62,138.06 163.62,143.12 162.72,144.01 162.72,145.78 164.25,147.31 164.25,149.66 165.94,151.34 165.94,152.47 165.94,156.66 163.51,159.09 163.51,161.45 v2(162.82,162.14)
  BOTTOM w0.102: RN5503.6 v2(73.7,166.68) ; v2(183.54,67.8) 183.33,68.01 183.33,69.27 182.59,70.01 182.59,70.87 182.76,71.03 182.76,72.18 181.62,73.32 181.62,73.52 180.96,74.18 180.56,74.18 180.34,74.39 180.34,74.42 180.3,74.46 180.3,74.79 180.3,74.8 v1(180.3,76.99) 180.3,77.24 180.21,77.34 180.21,78.88 180.13,78.96 v2(180.13,79.13)
PANEL_SIZE_ID: length 248.6
  TOP w0.102: v2(81.86,167.54) 81.53,167.87 R5526.1 81.08,167.16 R5525.2
  L3 w0.102: v2(73.69,168.81) 74.08,168.43 80.98,168.43 v2(81.86,167.54) 82.5,167.54 87.15,172.19 87.92,172.19 90.76,175.03 102.29,175.03 102.53,174.79 105.45,174.79 105.66,175 109.11,175 110.28,173.84 113.89,173.84 114.77,172.95 115.34,172.95 115.79,173.41 118.89,173.41 119.6,172.7 120.27,172.7 120.9,173.33 123.61,173.33 124.27,172.67 125.63,172.67 126.75,171.55 128.86,171.55 129.49,172.19 135.37,172.19 136.29,173.11 148.55,173.11 153.07,168.58 155.41,168.58 159.42,164.57 160.48,164.57 160.73,164.33 v2(161.07,164.33) ; v2(128.94,77.85) 129.37,77.41 129.37,75.81 130.05,75.13 130.05,75.01 131.87,73.19 139.65,73.19 140.09,73.63 143.95,73.63 146.09,71.49 146.66,71.49 147.03,71.86 147.78,71.86 147.92,71.72 149.52,71.72 150.5,70.74 150.5,70.48 150.86,70.12 151.36,70.12 151.56,70.32 152.9,70.32 153.22,70 153.93,70 154.47,70.54 157.88,70.54 159.3,69.12 160.29,69.12 161.7,70.53 164.31,70.53 164.8,71.02 v2(166.96,71.02)
  L4 w0.102: v2(161.07,164.33) 161.07,162.9 161.17,162.79 161.17,160.41 161.71,159.88 161.71,154.76 160.58,153.63 160.58,151.69 160.97,151.29 160.97,148.93 159.9,147.86 159.9,140.02 159.9,138.87 162.36,136.41 162.36,135.82 164.23,133.94 164.57,133.6 164.57,130.92 162.8,129.15 162.8,119.63 162.2,119.03 162.2,109.72 162.86,109.06 162.86,103.1 162.17,102.41 162.17,101.41 161.59,100.82 161.59,99.7 161.87,99.42 161.87,93.25 161.92,93.2 161.92,91.3 161.7,91.08 161.7,89.57 163.93,87.34 164.57,87.34 164.92,86.99 164.92,86.64 164.92,85.73 165.58,85.07 165.58,84.87 165.72,84.74 165.72,83.64 165.87,83.49 165.87,81.81 166.59,81.1 166.59,79.95 166.02,79.38 166.02,78.76 166.69,78.09 166.69,73.88 167.07,73.5 167.07,73.14 166.78,72.85 166.78,71.61 166.96,71.42 v2(166.96,71.02)
  BOTTOM w0.102: v2(161.07,164.33) v1(160.3,164.33) ; CPU1.AP13 128.61,77.52 v2(128.94,77.85) ; R5521.2 v2(73.69,168.81)
PANEL_SIZE_ID_CONN: length 2.4
  TOP w0.102: LCD1.22 78.65,166.82 78.94,167.12 v1(79.38,167.12) 80.24,167.12 R5525.1
PBAT_PRES1#: length 8
  TOP w0.102: 154.81,178.08 155.52,177.38 AFTP3902.1 155.52,174.71 156.45,173.78 RN4302.8
  TOP w0.508: 154.81,178.08 154.25,178.64 BATT1.5
PBAT_PRES#: length 196
  TOP w0.102: RN4302.1 156.45,171.34 155,169.89 D4304.3 152.78,167.54 153.09,167.23 EC4306.2 153.09,165.7 v2(153.03,165.64) ; v2(120.49,169.07) 120.49,169.54 v1(120.25,169.78) PC4310.2 PR4316.1 PR4315.2 117.47,172.5 117.72,172.75 PQ4303.2 ; v2(174.88,69.37) 174.88,69.14 174.88,69.14 174.88,67.83 175.28,67.43 KBC24.97
  L3 w0.102: v2(153.03,165.64) 153.23,165.44 153.23,164.48 155.25,162.46 158.19,162.46 160,160.65 162.79,160.65 163.61,161.47 v2(165.32,161.47)
  L4 w0.102: v2(153.03,165.64) 148.57,170.1 135.45,170.1 134.42,169.07 v2(120.49,169.07) 119.69,169.07 119.64,169.02 118.86,169.02 118.25,169.63 115.63,169.63 114.36,170.9 109.39,170.9 107.68,169.19 107.29,169.19 104.49,166.39 v2(101.51,166.39) ; v2(165.32,161.47) 165.78,161.01 165.78,159.39 167.69,157.48 167.69,149.15 166.05,147.51 166.05,144.33 165.62,143.91 165.62,139.62 167.71,137.54 167.71,136.44 169.13,135.01 169.13,131.03 174.59,125.57 174.59,119.67 177.04,117.22 177.04,109.82 178.29,108.57 178.29,103.25 177.66,102.63 177.66,97.06 176.78,96.19 176.27,96.19 175.28,95.19 175.28,87.92 175.47,87.72 175.47,86.14 174.92,85.59 174.92,83.94 174.27,83.28 174.27,81.77 174.33,81.72 174.33,80.95 174.1,80.72 174.1,75.3 173.9,75.1 173.9,74.04 173.79,73.93 173.79,72.03 173.86,71.97 173.86,71.59 174.78,70.67 175.05,70.67 175.3,70.41 175.3,69.86 174.88,69.44 v2(174.88,69.37)
  BOTTOM w0.102: v2(101.51,166.39) 102.46,165.43 PG4416.1 ; R2415.1 174.24,69.78 174.63,69.39 174.86,69.39 v2(174.88,69.37)
PBAT_SMBCLK1: length 7.7
  TOP w0.14: 157.43,177.41 AFTP3904.1 157.43,175.46 157.86,175.03 157.86,173.52 157.6,173.25 RN4302.6
  TOP w0.508: 157.43,177.41 158.25,178.22 BATT1.3
PBAT_SMBDAT1: length 7.6
  TOP w0.14: 156.59,178.08 156.59,175.47 AFTP3903.1 157.1,174.37 RN4302.7
  TOP w0.508: 156.59,178.08 156.25,178.42 BATT1.4
PCH_ALW_ON: length 25.8
  TOP w0.127: v2(175.52,78.47) 175.26,78.21 KBC24.71 ; v2(170.07,80.95) 168.66,80.95 v1(168.33,80.62) 168.17,80.46 168.17,80 R2496.1
  L3 w0.127: v2(158.29,81.29) 158.36,81.29 159.96,82.89 162.5,82.89 163.37,82.03 166.83,82.03 167.91,80.95 v2(170.07,80.95) 170.83,80.95 171.62,80.16 172.82,80.16 174.7,78.28 175.33,78.28 v2(175.52,78.47)
  BOTTOM w0.127: v2(158.29,81.29) 158.43,81.29 R4102.1
PCH_BATLOW#: length 32.4
  TOP w0.102: v2(150.9,68.76) v1(152.39,68.76) 153,68.76 153.37,68.39 R1723.2
  L3 w0.102: v2(150.9,68.76) 150.9,68.87 149.98,69.79 148.27,69.79 148.26,69.8 147.42,69.8 147.42,69.79 146.13,69.79 144.42,68.08 141.44,68.08 139.72,69.79 134.53,69.79 134.35,69.61 132.49,69.61 130.64,71.46 130.64,72.18 129.69,73.13 129.67,73.13 127.95,74.85 127.95,75.82 v2(128.03,75.9)
  BOTTOM w0.102: v2(128.03,75.9) 128.35,75.57 CPU1.AU13
PCH_DPC_AUXN: length 123.3
  TOP w0.127: VGABD1.11 195.97,80.52 196.05,80.6 196.77,80.6 197.09,80.92 197.09,82.93 195.16,84.86 195.16,86.45 194.48,87.13 194.48,87.33 186.12,95.69 175.05,95.69 174,96.74 172.67,96.74 172.48,96.55 156.01,96.55 ; 156.01,96.55 v1(156.01,96.72) ; 156.01,96.55 152.41,96.55 151.69,95.83 150.25,95.83 148.19,93.76 148.19,93.51 v2(147.98,93.3)
  L4 w0.114: v2(147.98,93.3) 147.98,93.84 143.9,97.93 143.9,98.54 141.06,101.38 133.99,101.38 132.96,100.35 132.96,99.33 131.92,98.29 130.41,98.29 130.26,98.45 129.21,98.45 127.39,96.63 127.39,93.3 127.93,92.76 127.93,90.67 127.26,90 127.04,90 124.67,87.63 124.67,86.35 124.29,85.97 123.67,85.97 123.15,85.45 121.8,85.45 121.48,85.77 116.85,85.77 115.88,86.74 110.97,86.74 109.49,88.22 109.49,89.75 108.26,90.98 108.26,92.05 108.81,92.59 v2(108.81,92.62)
  BOTTOM w0.127: v2(108.81,92.62) 108.62,92.62 CPU1.E48
PCH_DPC_AUXP: length 123.3
  TOP w0.127: v2(148.88,93.3) 148.88,93.27 148.71,93.1 148.53,93.1 148.43,93.19 148.43,93.66 150.35,95.58 151.79,95.58 152.51,96.31 158.59,96.31 ; 158.59,96.31 172.58,96.31 172.77,96.5 173.9,96.5 174.95,95.45 186.02,95.45 194.24,87.23 194.24,87.03 194.92,86.35 194.92,84.76 196.85,82.83 196.85,81.02 196.67,80.84 196.12,80.84 195.94,81.02 VGABD1.12 ; 158.59,96.31 v1(158.59,96.16)
  L4 w0.114: v2(108.82,91.97) 108.74,92.05 108.59,92.05 108.49,91.95 108.49,91.07 109.72,89.84 109.72,88.32 111.06,86.97 115.97,86.97 116.95,86 121.57,86 121.89,85.68 123.06,85.68 123.58,86.2 124.19,86.2 124.44,86.45 124.44,87.73 126.94,90.23 127.17,90.23 127.7,90.76 127.7,92.66 127.16,93.2 127.16,96.72 129.11,98.68 130.35,98.68 130.51,98.52 131.83,98.52 132.73,99.43 132.73,100.44 133.9,101.61 141.15,101.61 144.13,98.64 144.13,98.02 148.42,93.73 148.42,93.22 148.5,93.14 148.72,93.14 v2(148.88,93.3)
  BOTTOM w0.127: v2(108.82,91.97) 108.68,92.1 108.53,92.1 108.32,91.9 108.32,91.75 CPU1.F48
PCH_DPC_N0: length 126
  TOP w0.127: VGABD1.5 194.54,77.52 194.41,77.64 194.03,77.64 193.61,78.07 193.61,78.62 193.3,78.92 193.3,81.97 192.69,82.58 192.69,86.58 188.51,90.77 185.95,90.77 185.76,90.57 169.94,90.57 168.77,91.74 166.87,91.74 166.34,92.28 162.03,92.28 161.68,92.63 158.57,92.63 ; v2(155.34,91.83) 155.72,91.83 155.87,91.68 156.78,91.68 157.72,92.63 158.57,92.63 ; 158.57,92.63 v1(158.57,92.49)
  L4 w0.114: v2(155.34,91.83) 155.34,92.14 155,92.49 155,93.57 154.42,94.15 154.42,95.85 153.88,96.39 153.88,102.33 150.46,105.75 150.46,106.69 147.09,110.06 138.39,110.06 138.25,109.91 129.32,109.91 127.78,108.37 116.31,108.37 113.26,105.32 111.99,105.32 111.09,104.42 110.34,104.42 110.1,104.66 110.1,104.96 109.92,105.15 v2(109.82,105.15)
  BOTTOM w0.089: 108.34,97.19 108.34,97.17 108.37,97.14 108.37,96.29 107.67,95.59 107.67,94.97 107.61,94.85 107.61,94.69 107.67,94.52 107.67,94.32 107.58,94.15 107.58,93.95 CPU1.C50
  BOTTOM w0.127: v2(109.82,105.15) 110.06,105.15 110.19,105.02 110.19,104.6 109.17,103.59 109.17,101.55 108.7,101.08 108.7,99.41 108.34,99.05 108.34,97.19
PCH_DPC_N1: length 126.8
  TOP w0.127: 160.71,93.67 161.78,93.67 162.4,93.05 163.39,93.05 164.54,94.2 186.18,94.2 193.47,86.91 193.47,82.94 194.08,82.32 194.08,79.58 194.63,79.02 VGABD1.8 ; 160.71,93.67 v1(160.71,93.51) ; 160.71,93.67 156.73,93.67 156.55,93.49 156.55,93.24 v2(156.76,93.03)
  L4 w0.114: v2(108.36,105.16) 108.8,105.6 109.21,105.6 109.94,106.33 112.78,106.33 115.79,109.34 127.37,109.34 128.91,110.89 137.84,110.89 137.99,111.04 147.53,111.04 151.46,107.1 151.46,106.26 154.85,102.86 154.85,96.79 155.4,96.25 155.4,94.79 156.52,93.67 156.52,93.27 v2(156.76,93.03)
  BOTTOM w0.089: 107.11,96.55 107.1,96.53 107.1,96.5 106.68,96.08 106.55,96.08 105.85,95.37 105.85,94.93 105.91,94.81 105.91,94.72 105.84,94.56 105.84,94.27 105.98,94.03 CPU1.C52
  BOTTOM w0.127: 107.11,96.55 107.38,96.81 107.38,99.52 107.67,99.82 107.67,101.25 108.36,101.93 108.36,103.89 108.64,104.17 108.64,104.89 v2(108.36,105.16)
PCH_DPC_P0: length 126
  TOP w0.127: 166.16,92.52 166.44,92.52 166.97,91.99 168.87,91.99 170.04,90.82 185.66,90.82 185.85,91.01 188.61,91.01 192.93,86.68 192.93,82.68 193.54,82.07 193.54,79.02 193.85,78.72 193.85,78.17 194.13,77.89 194.4,77.89 194.53,78.02 194.66,78.02 VGABD1.6 ; 166.16,92.52 162.13,92.52 161.78,92.87 157.62,92.87 156.68,91.92 155.97,91.92 155.76,92.13 v2(155.76,92.38) ; 166.16,92.52 v1(166.16,92.71)
  L4 w0.114: v2(155.76,92.38) 155.43,92.38 155.23,92.58 155.23,93.67 154.65,94.25 154.65,95.94 154.11,96.48 154.11,102.42 150.69,105.84 150.69,106.78 147.19,110.29 138.3,110.29 138.15,110.14 129.23,110.14 127.69,108.6 116.22,108.6 113.17,105.55 111.89,105.55 110.99,104.65 110.43,104.65 110.33,104.75 110.33,104.86 v2(110.62,105.15)
  BOTTOM w0.089: 108.58,97.19 108.58,97.17 108.56,97.14 108.56,96.21 107.85,95.5 107.85,94.93 107.79,94.81 107.79,94.72 107.85,94.56 107.85,94.27 107.76,94.11 107.76,93.48 CPU1.D50
  BOTTOM w0.127: 108.58,97.19 108.58,98.95 108.94,99.31 108.94,100.98 109.41,101.45 109.41,103.49 110.43,104.5 110.43,104.96 v2(110.62,105.15)
PCH_DPC_P1: length 126.8
  TOP w0.127: 158.74,93.91 161.88,93.91 162.5,93.29 163.29,93.29 164.44,94.44 186.28,94.44 193.71,87.01 193.71,83.04 194.32,82.42 194.32,79.68 194.48,79.52 VGABD1.9 ; 158.74,93.91 v1(158.74,94.1) ; 158.74,93.91 156.63,93.91 156.31,93.59 156.31,93.29 v2(156.05,93.03)
  L4 w0.114: v2(156.05,93.03) 156.29,93.27 156.29,93.58 155.17,94.69 155.17,96.16 154.63,96.7 154.63,102.77 151.23,106.16 151.23,107.01 147.43,110.81 138.08,110.81 137.94,110.66 129.01,110.66 127.46,109.12 115.89,109.12 112.88,106.1 110.04,106.1 109.16,105.22 v2(109.16,105.16)
  BOTTOM w0.089: CPU1.D52 106.59,93.74 106.59,93.91 106.44,94.04 106.1,94.18 106.02,94.32 106.02,94.52 106.08,94.69 106.08,94.85 106.02,94.97 106.02,95.28 106.63,95.89 106.76,95.89 107.23,96.36 107.27,96.36 107.28,96.38
  BOTTOM w0.127: v2(109.16,105.16) 108.88,104.89 108.88,104.07 108.6,103.79 108.6,101.83 107.91,101.15 107.91,99.72 107.62,99.42 107.62,96.71 107.28,96.38
PCH_DPWROK: length 47.1
  TOP w0.127: v2(142.37,56.99) 142.06,56.67 140.94,56.67 140.57,57.04 R1704.2
  L4 w0.127: v2(141.52,48.16) 141.59,48.23 141.59,52.22 142.1,52.73 142.1,56.72 v2(142.37,56.99)
  BOTTOM w0.127: CPU1.BB20 125.33,71.88 125.33,70.32 125.62,70.03 v1(125.62,69.37) 125.62,67.27 125.9,67 125.9,65.4 126.66,64.64 126.66,64.44 127.52,63.58 127.52,57.3 134.64,50.18 134.64,49.08 R1718.1 135.75,49.85 138.42,49.85 140.14,48.13 141.49,48.13 v2(141.52,48.16)
PCH_JTAG_TCK: length 9
  BOTTOM w0.089: 105.59,97.47 105.36,97.24 105.11,97.24 104.08,96.21 104.08,94.92 103.81,94.65 CPU1.B56
  BOTTOM w0.114: R407.1 106.9,101.75 TP9917.1 106.9,100.45 106.31,99.86 106.31,98.18 105.59,97.47
PCH_JTAG_TDI: length 14.4
  BOTTOM w0.089: CPU1.D59 102.84,93.52 102.84,94.16 102.89,94.3 102.89,94.57 102.86,94.66 102.86,94.86 102.89,94.95 102.89,95.4 102.74,95.56 102.74,95.94 102.97,96.17 103.19,96.17 103.25,96.23
  BOTTOM w0.114: R9928.1 106.31,104.39 106.31,101.93 R408.1 104.79,100.42 v1(104.79,98.57) 104.79,98.23 104.53,97.97 104.53,97.52 103.25,96.23
PCH_JTAG_TDO: length 15.7
  BOTTOM w0.114: CPU1.A56 103.81,96.2 105.81,98.2 TP9916.1 105.81,100.54 106.54,101.27 106.54,103.67 R409.1 106.58,104.78 106.24,104.78 105.96,105.07 105.96,105.55 105.75,105.76 104.03,105.76 103.92,105.65 R9935.2
PCH_JTAG_TMS: length 10.8
  BOTTOM w0.089: CPU1.C59 102.66,93.99 102.66,94.2 102.72,94.33 102.72,94.53 102.68,94.62 102.68,94.89 102.72,94.98 102.72,95.31 102.56,95.47 102.56,96.01 102.92,96.37 102.99,96.37 103.11,96.5
  BOTTOM w0.114: 103.11,96.5 103.37,96.76 103.37,97.05 v1(103.56,97.23) 104.29,97.97 104.29,98.66 104.41,98.78 104.41,100.9 R9927.1 105.25,101.74 105.25,102.86 R416.1
PCH_PLTRST#: length 31.9
  TOP w0.102: v2(139.45,72.73) 140.69,73.96 144.98,73.96 146.75,75.73 v1(150.07,75.73) 152.28,75.73 152.81,75.2 v2(152.81,75.15)
  L4 w0.102: v2(139.45,72.73) 139.45,74.86 139.05,75.26 138.03,75.26 137.52,75.77 137.01,75.77 133.74,75.77 133.04,75.08 132.46,75.08 132.03,75.51 131.5,75.51 131.2,75.81 131.2,78.06 v2(130.77,78.5)
  BOTTOM w0.102: CPU1.AN10 130.64,78.5 v2(130.77,78.5) ; R1713.2 154.17,75.54 153.8,75.54 153.41,75.15 v2(152.81,75.15)
PCH_PLTRST#_EC: length 9.4
  TOP w0.102: KBC24.56 178.48,83.73 177.65,84.56 177.22,84.56 176.08,85.7 C2402.2 176.08,86.25 175.75,86.58 175.75,86.59 174.6,87.74 v1(174.37,87.74) 174.01,87.74 173.24,86.97 R2410.1
PCH_POPIRCOMP: length 12.4
  TOP w0.152: v2(126.19,75.9) 126.19,75.84 125.78,75.42 125.78,74.97 126.19,74.55 126.19,73.91 126.33,73.77
  TOP w0.508: 126.33,73.77 127.02,73.08 127.03,73.08 127.05,73.07 127.05,69.35 v1(126.98,69.28) R413.1
  BOTTOM w0.305: v2(126.19,75.9) 126.3,75.9 126.63,75.57 CPU1.AU16
PCH_RSMRST#: length 34.8
  TOP w0.127: KBC24.88 174.74,71.41 174.99,71.16 175.55,71.16 176.23,71.85 v2(176.23,72.11) ; v2(150.8,75.27) v1(150.8,74.71)
  L3 w0.127: v2(176.23,72.11) 176.33,72.2 176.87,72.2 177.18,72.51 177.18,73.55 176.65,74.08 175.71,74.08 175.57,73.93 175.2,73.93 175.05,74.08 171.62,74.08 171.12,74.57 168.06,74.57 167.93,74.44 159.73,74.44 159.6,74.58 154.16,74.58 154.09,74.65 151.43,74.65 v2(150.8,75.27)
  BOTTOM w0.127: R1702.2 150.68,74.6 EC1712.1 150.69,75.16 v2(150.8,75.27)
PCH_SMBCLK: length 386.1
  TOP w0.14: Q1801.4 150.16,100.28 151.18,99.27 152.44,99.27 153.13,99.96 RN1810.3 154.2,100.73 156.85,103.39 159.62,103.39 162.84,106.6 162.84,108.37 166.45,111.98 170.14,111.98 v1(171.54,113.38) 172.1,113.94 v2(172.1,114.1) ; v2(48.18,70.62) 48.21,70.62 48.5,70.32 EC6505.1 49.84,70.26 R6515.1 ; v2(196.33,82.72) 196.12,82.52 VGABD1.15 ; R9920.1 129.19,29.37 v2(129.27,29.29)
  L3 w0.127: v2(196.55,27.06) 196.03,26.54 188.98,26.54 187.2,24.76 184.8,24.76 184.12,25.44 184.12,25.72 182.64,27.21 170.81,27.21 170.49,27.52 168.68,27.52 168.14,28.07 164.06,28.07 163.15,28.97 161.1,28.97 159.71,27.58 153.72,27.58 153.08,27.58 152.49,26.98 150.4,26.98 148.72,28.66 145.6,28.66 v2(145.6,28.66) ; v2(196.33,82.72) 195.93,82.72 195.67,82.99 184.8,82.99 184.11,82.3 174.13,82.3 174.12,82.31 171.74,82.31 170.69,83.36 170.69,83.87 v2(170.05,84.51) ; v2(48.18,70.62) 48.31,70.62 48.6,70.32 49.81,70.32 50.21,69.93 50.21,68.9 52.41,66.7 54.51,66.7 60.87,60.34 60.87,53.65 61.19,53.33 61.19,53.3 v2(61.18,53.3)
  L4 w0.127: v2(172.1,114.1) 172.61,114.1 174.23,112.48 174.23,110.66 172.57,109 172.57,102.82 171.69,101.93 171.69,97.31 170.52,96.14 170.52,93.47 v2(169.95,92.89) 169.95,92.05 169.7,91.81 169.7,91.17 169.71,91.17 169.71,90.13 169.26,89.69 169.26,87.91 170.01,87.17 170.01,84.55 v2(170.05,84.51)
  BOTTOM w0.14: v2(196.55,27.06) 195.51,28.09 195.51,41.01 190.85,45.67 190.85,58.87 194.15,62.17 194.15,65.7 196.32,67.87 196.32,71.18 195.86,71.63 195.86,77.48 195.45,77.9 195.45,81.99 196.18,82.72 v2(196.33,82.72) ; DM1.202 125.95,29.1 126.32,28.74 128.19,28.74 128.75,29.29 v2(129.27,29.29) 130.35,28.21 140.61,28.21 141.43,27.39 141.57,27.39 142.27,26.68 142.27,26.66 142.61,26.31 142.61,25.85 142.61,22.95 140.45,20.79 DM2.202 140.45,15.91 141.23,15.14 142.95,15.14 144.99,17.18 144.99,23.24 145.66,23.91 145.66,28.6 v2(145.6,28.66) 145.18,29.08 145.18,29.98 146,30.8 146,35 145.5,35.5 145.5,35.73 144.41,36.83 135.32,36.83 129.24,42.9 123.83,42.9 120.91,45.81 82.3,45.81 75.22,52.9 61.62,52.9 61.19,53.33 61.19,53.3 v2(61.18,53.3) ; v2(169.95,92.89) 170,92.95 U6701.1
PCH_SMBDATA: length 388.3
  TOP w0.14: v2(48.94,70.87) 49.28,71.21 EC6506.1 49.84,71.15 R6511.1 ; v2(196.29,82.06) 196.25,82.02 VGABD1.14 ; R9918.1 128.72,28.48 v2(128.76,28.52) ; Q1801.1 147.53,102.21 147.84,102.52 151.64,102.52 152.78,101.38 RN1810.4 154.25,101.38 156.68,103.81 159.45,103.81 162.42,106.78 162.42,108.6 166.22,112.4 169.69,112.4 v1(170.27,112.98) v2(172.08,114.79)
  L3 w0.127: v2(169.78,83.36) 170.13,83.36 171.57,81.92 184.45,81.92 185.01,82.48 195.44,82.48 195.86,82.06 v2(196.29,82.06) ; v2(145.63,29.47) 149.11,29.47 151.09,27.49 152.28,27.49 152.87,28.09 152.88,28.09 153.93,29.13 153.93,29.14 154.26,29.47 160.88,29.47 160.89,29.48 161.31,29.48 161.31,29.48 163.36,29.48 163.59,29.25 164.27,28.57 168.35,28.57 168.9,28.03 170.7,28.03 171.11,27.62 182.76,27.62 184.55,25.83 184.55,25.58 184.98,25.16 186.87,25.16 188.74,27.02 195.67,27.02 v2(196.53,27.88) ; v2(48.94,70.87) 48.94,70.88 49.15,71.09 49.7,71.09 50.74,70.05 50.74,69.11 52.47,67.39 54.56,67.39 61.31,60.63 61.31,60.62 61.38,60.55 61.38,60.47 61.44,60.4 v2(61.44,53.88)
  L4 w0.127: v2(172.08,114.79) 171.65,114.36 171.65,113.83 173.72,111.76 173.72,110.87 172.06,109.21 172.06,103.03 171.18,102.14 171.18,97.52 170.01,96.35 170.01,95.02 v2(169.97,94.98) 169.97,93.64 169.44,93.1 169.44,92.68 169.56,92.56 169.56,92.23 169.32,91.99 169.32,91.58 169.31,91.57 169.31,90.31 168.86,89.85 168.86,87.79 168.86,87.79 168.86,87.73 169.57,87.02 169.57,84.2 169.57,84.19 169.57,83.57 v2(169.78,83.36)
  BOTTOM w0.14: U6701.4 170.38,94.57 v2(169.97,94.98) ; v2(61.44,53.88) 61.79,53.53 75.48,53.53 82.63,46.37 121.15,46.37 124.06,43.46 129.28,43.46 135.49,37.25 144.58,37.25 145.92,35.91 145.92,35.67 146.42,35.17 146.42,30.26 v2(145.63,29.47) 146.28,28.82 146.28,23.74 145.55,23.01 145.55,16.95 143.18,14.58 142.72,14.58 142.72,14.58 140.98,14.58 139.85,15.7 DM2.200 139.85,20.98 142.06,23.18 142.06,26.08 141.71,26.43 141.71,26.45 141.33,26.83 141.2,26.83 140.38,27.65 129.63,27.65 v2(128.76,28.52) 128.42,28.17 126.09,28.17 125.35,28.91 DM1.200 ; v2(196.53,27.88) 196.07,28.35 196.07,41.24 191.27,46.04 191.27,58.5 194.71,61.94 194.71,65.47 196.74,67.5 196.74,71.43 196.43,71.74 196.43,75.13 196.92,75.62 196.92,77.27 195.87,78.32 195.87,81.7 196.22,82.06 v2(196.29,82.06)
PCH_SPI_CS2#: length 4.1
  BOTTOM w0.14: R1816.2 138.4,74.2 138.21,74.39 138.21,74.94 137.53,75.62 135.76,75.62 CPU1.AU1
PCH_THERMTRIP: length 14.1
  BOTTOM w0.089: CPU1.C63 100.11,94.03 100.15,94.09 100.24,94.35 100.24,94.52 100.18,94.71 100.18,94.86 100.24,94.98 100.24,95.39 100.09,95.54 100.09,96 100.38,96.3 100.61,96.53
  BOTTOM w0.102: 100.61,96.53 100.74,96.66 100.74,98.32 100.91,98.49 100.91,100.47 101.1,100.67 101.1,101.92 100.33,102.68 100.33,102.88 99.77,103.45 R419.2 99.32,103.99 99.32,104.77 v1(98.95,105.14) 98.62,105.47 R420.1
PCH_WAKE#: length 71.1
  TOP w0.102: v2(155.06,64.67) 154.93,64.55 154.48,64.55 153.37,65.65 R1705.2 153.38,66.16 R1703.2 ; v2(158.16,47.93) v1(153,47.93) 147.17,47.93 145.02,50.08 143.35,50.08 142.6,50.83 141.54,50.83 141.18,51.19 135.81,51.19 132.37,54.64 132.37,57.05 132.92,57.6 v2(133.16,57.6)
  L4 w0.102: v2(155.06,64.67) 155.12,64.67 156.24,63.55 156.24,60.46 157.61,59.09 157.61,57.01 157.97,56.65 157.97,48.11 v2(158.16,47.93)
  BOTTOM w0.102: v2(133.16,57.6) 130.29,60.48 130.29,61.9 129.57,62.62 129.57,63.98 129.09,64.46 129.09,66.22 128.81,66.5 128.81,68.14 127.35,69.6 127.35,71.02 126.93,71.44 126.93,72.22 CPU1.BB15
PCI_CLK_LPC0: length 10.8
  TOP w0.14: v2(132.41,68.46) v1(132.41,67.63) 132.41,67.36 132.76,67.01 132.76,66.63 132.2,66.07 R1804.1
  BOTTOM w0.089: 130.64,71.53 130.64,71.71 130.54,71.81 130.54,73.94 130.82,74.22 CPU1.AW9
  BOTTOM w0.114: 130.64,71.53 130.64,70.93 131.92,69.64
  BOTTOM w0.14: v2(132.41,68.46) 132.41,69.15 131.92,69.64
PCI_CLK_LPC1: length 13.4
  TOP w0.14: R1805.1 136.37,65.82 135.44,66.74 v1(135.44,66.87) v2(135.44,67.62)
  BOTTOM w0.089: CPU1.AY9 130.82,73.52 131.14,73.2 131.14,72.44
  BOTTOM w0.114: 131.14,72.44 131.14,71.01 131.83,70.32 132.93,70.32 133.1,70.49 133.99,70.49 134.26,70.21
  BOTTOM w0.14: v2(135.44,67.62) 135.38,67.68 134.94,67.68 133.86,68.76 133.86,69.15 134.26,69.56 134.26,70.21
PCIE_CLK_XDP_N: length 1.2
  TOP w0.127: TP9909.1 110.69,91.37 v2(110.67,91.39)
  BOTTOM w0.127: CPU1.F43 110.79,91.39 v2(110.67,91.39)
PCIE_CLK_XDP_P: length 1.2
  TOP w0.127: v2(110.63,92.03) 110.28,92.38 TP9908.1
  BOTTOM w0.127: CPU1.E43 110.78,92.03 v2(110.63,92.03)
PCIE_LAN_WAKE#: length 242.4
  TOP w0.127: D1702.2 156.54,72.01 156.76,71.78 v2(156.76,71.76) ; v2(57.2,169.32) 56.76,169.32 56.76,169.31 v1(54.05,169.31) 51.88,169.31 R3113.1 51.37,168.8 50.13,168.8 49.88,169.05 49.31,169.05 49.19,169.17 LOM31.21
  L3 w0.127: v2(57.2,169.32) 59.4,171.51 64.17,171.51 66.41,173.75 77.4,173.75 77.45,173.69 81.27,173.69 81.93,174.35 81.93,174.54 82.47,175.09 84.5,175.09 85.4,174.19 88.53,174.19 90.49,176.16 102.54,176.16 102.92,175.78 105.05,175.78 105.26,175.98 113.94,175.98 115.04,174.88 117.67,174.88 118.14,174.4 124,174.4 124.75,173.65 126.02,173.65 126.7,174.34 135.13,174.34 135.31,174.15 148.89,174.15 152.58,170.46 154.95,170.46 158.54,166.87 159.63,166.87 160.48,166.02 161.58,166.02 v2(162.21,166.66) ; v2(156.76,71.76) 157.6,71.76 159.28,70.08 159.63,70.08 160.01,70.46 160.93,70.46 162.27,71.81 163.36,71.81 163.76,72.21 167.51,72.21 v2(167.64,72.08)
  L4 w0.127: v2(162.21,166.66) 162.21,164.02 162.43,163.81 162.43,162.9 162.11,162.58 162.11,160.79 162.41,160.5 162.41,158.63 164.83,156.2 164.83,152.01 164.83,151.8 160.6,147.57 160.6,139.73 160.6,139.16 163.06,136.7 163.06,136.11 164.93,134.23 165.33,133.83 165.33,130.69 164.66,130.01 164.66,128.14 164.66,127.21 165.04,126.83 165.04,120.92 165.58,120.38 165.58,118.8 163.96,117.18 163.96,108.57 164.19,108.33 164.19,106.74 164.19,106.53 163.94,106.27 163.94,102.65 163.37,102.08 163.37,100.1 163.19,99.92 163.19,97.16 163.38,96.97 163.38,95.55 163.53,95.4 163.53,95.38 163.92,94.99 163.92,94.92 163.92,94.91 163.92,94.54 163.92,94.53 163.92,92.75 165.85,90.82 165.85,89.95 165.85,89.92 166.18,89.59 166.18,86.25 166.84,85.59 166.84,85.39 166.98,85.26 166.98,84.16 167.13,84.01 167.13,82.33 167.84,81.62 167.84,79.18 167.59,78.92 167.59,76.95 167.54,76.9 167.54,74.23 167.92,73.85 167.92,73.63 168.31,73.24 168.31,72.54 167.85,72.08 v2(167.64,72.08)
PCIE_RCOMPN: length 10.5
  TOP w0.305: v2(137.25,95.38) v1(136.68,95.38)
  L3 w0.305: v2(132.6,91.39) 132.74,91.52 133.62,91.52 136.68,94.59 136.68,95.01 137.05,95.38 v2(137.25,95.38)
  BOTTOM w0.305: v2(132.6,91.39) 132.73,91.39 CPU1.F5 ; v2(137.25,95.38) 137.57,95.7 138.14,95.7 138.52,96.08 139.4,96.08 R1604.1
PCIE_RCOMPP: length 10.5
  TOP w0.305: v2(137.26,96.16) v1(137.26,96.73)
  L3 w0.305: v2(132.6,92.04) 132.68,91.96 133.44,91.96 136.25,94.77 136.25,95.19 137.22,96.16 v2(137.26,96.16)
  BOTTOM w0.305: v2(132.6,92.04) 132.92,92.36 CPU1.E5 ; v2(137.26,96.16) 137.29,96.13 137.97,96.13 138.35,96.51 139.45,96.51 R1604.2
PCIE_RX_CON_N6: length 4.8
  TOP w0.127: 50.3,165.51 50.52,165.29 51.05,165.29 C3111.1 ; 50.3,165.51 v1(50.18,165.38) ; 50.3,165.51 49.72,166.09 49.72,167.38 49.53,167.57 LOM31.17
PCIE_RX_CON_P6: length 4.8
  TOP w0.127: 49.96,167.11 v1(50.12,167.11) ; 49.96,167.11 49.96,167.48 49.63,167.81 49.41,167.81 49.25,167.97 LOM31.18 ; 49.96,167.11 49.96,166.19 50.62,165.53 51.18,165.53 C3109.1
PCIE_RX_CPU_N5: length 86.6
  TOP w0.127: v2(126.2,91.39) 126.32,91.39 v1(126.65,91.06)
  L4 w0.114: v2(163.07,52.58) 162.8,52.85 162.16,52.85 161.87,53.14 161.87,59.27 160.35,60.78 160.35,66.23 160.67,66.54 160.67,71.47 158.74,73.39 158.74,74.45 158.58,74.61 158.58,75.54 157.58,76.54 157.58,78.63 151.2,85.02 151.2,88.58 150.98,88.8 150.98,89.51 149.33,91.16 149.33,93.89 146.29,96.93 146.29,97.38 141.54,102.13 133.6,102.13 132.21,100.74 132.21,99.64 131.61,99.04 130.72,99.04 130.54,99.23 128.93,99.23 126.44,96.74 126.44,93.05 126.7,92.79 126.7,91.89 v2(126.2,91.39)
  BOTTOM w0.127: v2(163.07,52.58) 163.01,52.52 WLAN1.43 ; CPU1.F16 126.33,91.39 v2(126.2,91.39)
PCIE_RX_CPU_N6: length 169.2
  TOP w0.127: v2(53.16,165.04) 52.88,165.32 52.7,165.32 C3111.2
  L4 w0.114: v2(125.28,90.74) 125.17,90.74 125.04,90.61 125.04,88.87 123.57,87.4 122.92,87.4 121.84,88.48 118.22,88.48 117.64,89.07 113.25,89.07 112.81,89.5 112.81,90.84 113.35,91.38 113.35,94.01 112.3,95.06 112.3,97.55 113.03,98.28 113.03,99.26 111.51,100.78 107.91,100.78 107.26,101.43 105.66,101.43 104.11,102.97 93.72,102.97 89.85,106.85 89.85,113.15 95.06,118.37 95.06,122.47 94.5,123.03 94.5,126.49 95.06,127.05 95.06,130.59 89.75,135.91 89.75,142.93 83.08,149.59 83.08,151.64 82.09,152.64 82.09,159.02 83.86,160.8 83.86,166.53 85.86,168.53 85.86,173.5 83.89,175.47 80.21,175.47 78.99,174.24 63.15,174.24 54.38,165.47 53.43,165.47 53.16,165.2 v2(53.16,165.04)
  BOTTOM w0.127: CPU1.G18 125.41,90.74 v2(125.28,90.74) ; v2(53.16,165.04) v1(53.16,164.47)
PCIE_RX_CPU_P5: length 86.6
  TOP w0.127: v2(126.2,92.04) v1(126.2,92.78)
  L4 w0.114: v2(126.2,92.04) 126.34,92.04 126.47,92.17 126.47,92.7 126.21,92.96 126.21,96.84 128.83,99.46 130.63,99.46 130.82,99.27 131.52,99.27 131.98,99.74 131.98,100.84 133.5,102.36 141.63,102.36 146.52,97.47 146.52,97.02 149.55,93.99 149.55,91.25 151.2,89.6 151.2,88.9 151.42,88.68 151.42,85.11 157.81,78.73 157.81,76.63 158.81,75.63 158.81,74.7 158.97,74.54 158.97,73.49 160.9,71.56 160.9,66.45 160.58,66.13 160.58,60.88 162.1,59.36 162.1,53.24 162.26,53.08 162.83,53.08 v2(163,53.25)
  BOTTOM w0.127: CPU1.E16 126.52,92.36 v2(126.2,92.04) ; v2(163,53.25) 163,53.16 162.61,52.76 161.9,52.76 161.64,53.02 WLAN1.41
PCIE_RX_CPU_P6: length 169.2
  TOP w0.127: C3109.2 52.51,165.56 52.89,165.56 v2(53.16,165.83)
  L4 w0.114: v2(53.16,165.83) 53.29,165.7 54.29,165.7 63.06,174.47 78.89,174.47 80.12,175.7 83.98,175.7 86.09,173.59 86.09,168.44 84.09,166.44 84.09,160.7 82.32,158.93 82.32,152.73 83.31,151.74 83.31,149.68 89.97,143.02 89.97,136 95.29,130.69 95.29,126.96 94.73,126.4 94.73,123.13 95.29,122.57 95.29,118.27 90.08,113.06 90.08,106.94 93.81,103.2 104.21,103.2 105.75,101.66 107.35,101.66 108,101.01 111.61,101.01 113.26,99.36 113.26,98.19 112.53,97.46 112.53,95.16 113.58,94.11 113.58,91.29 113.04,90.75 113.04,89.59 113.34,89.3 117.73,89.3 118.32,88.71 121.94,88.71 123.02,87.63 123.48,87.63 124.81,88.96 124.81,90.92 v2(125.28,91.39)
  BOTTOM w0.127: v2(125.28,91.39) 125.41,91.39 CPU1.F18 ; v2(53.16,165.83) v1(53.16,166.39)
PCIE_TX_CON_N5: length 88
  TOP w0.127: v2(127.36,103.61) 127.21,103.76 v1(127.21,104.17)
  L4 w0.114: v2(163.81,60.74) 163.57,60.98 163.4,60.98 162.6,61.78 162.6,64.59 163.93,65.93 163.93,66.68 163.3,67.31 163.3,70.97 163.5,71.18 163.5,71.91 163.62,72.02 163.62,73.78 160,77.39 160,79.53 158.74,80.79 158.74,81.47 158.43,81.77 157.91,81.77 154.29,85.4 154.29,88.67 153.22,89.74 153.22,91.46 152.84,91.84 152.84,92.81 152.53,93.13 152.53,95.34 152.37,95.5 152.37,100.35 151.13,101.59 151.13,102.91 150.2,103.83 149.35,103.83 148.76,103.24 143.87,103.24 142.61,104.5 139.21,104.5 138.38,105.32 131.3,105.32 128.8,102.82 127.98,102.82 127.74,103.06 127.74,103.39 127.52,103.61 v2(127.36,103.61)
  BOTTOM w0.127: WLAN1.37 161.55,54.02 161.68,54.15 162.05,54.15 162.83,54.93 162.83,56.26 162.48,56.62 162.48,60.17 163.26,60.95 163.61,60.95 163.81,60.75 v2(163.81,60.74) ; v2(127.36,103.61) 127.49,103.61 127.69,103.41 127.69,102.74 C1601.1
PCIE_TX_CON_N6: length 165.2
  TOP w0.127: v1(124.68,103.79) 124.4,103.51 v2(124.4,103.31) ; v2(48,164.79) 47.69,165.11 47.69,165.56 47.13,166.12 LOM31.14
  L4 w0.114: v2(48,164.79) 47.79,165 47.79,165.82 48.52,166.55 50.96,166.55 52,167.59 54.22,167.59 61.65,175.01 77.62,175.01 79.28,176.67 81.17,176.67 81.62,176.22 84.25,176.22 86.76,173.71 86.76,167.55 85.24,166.03 85.24,163.18 84.63,162.56 84.63,160.44 82.84,158.65 82.84,152.96 83.83,151.97 83.83,149.9 90.55,143.18 90.55,139.63 91.2,138.98 91.2,136.4 91.58,136.02 91.58,135.14 95.81,130.9 95.81,126.72 95.25,126.16 95.25,123.34 95.81,122.78 95.81,118.06 90.6,112.84 90.6,107.32 94.19,103.73 104.44,103.73 106,102.18 107.66,102.18 108.31,101.53 111.84,101.53 114.08,99.29 117.41,99.29 120.68,102.57 124.02,102.57 124.26,102.8 124.26,103.16 v2(124.4,103.31)
  BOTTOM w0.127: v2(124.4,103.31) 124.2,103.1 124.2,102.5 C1603.1
PCIE_TX_CON_P5: length 87.5
  TOP w0.127: v1(127.84,103.12) 128.17,103.45 v2(128.17,103.61)
  L4 w0.114: v2(128.17,103.61) 127.96,103.4 127.96,103.15 128.07,103.05 128.7,103.05 131.21,105.55 138.48,105.55 139.3,104.73 142.71,104.73 143.97,103.47 148.66,103.47 149.26,104.06 150.3,104.06 151.36,103 151.36,101.68 152.6,100.45 152.6,95.6 152.75,95.44 152.75,93.22 153.07,92.9 153.07,91.94 153.45,91.56 153.45,89.83 154.51,88.77 154.51,85.5 158.01,82 158.52,82 158.96,81.56 158.96,80.89 160.23,79.62 160.23,77.49 163.84,73.88 163.84,71.92 163.73,71.81 163.73,71.09 163.53,70.88 163.53,67.41 164.16,66.77 164.16,65.83 162.83,64.5 162.83,61.88 163.5,61.21 163.68,61.21 163.81,61.34 v2(163.81,61.54)
  BOTTOM w0.127: v2(128.17,103.61) 127.93,103.37 127.93,102.64 C1602.1 ; WLAN1.35 161.55,54.52 161.68,54.39 161.95,54.39 162.59,55.03 162.59,56.16 162.24,56.52 162.24,56.72 162.24,60.27 163.16,61.19 163.47,61.19 v2(163.81,61.54)
PCIE_TX_CON_P6: length 166.1
  TOP w0.127: v2(123.74,103.3) 123.74,103.51 v1(123.45,103.8) ; 46.73,166.88 46.73,166.17 47.44,165.46 47.44,164.84 47.36,164.76 v2(47.14,164.76)
  L4 w0.114: v2(123.74,103.3) 123.8,103.3 124.03,103.07 124.03,102.9 123.92,102.79 120.59,102.79 117.31,99.52 114.18,99.52 111.94,101.76 108.41,101.76 107.76,102.41 106.09,102.41 104.54,103.96 94.28,103.96 90.82,107.42 90.82,112.75 96.04,117.96 96.04,122.88 95.48,123.44 95.48,126.07 96.04,126.63 96.04,131 91.81,135.23 91.81,136.12 91.43,136.5 91.43,139.07 90.78,139.72 90.78,143.27 84.06,149.99 84.06,152.06 83.07,153.06 83.07,158.55 84.86,160.34 84.86,162.47 85.47,163.08 85.47,165.94 86.99,167.45 86.99,173.8 84.34,176.45 81.72,176.45 81.27,176.9 79.19,176.9 77.53,175.24 61.55,175.24 54.13,167.81 51.9,167.81 50.87,166.78 48.43,166.78 47.56,165.92 47.56,164.77 47.47,164.68 47.22,164.68 v2(47.14,164.76)
  BOTTOM w0.127: C1604.1 123.96,102.47 123.96,103.2 123.86,103.3 v2(123.74,103.3)
PCIE_TX_CPU_N5: length 10.3
  BOTTOM w0.089: 125.17,97.14 125.17,97.11 125.21,97.08 125.21,96.57 124.91,96.28 124.91,95.46 125.02,95.35 125.02,95.02 124.98,94.86 124.98,94.65 125.02,94.51 125.02,94.37 124.96,94.16 124.96,94.08 CPU1.C19
  BOTTOM w0.127: 125.49,100.12 v1(125.35,100.26) ; 125.49,100.12 126.02,100.65 127.5,100.65 127.68,100.84 127.68,101.26 127.47,101.48 C1601.2 ; 125.49,100.12 125.17,99.8 125.17,97.14
PCIE_TX_CPU_N6: length 8.8
  BOTTOM w0.089: 124.21,97.87 124.21,97.85 124.17,97.81 124.17,97.3 124.3,97.17 124.3,94.72 124.48,94.53 124.48,93.99 124.19,93.7 CPU1.D20
  BOTTOM w0.127: 123.96,98.96 124.21,98.72 124.21,97.87 ; 123.96,98.96 123.69,99.24 123.69,99.95 124.21,100.47 124.21,100.94 C1603.2 ; 123.96,98.96 v1(124.1,99.1)
PCIE_TX_CPU_P5: length 10.9
  BOTTOM w0.089: 125.41,97.14 125.41,97.11 125.38,97.08 125.38,96.5 125.09,96.21 125.09,95.53 125.2,95.42 125.2,94.99 125.15,94.84 125.15,94.68 125.2,94.54 125.2,94.34 125.14,94.13 125.14,93.8 125.07,93.55 CPU1.D19
  BOTTOM w0.127: C1602.2 127.92,101.19 127.92,100.74 127.6,100.41 127.3,100.41 ; 127.3,100.41 126.12,100.41 125.41,99.7 125.41,97.14 ; 127.3,100.41 v1(127.3,100.23)
PCIE_TX_CPU_P6: length 8.1
  BOTTOM w0.089: 123.96,97.87 123.96,97.85 124,97.81 124,97.22 124.12,97.1 124.12,94.64 124.3,94.46 124.3,94.22 CPU1.C20
  BOTTOM w0.127: 123.54,100.15 123.45,100.05 123.45,99.14 123.96,98.62 123.96,97.87 ; 123.54,100.15 123.96,100.57 123.96,100.96 C1604.2 ; 123.54,100.15 v1(123.42,100.28)
PCIE_WAKE#: length 8
  TOP w0.127: R1705.1 154.49,65.92 155.39,65.92 155.55,66.09 v1(155.55,67.24) 155.55,67.56 154.1,69.01 153.7,69.01 153.16,69.55 153.16,70.15 D1702.3
PCIE_WLAN_WAKE#: length 34
  TOP w0.127: R6121.1 162.72,48.33 161.73,48.33 v1(161.24,48.82) 160.54,49.52 v2(159.33,49.52) ; R1714.2 157.11,70.53 v2(156.1,71.53) 154.61,70.04 D1702.1
  L4 w0.127: v2(156.1,71.53) 156.1,71.45 157.04,70.51 157.04,65.64 157.26,65.42 157.26,64.56 157.95,63.87 157.95,63.18 157.24,62.47 157.24,60.87 159.84,58.27 159.84,50.04 v2(159.33,49.52)
  BOTTOM w0.127: WLAN1.55 v2(159.33,49.52)
PCIE_WLAN_WAKE#_R: length 6.2
  TOP w0.127: v2(165.96,47.9) v1(165.49,48.37) 165.16,48.7 R6121.2
  BOTTOM w0.127: WLAN1.70 166.68,45.77 165.96,46.49 v2(165.96,47.9)
PD4403_A: length 3.5
  TOP w0.102: v1(118.78,164.87) PD4404.A 118.08,166.42 117.82,166.69 PQ4408.B
PD4403_K: length 3.2
  TOP w0.102: PD4404.K 121.07,166.86 120.45,167.48 PR4458.2 120.45,168.18 v1(121.27,169)
PD#: length 5.5
  TOP w0.102: v1(32.21,8.85) 31.78,9.28 R2708.2 31.78,9.79 30.62,10.95 30.62,11.32 29.77,12.17 29.39,12.17 29.15,12.41 HDA27.47
PECI_EC: length 3.6
  TOP w0.14: C2405.1 171.06,68.82 R2437.1 v1(171.97,68.83) 172.22,68.83 172.4,69.01 KBC24.94
PEG_CLK1_CPU: length 120.1
  L4 w0.114: v2(111.78,102.98) 111.58,102.98 111.5,103.06 111.5,103.34 111.68,103.52 112.56,103.52 116.65,107.62 128.16,107.62 129.7,109.16 138.56,109.16 138.7,109.31 146.77,109.31 149.71,106.37 149.71,105.4 152.11,103 152.11,101.93 152.24,101.8 153.13,100.92 153.13,95.82 153.31,95.63 153.31,93.43 153.97,92.77 153.97,91.82 155.72,90.07 155.72,86.49 157.3,84.91 157.3,84.27 158.03,83.54 158.37,83.54 159.32,82.59 159.32,81.97 159.49,81.8 159.49,81.11 161.14,79.46 161.14,77.32 164.36,74.09 164.36,72.35 164.62,72.1 164.62,71.19 164.24,70.81 164.1,70.67 164.1,68.36 164.33,68.13 164.33,67.89 164.26,67.82 v2(164.04,67.82)
  BOTTOM w0.089: CPU1.A42 111.45,95.3 111.45,95.52 111.5,95.56 111.5,97.2 111.09,97.61 111.09,98.67 111.08,98.67 111.08,98.7 111.07,98.71
  BOTTOM w0.127: WLAN1.47 161.46,51.52 161.54,51.45 163.14,51.45 163.54,51.85 163.54,54.77 163.36,54.95 163.36,56.55 163.06,56.85 163.06,58.26 165.22,60.42 165.22,61.36 163.89,62.69 163.89,64.42 164.32,64.85 164.32,65.38 EC6103.1 164.04,65.86 164.33,66.14 164.33,67.54 v2(164.04,67.82) ; 111.07,99.22 v1(110.91,99.22) ; 111.07,99.22 111.07,98.71 ; 111.07,99.22 111.07,101.22 112.31,102.46 112.31,103.3 112.1,103.51 111.6,103.51 111.43,103.35 111.43,103.1 111.56,102.97 111.77,102.97 v2(111.78,102.98)
