# Allegro board 14291-1.0917WZS2026.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD25: length 70.2
  TOP w0.178: VRAM3.N2 197.91,170.92 197.52,170.52 195.63,170.52 194.47,169.37 193.81,169.37 192.81,168.36 v2(192.81,167.75) ; VRAM4.N2 182.48,166.12 182.87,166.52 186.79,166.52 187.51,167.23 188.11,167.23 188.42,167.55 188.42,168.33 v2(188.57,168.47)
  L3 w0.127: v2(192.81,167.75) 192.43,167.75 192.23,167.55 192.23,166.83 192.04,166.64 191.77,166.64 191.57,166.83 191.57,167.23 191.38,167.42 191.11,167.42 190.91,167.23 190.91,166.41 190.73,166.22 190.44,166.22 190.25,166.41 190.25,167.3 v2(189.95,167.6) 189.81,167.46 189.81,166.58 189.61,166.38 189.03,166.38 188.88,166.52 188.88,166.73 189.05,166.9 189.05,167.87 189.25,168.07 189.6,168.07 189.8,168.28 189.8,168.61 189.6,168.82 188.78,168.82 188.57,168.61 v2(188.57,168.47)
  L4 w0.165: v2(189.95,167.6) 189.95,167.65 189.33,168.27 189.03,168.27 188.83,168.08 188.83,167.82 189.81,166.85 190.04,166.85 190.11,166.92 190.34,166.92 190.57,166.68 190.57,166.45 190.51,166.38 190.51,166.15 190.74,165.91 190.97,165.91 191.04,165.98 191.28,165.98 191.51,165.75 191.51,165.52 191.44,165.45 191.44,165.21 191.62,165.04 191.9,165.04 192.37,164.57 193.03,164.57 193.64,163.96 193.64,163.55 194.6,162.59 194.6,159.91 197.27,157.23 197.27,156.97 197.44,156.81 197.66,156.81 197.85,156.61 197.85,156.34 197.66,156.15 197.44,156.15 197.27,155.98 197.27,155.5 197.27,155.49 197.27,154 196.65,153.37 196.65,152.7 196.78,152.57 197.75,152.57 197.97,152.34 197.97,151.63 197.76,151.41 197.76,150.97 197.97,150.75 197.97,150.28 197.44,149.75 v2(197.36,149.75)
  BOTTOM w0.178: v2(197.36,149.75) 197.29,149.75 GPU1.J23 ; v2(192.81,167.75) 193.1,167.45 193.1,166.69 193.54,166.25 194.3,166.25 194.54,166.49 197.51,166.49 197.88,166.12 VRAM1.N2 ; v2(188.57,168.47) 188.78,168.68 v1(188.78,169.09) 188.78,169.33 188.39,169.72 187.09,169.72 186.32,170.49 183.06,170.49 182.63,170.92 VRAM2.N2
FBA_CMD26: length 60.1
  TOP w0.178: v2(189.76,162.65) 189.45,162.34 v1(189.3,162.34) ; v2(198.4,168.95) 198.95,169.5 VRAM3.M3 ; VRAM4.M3 181.55,167.34 182.17,167.97 182.17,168.56 v2(182.27,168.65)
  L3 w0.127: v2(198.4,168.95) 198.5,168.85 198.5,168.38 197.36,167.23 196.27,167.23 195.55,166.51 195.55,165.97 195.86,165.65 195.86,165.03 194.92,164.09 194.7,164.09 194.21,164.09 193.06,162.94 191.55,162.94 190.95,162.34 190.08,162.34 v2(189.76,162.65) 189.73,162.69 187.22,162.69 184.35,165.56 184.35,165.8 184.64,166.08 184.64,166.32 184.4,166.55 184.17,166.55 183.88,166.26 183.65,166.26 183.42,166.5 183.42,166.73 183.7,167.02 183.7,167.25 183.47,167.48 183.24,167.48 182.89,167.13 182.6,167.13 181.84,167.89 181.84,168.3 182.2,168.65 v2(182.27,168.65)
  L4 w0.165: v2(196.49,151.37) 196.29,151.37 196.05,151.6 196.05,152.76 196.06,152.77 196.06,153.14 195.8,153.39 195.45,153.39 195.29,153.54 195.29,156.48 194.65,157.13 192.77,157.13 189.43,160.47 188.19,160.47 187.46,161.2 187.46,162.11 187.46,162.11 187.46,163.6 187.66,163.8 188,163.8 188.17,163.63 188.17,161.52 188.36,161.33 188.63,161.33 188.83,161.52 188.83,162.89 189.03,163.1 189.56,163.1 189.76,162.89 v2(189.76,162.65)
  BOTTOM w0.178: v2(182.27,168.65) 181.95,168.97 181.95,169.32 181.55,169.72 VRAM2.M3 ; VRAM1.M3 198.8,166.92 198.15,167.57 198.15,168.7 v2(198.4,168.95) ; v2(196.49,151.37) 196.87,151.75 GPU1.J25
FBA_CMD27: length 71.7
  TOP w0.178: v2(194.28,168.62) 194.15,168.62 194.03,168.5 194.03,168.24 194.15,168.12 194.15,167.66 194.76,167.04 194.76,166.69 194.96,166.49 197.6,166.49 197.72,166.37 197.72,165.83 197.84,165.7 198.45,165.7 198.57,165.83 198.57,166 198.45,166.12 VRAM3.N8 ; v1(191.16,163.86) 191.15,163.87 v2(190.59,163.87) ; v2(186.53,167.04) 187.03,167.54 187.03,169.5 186.86,169.68 186.86,169.95 186.28,170.53 182.74,170.53 VRAM4.N8
  L3 w0.127: v2(194.28,168.62) 194.15,168.49 194.15,167.84 194.16,167.84 194.16,167.83 194.71,167.29 194.71,165.46 193.05,163.8 191.89,163.8 191.82,163.87 v2(190.59,163.87) 190.43,163.87 190.05,163.49 189.07,163.49 189.01,163.43 187.51,163.43 186.5,164.44 186.5,165.69 186.34,165.86 185.98,165.86 185.79,166.05 185.79,166.32 185.98,166.52 186.33,166.52 186.53,166.72 v2(186.53,167.04)
  L4 w0.165: v2(196.49,150.58) 196.49,150.68 196.31,150.86 195.82,151.35 195.35,151.82 195.22,151.82 194.93,152.11 194.93,153.42 194.92,153.43 194.92,156.33 194.51,156.74 192.63,156.74 189.27,160.1 188.04,160.1 187.09,161.05 187.09,163.88 186.89,164.08 186.61,164.08 186.41,163.88 186.41,163.36 186.22,163.16 185.93,163.16 185.73,163.36 185.73,164.27 186.37,164.9 187.07,164.9 187.81,164.17 188.62,164.17 189.32,163.47 190.02,163.47 190.43,163.87 v2(190.59,163.87)
  BOTTOM w0.178: v2(196.49,150.58) 196.87,150.97 GPU1.J24 ; v2(186.53,167.04) 186.53,166.67 186.38,166.52 182.44,166.52 182.35,166.43 VRAM2.N8 ; v2(194.28,168.62) 194.28,169.2 195.6,170.52 197.75,170.52 VRAM1.N8
FBA_CMD28: length 59.7
  TOP w0.178: v2(198.42,169.61) 197.9,169.08 197.9,168.34 198.15,168.09 VRAM3.N7 ; v2(183.16,168.78) 182.83,168.78 182.35,169.26 VRAM4.N7 ; v1(190.7,162.23) 190.67,162.26 190.67,162.81 v2(190.66,162.82)
  L3 w0.127: v2(198.42,169.61) 197.84,169.02 197.84,168.15 197.31,167.63 195.31,167.63 195.05,167.36 195.05,166.06 195.25,165.85 195.28,165.85 195.59,165.54 195.59,165.14 194.81,164.35 194.1,164.35 193.07,163.32 191.17,163.32 v2(190.66,162.82) 190.36,163.12 189.22,163.12 189.16,163.06 187.23,163.06 185.95,164.34 185.95,165.41 185.24,166.12 185.24,166.35 185.64,166.75 185.64,167.02 185.44,167.21 185.17,167.21 184.78,166.82 184.54,166.82 184.31,167.05 184.31,167.29 184.43,167.41 184.43,167.65 184.2,167.88 183.97,167.88 183.84,167.75 183.61,167.75 183.16,168.2 v2(183.16,168.78)
  L4 w0.165: v2(190.66,162.82) 190.43,162.82 190.26,162.99 190.26,163.18 190.48,163.41 190.95,163.41 191.12,163.57 191.12,164.06 191.31,164.26 191.58,164.26 191.78,164.06 191.78,163.06 191.88,162.96 192.23,162.96 192.4,163.13 192.4,163.32 192.56,163.48 192.89,163.48 193.06,163.32 193.06,163.13 193.22,162.96 193.42,162.96 193.62,162.76 193.62,162.48 193.42,162.28 191.36,162.28 191.17,162.09 191.17,161.83 191.36,161.65 193.68,161.65 193.86,161.47 193.86,161.13 193.68,160.95 192.47,160.95 192.26,160.75 192.26,159.86 192.47,159.65 192.79,159.65 193.69,159.65 193.8,159.54 196.47,156.87 196.47,155.12 v2(196.42,155.07)
  BOTTOM w0.178: v2(198.42,169.61) 198.15,169.88 VRAM1.N7 ; v2(183.16,168.78) 183.16,167.87 182.35,167.06 VRAM2.N7 ; v2(196.42,155.07) 196.32,155.07 195.62,154.36 195.62,153.64 195.89,153.37 GPU1.K27
FBA_CMD29: length 68.1
  TOP w0.178: v2(181.37,168.53) 181.04,168.85 181.04,169.83 VRAM4.L7 ; v2(198.64,167.74) 198.93,167.74 VRAM3.L7 ; v1(189.81,161.22) 189.81,161.81 v2(189.81,161.81)
  L3 w0.127: v2(198.64,167.74) 198.34,167.74 198.04,167.44 198.04,166.91 198.69,166.26 198.69,165.98 198.5,165.79 198.23,165.79 197.14,166.88 196.87,166.88 196.67,166.68 196.67,166.41 197.41,165.67 197.41,165.39 197.22,165.2 196.95,165.2 196.64,165.51 196.41,165.51 196.19,165.29 196.19,164.96 195.79,164.56 195.79,164.33 196.2,163.92 196.2,163.65 196.01,163.45 195.73,163.45 195.33,163.86 195.09,163.86 194.86,163.63 194.86,163.39 195.27,162.98 195.27,162.71 195.08,162.51 194.8,162.51 194.32,163 193.53,163 193.09,162.56 191.69,162.56 191.1,161.97 189.97,161.97 v2(189.81,161.81) 189.3,162.32 187.22,162.32 184.3,165.24 184.12,165.24 183.95,165.41 183.95,165.79 183.76,165.98 183.49,165.98 183.29,165.79 183.29,165.41 183.13,165.24 182.2,165.24 181.59,165.85 181.34,165.85 181.27,165.79 180.99,165.79 180.8,165.98 180.8,166.25 180.87,166.32 180.87,166.56 180.45,166.97 180.45,167.25 180.64,167.44 180.92,167.44 182.23,166.13 182.5,166.13 182.7,166.32 182.7,166.6 181.19,168.1 181.19,168.36 v2(181.37,168.53)
  L4 w0.165: v2(196.49,152.16) 196.33,152.33 196.33,153.25 195.66,153.91 195.66,156.63 194.8,157.49 194.23,157.49 194.07,157.66 194.07,158.19 193.9,158.36 193.57,158.36 193.41,158.19 193.41,157.66 193.24,157.49 192.92,157.49 192.51,157.91 192.51,158.14 192.79,158.43 192.79,158.7 192.6,158.89 192.5,158.89 192.5,158.9 192.33,158.9 192.04,158.61 191.81,158.61 191.2,159.21 191.2,159.58 191.53,159.9 191.53,160.27 191.35,160.45 191.06,160.45 190.61,160 190.41,160 190.17,160.25 190.17,160.45 190.76,161.04 190.76,161.82 190.53,162.05 190.05,162.05 v2(189.81,161.81)
  BOTTOM w0.178: v2(181.37,168.53) 181.76,168.53 182.14,168.15 182.14,167.49 181.93,167.29 181.12,167.29 VRAM2.L7 ; GPU1.K25 196.07,152.05 196.18,152.16 v2(196.49,152.16) ; v2(198.64,167.74) 198.6,167.74 198.43,167.91 198.43,168.35 198.92,168.84 198.92,169.43 199.18,169.69 199.18,169.83 199.47,170.12 VRAM1.L7
FBA_CMD30: length 70
  TOP w0.178: v2(178.67,168.15) 179.31,168.15 179.32,168.16 179.48,167.99 179.48,167.1 179.3,166.92 VRAM4.J3 ; VRAM3.J3 201.35,169.06 200.95,168.66 200.95,168.05 v2(201.08,167.92) ; v2(191.24,161.2) 191.43,161 v1(191.43,160.66)
  L3 w0.127: v2(201.08,167.92) 201.08,167.22 200.51,166.65 199.96,166.65 199.26,167.35 198.98,167.35 198.79,167.16 198.79,166.89 199.64,166.03 199.64,165.8 199.16,165.31 199.16,163.84 198.39,163.06 195.85,163.06 195.66,162.87 195.66,162.6 195.85,162.4 199.53,162.4 199.72,162.21 199.72,161.93 199.53,161.74 192.69,161.74 192.14,161.2 v2(191.24,161.2) 191.17,161.27 189.39,161.27 189.23,161.43 189.23,161.77 189.06,161.93 188.73,161.93 188.57,161.77 188.57,161.38 188.41,161.22 187.94,161.22 187.78,161.38 187.78,161.7 187.59,161.89 186.9,161.89 185.24,163.55 185.16,163.55 184.99,163.72 184.99,164.11 184.83,164.28 184.5,164.28 184.33,164.11 184.33,163.68 184.18,163.53 183.7,163.53 183.56,163.68 183.56,164.05 183.43,164.18 181.4,164.18 181.2,164.37 181.2,165.32 181.01,165.51 180.75,165.51 180.56,165.32 180.56,164.15 180.38,163.98 180,163.98 179.67,164.31 179.67,165.23 180.14,165.7 180.14,166.2 179.98,166.37 179.76,166.37 179.6,166.53 179.6,166.86 179.76,167.03 179.98,167.03 180.14,167.19 180.14,167.51 179.82,167.83 179.81,167.83 179.55,168.09 179.55,168.1 179.5,168.15 v2(178.67,168.15)
  L4 w0.165: v2(191.24,161.2) 191.9,160.54 191.9,159.66 192.29,159.27 192.93,159.27 193.46,158.73 194.08,158.73 196.03,156.79 196.03,155.4 195.98,155.35 195.98,154.88 196.02,154.84 196.02,154.82 196.23,154.61 v2(196.41,154.43)
  BOTTOM w0.178: v2(196.41,154.43) 196.58,154.61 196.6,154.61 196.99,155 197.16,155 197.29,154.87 197.29,154.52 196.99,154.22 196.99,154.06 197.27,153.78 197.27,153.62 197.03,153.37 GPU1.J27 ; v2(178.67,168.15) 178.67,168.17 178.67,168.17 178.67,169.21 179.15,169.69 VRAM2.J3 ; VRAM1.J3 201.35,167.65 v2(201.08,167.92)
FBA_CMD31: length 1.2
  TOP w0.178: TP7504.1 197.32,153.04 v2(197.31,153.03)
  BOTTOM w0.178: v2(197.31,153.03) 197.31,153.01 GPU1.J26
FBA_D0: length 38
  TOP w0.178: VRAM3.E3 204.37,169.94 204.37,169.58 204.55,169.4 204.8,169.4 204.95,169.55 v2(204.95,169.73) ; v1(201.22,145.38) 201.02,145.38 200.79,145.61 v2(200.65,145.61)
  L3 w0.165: v2(204.95,169.73) 204.95,170.25 205.07,170.37 205.51,170.37 205.8,170.08 205.8,169.33 206.27,168.85 206.27,168.23 207.89,166.61 207.89,164.44 207.72,164.28 207.23,164.28 207.1,164.15 207.1,163.83 207.23,163.71 207.72,163.71 207.89,163.54 207.89,163.19 209.18,161.9 209.18,152.06 207.53,150.41 207.39,150.41 206.85,149.87 206.61,149.87 206.6,149.88 206.36,149.88 206.19,149.71 206.19,149.48 206.21,149.46 206.21,149.23 206.04,149.06 205.8,149.06 205.79,149.07 205.56,149.07 205.39,148.9 205.39,148.67 205.4,148.66 205.4,148.42 205.15,148.17 204.91,148.17 204.68,148.4 204.5,148.4 204.28,148.17 204.28,147.99 204.51,147.77 204.51,147.56 204.41,147.46 204.41,147.46 204.15,147.2 204.15,147.2 202.53,145.58 200.69,145.58 v2(200.65,145.61)
  BOTTOM w0.178: GPU1.E18 200.35,146.09 200.52,146.09 200.65,145.96 v2(200.65,145.61)
FBA_D1: length 39.8
  TOP w0.178: v2(202.56,169.73) 202.56,169.52 202.2,169.16 201.87,169.16 201.69,169.33 201.69,169.66 VRAM3.H3 ; v2(199.85,145.53) 200.55,146.23 v1(200.55,146.42)
  L3 w0.165: v2(202.56,169.73) 202.85,170.02 204.39,170.02 204.47,169.94 204.47,169.5 204.69,169.27 205.21,169.27 205.4,169.07 205.4,167.54 206.06,166.88 206.06,165.31 206.3,165.07 206.3,164.16 208.78,161.68 208.78,152.35 207.62,151.19 207.29,151.19 204.77,148.67 204.11,148.67 202.73,147.28 202.73,147.05 202.96,146.82 202.96,146.58 202.79,146.41 202.56,146.41 202.33,146.65 202.09,146.65 201.9,146.46 201.9,146.06 201.72,145.88 201.31,145.88 200.9,146.29 200.39,146.29 199.85,145.74 v2(199.85,145.53)
  BOTTOM w0.178: v2(199.85,145.53) 199.83,145.54 199.26,145.54 199.14,145.66 199.14,145.84 199.29,145.99 GPU1.F18
FBA_D2: length 43
  TOP w0.178: VRAM3.F2 204.15,171.32 204.15,172.08 204.35,172.28 204.35,172.83 v2(204.49,172.97) 204.49,173.66 v1(203.88,174.27)
  L3 w0.165: v2(204.49,172.97) 204.47,172.95 204.47,172.16 204.8,171.83 206.27,171.83 208.76,169.34 208.76,163.38 209.97,162.17 209.97,151.45 206.64,148.13 206.64,147.38 203.48,144.22 201.16,144.22 200.99,144.39 200.32,144.39 v2(199.84,143.91)
  BOTTOM w0.178: GPU1.E16 200.24,144.31 v2(199.84,143.91)
FBA_D3: length 39.5
  TOP w0.178: VRAM3.G2 203.19,170.68 203.19,170.68 v2(203.37,170.5) ; v2(199.78,144.74) 200,144.74 v1(200.27,144.47)
  L3 w0.165: v2(199.78,144.74) 199.93,144.9 200.67,144.9 200.94,145.17 203.8,145.17 205.16,146.53 205.16,146.91 205.38,147.12 205.75,147.12 206.19,147.56 206.19,148.49 209.57,151.88 209.57,162.08 208.32,163.33 208.32,166.99 208.16,167.16 207.79,167.16 207.67,167.28 207.67,167.6 207.79,167.73 208.16,167.73 208.32,167.89 208.32,168.16 205.66,170.83 204.75,170.83 204.42,171.16 204.02,171.16 v2(203.37,170.5)
  BOTTOM w0.178: v2(199.78,144.74) 199.41,145.11 GPU1.F17
FBA_D4: length 37.7
  TOP w0.178: VRAM3.F7 203.75,166.66 204.12,166.29 204.12,164.54 203.7,164.12 203.21,164.12 v2(202.6,163.51) ; v2(200.65,148) v1(201.06,147.59)
  L3 w0.165: v2(202.6,163.51) 202.6,162.53 202.91,162.22 203.77,162.22 206.72,159.28 206.72,155.92 206.55,155.75 206.31,155.75 206.14,155.92 206.14,159.06 204.95,160.25 204.78,160.25 204.54,160.02 204.54,159.84 205.57,158.8 205.57,150.95 204.39,149.76 203.8,149.76 201.64,147.61 200.88,147.61 200.65,147.84 v2(200.65,148)
  BOTTOM w0.178: GPU1.D20 201.05,147.87 200.92,148 v2(200.65,148)
FBA_D5: length 35.3
  TOP w0.178: VRAM3.H8 201.76,165.73 201.76,165.1 201.35,164.69 201.35,164.33 v2(201.38,164.29) ; v2(201.46,148.88) 201.66,148.88 v1(202.16,148.38)
  L3 w0.165: v2(201.38,164.29) 201.38,161.7 203.17,159.91 203.17,159.9 203.17,159.2 202.5,158.53 202.5,156.23 202.63,156.1 202.94,156.1 203.07,156.23 203.07,158.18 203.2,158.31 203.52,158.31 203.64,158.18 203.64,154.72 203.77,154.59 204.74,154.59 204.87,154.47 204.87,152.74 204.7,152.58 202.48,152.58 202.35,152.45 202.35,151.99 202.48,151.86 204.74,151.86 204.87,151.74 204.87,151.36 204.47,150.97 203.06,150.97 202.88,150.79 202.88,150.12 203.01,149.99 203.01,149.8 202.75,149.53 202.51,149.53 202.34,149.7 202.16,149.7 201.94,149.48 201.94,149.3 202.11,149.13 202.11,148.9 201.82,148.6 201.58,148.6 201.46,148.73 v2(201.46,148.88)
  BOTTOM w0.178: GPU1.D21 201.19,148.33 201.35,148.33 201.46,148.44 v2(201.46,148.88)
FBA_D6: length 38.3
  TOP w0.178: v1(199.39,146.83) 199.39,146.85 v2(199,147.24) ; VRAM3.H7 202.09,166.98 202.09,167.94 v2(202.29,168.14)
  L3 w0.165: v2(199,147.24) 199.25,147.24 199.42,147.41 199.42,148.66 199.37,148.72 199.37,148.73 198.53,149.58 198.53,151.19 199.12,151.78 200.22,151.78 200.45,151.56 200.86,151.56 201.17,151.86 201.82,151.86 202,152.04 202,152.6 202.59,153.2 202.59,154.13 202.72,154.25 202.93,154.25 203.12,154.44 203.12,155.41 202.98,155.55 202.02,155.55 201.87,155.4 201.87,154.92 201.59,154.64 201.06,154.64 200.84,154.86 200.84,155.18 200.7,155.31 200.7,157.1 200.83,157.22 201.2,157.22 201.32,157.1 201.32,156.69 201.45,156.57 201.77,156.57 201.89,156.69 201.89,159.45 202.2,159.75 202.2,160.33 200.5,162.03 200.5,165 200.75,165.25 203.54,165.25 203.86,165.56 203.86,166.74 202.46,168.14 v2(202.29,168.14)
  BOTTOM w0.178: GPU1.F20 199.39,147.63 v2(199,147.24)
FBA_D7: length 38.9
  TOP w0.178: v2(202.52,164.17) 203.09,164.74 203.09,164.82 203.32,165.04 203.32,165.69 VRAM3.F8
  L3 w0.165: v2(202.52,164.17) 202.32,164.37 201.98,164.37 201.89,164.28 201.89,162.58 202.63,161.83 203.56,161.83 204.49,160.9 204.49,160.67 204.32,160.49 204.08,160.49 203.32,161.26 203.14,161.26 202.92,161.03 202.92,160.85 204.04,159.73 204.04,155.12 204.16,154.99 204.48,154.99 204.61,155.12 204.61,158.61 204.73,158.74 205.05,158.74 205.18,158.61 205.18,151.3 204.58,150.7 203.68,150.7 203.28,150.3 203.28,149.69 201.69,148.1 201.17,148.1 200.83,148.44 200.06,148.44 199.87,148.25 v2(199.87,148.02)
  BOTTOM w0.178: v2(199.87,148.02) 199.87,148.35 199.98,148.47 GPU1.E21 ; v2(202.52,164.17) 202.07,163.72 v1(202.07,162.75)
FBA_D8: length 46
  TOP w0.178: v2(206.54,166.51) 206.22,166.51 206.15,166.43 VRAM3.C8
  L4 w0.165: v2(206.54,166.51) 206.54,166.88 206.61,166.95 207.55,166.95 207.79,166.7 207.79,166.25 209.07,164.97 209.35,164.97 209.54,165.16 209.54,165.43 208.46,166.51 208.46,166.74 208.7,166.98 208.93,166.98 210.73,165.18 210.73,164.66 213.35,162.04 213.82,162.04 214.09,161.77 214.09,156.71 213.92,156.55 213.63,156.55 213.45,156.36 213.45,156.07 213.63,155.88 213.95,155.88 214.09,155.75 214.09,155.36 213.95,155.22 213.62,155.22 213.45,155.05 213.45,151.08 211.67,149.31 211.67,147.21 209.32,144.86 207.1,144.86 206.4,144.15 204.41,144.15 204.19,144.37 201.77,144.37 201.67,144.28 201.26,144.28 201.14,144.15 201.14,143.74 200.64,143.25 v2(200.64,143.13)
  BOTTOM w0.178: GPU1.E15 200.25,143.29 200.41,143.13 v2(200.64,143.13)
FBA_D9: length 47.7
  TOP w0.178: v2(200.67,143.92) 201.38,143.92 v1(201.38,143.91) ; VRAM3.B8 206.55,165.72 206.55,164.7 206.86,164.39 208.18,164.39 208.36,164.57 208.36,165.36 208.53,165.54 208.89,165.54 209.07,165.36 209.07,164.57 209.25,164.39 209.69,164.39 209.94,164.63 v2(209.94,164.96)
  L4 w0.165: v2(209.94,164.96) 210.23,164.96 210.41,164.79 210.41,164.42 213.22,161.62 213.53,161.62 213.69,161.45 213.69,161.12 213.53,160.96 213.22,160.96 213.05,160.79 213.05,160.46 213.22,160.3 213.53,160.3 213.69,160.13 213.69,159.8 213.53,159.63 213.22,159.63 213.05,159.47 213.05,159.14 213.22,158.97 213.53,158.97 213.69,158.81 213.69,158.48 213.53,158.31 213.22,158.31 213.05,158.15 213.05,157.82 213.22,157.65 213.53,157.65 213.69,157.49 213.69,157.16 213.53,156.99 213.22,156.99 213.05,156.83 213.05,151.24 211.28,149.47 211.28,147.71 211.05,147.49 210.81,147.49 210.58,147.49 210.34,147.26 210.34,147.02 210.48,146.88 210.48,146.61 210.29,146.41 210.02,146.41 209.88,146.56 209.64,146.56 209.41,146.32 209.41,146.09 209.55,145.95 209.55,145.67 209.27,145.39 208.92,145.39 208.58,145.73 208.26,145.73 207.82,145.3 207.02,145.3 206.14,144.42 204.86,144.42 204.59,144.69 202.15,144.69 201.44,145.39 201.19,145.39 200.97,145.17 200.41,145.17 200.25,145 200.25,144.52 200.38,144.4 200.56,144.4 200.67,144.28 v2(200.67,143.92)
  BOTTOM w0.178: GPU1.D15 201.05,143.76 200.89,143.92 v2(200.67,143.92)
FBA_D10: length 47.9
  TOP w0.178: v2(205.85,167.79) 205.85,168.57 205.68,168.74 205.27,168.74 205.1,168.57 205.1,167.07 205.25,166.92 VRAM3.D7
  L4 w0.089: v2(199.83,143.02) 199.83,143 200.13,142.7 200.86,142.7 201.06,142.9 201.06,143.29 201.18,143.4
  L4 w0.165: 201.18,143.4 201.88,144.11 204.08,144.11 204.3,143.89 206.62,143.89 207.19,144.45 209.52,144.45 212.06,147 212.06,149.14 214.08,151.16 214.08,151.52 214.48,151.92 214.48,152.62 214.32,152.79 214.04,152.79 213.88,152.95 213.88,153.28 214.04,153.45 214.32,153.45 214.48,153.62 214.48,162 213.98,162.5 213.74,162.5 213.71,162.47 213.48,162.47 213.25,162.71 213.25,162.94 213.28,162.97 213.28,163.2 213.04,163.44 212.81,163.44 212.78,163.41 212.55,163.41 212.31,163.64 212.31,163.88 212.34,163.91 212.34,164.14 212.11,164.37 211.87,164.37 211.84,164.34 211.61,164.34 211.38,164.58 211.38,164.81 211.41,164.84 211.41,165.07 209.17,167.31 206.1,167.31 205.85,167.56 v2(205.85,167.79)
  BOTTOM w0.178: GPU1.F15 199.64,143.51 199.83,143.32 v2(199.83,143.02)
FBA_D11: length 52.2
  TOP w0.178: v2(210.46,169.98) 210.38,169.91 210.38,169.18 208.12,166.92 VRAM3.A7
  L4 w0.089: v2(199.8,142.26) 199.97,142.26 200.38,141.84 201.01,141.84
  L4 w0.165: 201.01,141.84 201.46,141.4 202.14,141.4 203.02,140.52 207.41,140.52 207.49,140.59 208.43,140.59 209.17,141.34 210.62,141.34 215.1,145.82 215.1,147.22 216.99,149.1 216.99,150.31 217.39,150.71 217.39,163.23 210.64,169.98 v2(210.46,169.98)
  BOTTOM w0.178: v2(210.46,169.98) 210.57,169.87 v1(211.29,169.87) ; v2(199.8,142.26) 199.8,142.25 199.41,141.86 GPU1.F13
FBA_D12: length 49.9
  TOP w0.178: v2(201.48,142.25) 201.04,142.69 v1(201.04,142.73) ; v2(209.37,171.68) 209.37,171.66 208.95,171.24 208.94,171.24 208.21,170.5 206.57,170.5 VRAM3.C2
  L4 w0.165: v2(209.37,171.68) 209.65,171.4 209.65,169.8 210.29,169.16 210.36,169.16 216.6,162.91 216.6,151.04 216.2,150.64 216.2,149.43 214.32,147.55 214.32,146.15 210.29,142.12 208.59,142.12 207.89,141.43 202.82,141.43 202.42,141.83 201.9,141.83 v2(201.48,142.25)
  BOTTOM w0.178: GPU1.C13 201.66,141.83 201.48,142 v2(201.48,142.25)
FBA_D13: length 51
  TOP w0.178: v1(203.12,143.71) 203.4,143.71 v2(204.59,142.52) ; VRAM3.C3 206.38,170.12 207.8,168.71 208.22,168.71 209.24,169.73 209.24,170.16 v2(209.11,170.29)
  L4 w0.165: v2(209.11,170.29) 209.11,170.51 208.81,170.82 208.36,170.82 208.2,170.65 208.2,170.01 208.36,169.84 209.11,169.84 216.21,162.74 216.21,151.2 215.81,150.8 215.81,149.59 213.92,147.71 213.92,146.32 210.12,142.52 208.35,142.52 207.67,141.84 206.27,141.84 206.17,141.74 205.3,141.74 204.59,142.45 v2(204.59,142.52)
  BOTTOM w0.178: GPU1.B13 203.03,142.21 204.41,142.21 204.59,142.4 v2(204.59,142.52)
FBA_D14: length 51.4
  TOP w0.178: v2(210.43,170.67) 210.36,170.74 208.84,170.74 208.22,170.12 VRAM3.A3 ; v2(200.64,141.42) 200.24,141.03 v1(200.24,141.03)
  L4 w0.165: v2(210.43,170.67) 210.67,170.67 217.78,163.55 217.78,150.55 217.38,150.15 217.38,148.94 215.5,147.06 215.5,145.63 210.78,140.92 209.82,140.92 208.84,139.94 208.84,139.92 208.57,139.65 208.55,139.65 208.53,139.63 207.26,139.63 206.73,140.16 202.78,140.16 201.92,141.02 201.46,141.02 201.05,141.42 v2(200.64,141.42)
  BOTTOM w0.178: v2(200.64,141.42) 200.64,141.43 200.25,141.82 GPU1.E13
FBA_D15: length 50.2
  TOP w0.178: VRAM3.A2 208.23,170.92 208.78,171.48 208.78,172.04 209.04,172.29 209.62,172.29 v2(209.65,172.27) v1(210.56,172.27)
  L4 w0.165: v2(204.77,140.96) 204.8,140.99 208.19,140.99 208.93,141.73 210.45,141.73 214.71,145.99 214.71,147.38 216.59,149.27 216.59,150.47 217,150.88 217,163.07 210.65,169.42 210.4,169.42 209.95,169.87 209.95,171.96 v2(209.65,172.27)
  BOTTOM w0.178: GPU1.D13 201.47,141.41 204.26,141.41 204.72,140.96 v2(204.77,140.96)
FBA_D16: length 42.5
  L4 w0.165: v2(203.83,172.51) 203.83,171.63 205.41,170.05 205.41,167.6 206.09,166.93 206.09,166.27 206.88,165.49 206.88,164.71 207.17,164.42 209.86,164.42 212.66,161.62 212.66,151.41 210.88,149.63 210.88,148.35 208.86,146.33 v2(208.25,146.33)
  BOTTOM w0.178: v2(203.83,172.51) 204.13,172.21 204.13,171.3 VRAM1.F8 ; v2(208.25,146.33) v1(206.87,144.95) 206.69,144.77 206.39,144.77 204.74,143.13 203.03,143.13 GPU1.B15
FBA_D17: length 38.7
  L4 w0.165: v2(204.12,170.52) 204.41,170.23 204.41,169.63 205.14,168.89 205.14,167.49 205.81,166.83 205.81,166.12 206.6,165.33 206.6,164.61 207.12,164.09 209.55,164.09 212.26,161.38 212.26,151.57 210.49,149.79 210.49,148.52 209.47,147.5 208.24,147.5 v2(208.18,147.44)
  BOTTOM w0.178: VRAM1.F7 203.75,170.13 204.12,170.5 v2(204.12,170.52) ; v2(208.18,147.44) v1(207.77,147.03) 207.53,146.79 206.24,146.79 205.87,146.42 205.53,146.08 205.53,145.96 204.08,144.51 203.8,144.51 203.61,144.7 202.5,144.7 202.11,144.31 GPU1.C16
FBA_D18: length 41.7
  L4 w0.165: v2(202.83,169.13) 203.54,169.13 204.19,168.48 204.74,168.48 204.87,168.36 204.87,167.47 204.49,167.09 204.49,165.54 204.78,165.25 204.78,164.84 206.14,163.48 208.84,163.48 211.48,160.84 211.48,151.9 209.7,150.12 209.7,149.56 v2(208.4,148.26)
  BOTTOM w0.178: v2(202.83,169.13) 202.5,169.13 202.03,169.6 202.03,170 VRAM1.H7 ; v2(208.4,148.26) 208.71,147.96 208.71,147.91 209.35,147.27 209.91,147.27 210.08,147.09 210.08,146.74 209.91,146.56 209.35,146.56 209.17,146.38 209.17,146.01 v1(208.77,145.62) 207.42,144.26 206.53,144.26 205.04,142.77 205.04,142.29 204.53,141.77 203.51,141.77 GPU1.A13
FBA_D19: length 41.5
  L4 w0.165: v2(205.84,144.86) 205.73,144.96 205.73,146.38 205.38,146.74 205.38,147.36 204.55,148.19 204.21,148.19 203.93,148.47 203.93,149.28 204.72,150.07 206.35,150.07 207.13,150.84 207.4,150.84 209.36,152.8 209.36,159.77 208.41,160.71 205.86,160.71 203.37,163.21 203.32,163.21 203.04,163.49 203.04,167.52 202.73,167.82 202.73,168.59 202.03,169.29 202.03,170.23 202.14,170.34 202.14,170.7 202.73,171.29 202.73,171.79 202.49,172.04 201.97,172.04 201.76,171.82 v2(201.76,171.29)
  BOTTOM w0.178: GPU1.A15 203.45,143.51 203.52,143.44 204.66,143.44 205.84,144.62 v2(205.84,144.86) ; v2(201.76,171.29) 201.76,171.3 202.13,170.92 VRAM1.H8
FBA_D20: length 40.4
  TOP w0.178: v1(203.78,162.67) 203.78,163.37 v2(203.51,163.64)
  L4 w0.165: v2(203.51,163.64) 205.49,161.66 208.02,161.66 209.75,159.93 209.75,152.64 207.51,150.39 207.05,150.39 206.45,149.79 205.84,149.79 205.78,149.73 205.78,149.04 205.61,148.87 205.28,148.87 205.12,149.04 205.12,149.57 205.05,149.64 204.67,149.64 204.21,149.18 204.21,148.65 204.39,148.47 204.67,148.47 205.05,148.09 205.33,148.09 205.46,148.21 205.96,148.21 206.32,147.86 206.32,146.83 206.15,146.66 205.85,146.66 205.68,146.83 205.68,147.76 v2(205.7,147.76)
  BOTTOM w0.178: GPU1.B18 202.66,146 202.97,146 203.08,145.89 203.08,145.69 203.47,145.29 204.07,145.29 204.87,146.09 204.87,146.21 205.33,146.67 205.33,146.97 205.46,147.1 205.75,147.1 205.89,147.23 205.89,147.58 205.71,147.76 v2(205.7,147.76) ; v2(203.51,163.64) 203.51,163.63 204.78,163.63 204.93,163.78 204.93,164.16 204.78,164.32 204.31,164.32 204.16,164.47 204.16,165.97 204.01,166.12 VRAM1.F2
FBA_D21: length 38.2
  L4 w0.165: v2(209.19,148.11) 209.52,148.11 210.1,148.69 210.1,149.96 211.87,151.73 211.87,161.08 209.12,163.83 206.99,163.83 206.32,164.49 206.32,165.19 v2(204.99,166.52)
  BOTTOM w0.178: GPU1.A18 203.45,145.85 203.58,145.72 204.11,145.72 204.59,146.2 204.59,146.33 205.05,146.79 205.05,147.76 205.76,148.47 207.75,148.47 v1(208.93,149.66) 210.13,150.85 210.41,150.85 210.63,150.64 210.63,150.35 208.91,148.63 208.91,148.39 v2(209.19,148.11) ; VRAM1.E3 204.55,166.59 204.63,166.52 v2(204.99,166.52)
FBA_D22: length 38.1
  TOP w0.178: v1(203.09,147.26) 203.33,147.02 v2(204.59,147.02)
  L4 w0.165: v2(204.59,147.02) 204.39,146.82 203.93,146.82 203.73,146.61 203.5,146.61 203.37,146.74 203.37,150.37 203.65,150.65 206,150.65 208.57,153.22 208.57,159.44 208.09,159.92 205.38,159.92 203.22,162.08 202.7,162.08 201.28,163.5 200.94,163.5 200.76,163.68 200.76,164.9 201.16,165.31 201.93,165.31 202.1,165.48 202.1,165.89 201.95,166.04 201.53,166.04 201.37,166.2 200.95,166.2 200.78,166.36 200.78,166.72 200.95,166.88 201.52,166.88 202.04,167.4 v2(202.53,167.4)
  BOTTOM w0.178: VRAM1.H3 202.15,167.31 202.24,167.4 v2(202.53,167.4) ; v2(204.59,147.02) 204.59,146.96 204.46,146.83 203.87,146.83 203.49,146.83 203.45,146.79 GPU1.A19
FBA_D23: length 40.3
  TOP w0.178: v1(203.1,146.02) 203.46,146.38 204.13,146.38 v2(204.13,146.38)
  L4 w0.165: v2(202.43,164.81) 202.21,165.03 201.98,165.03 201.85,164.9 201.85,163.32 202.82,162.35 203.64,162.35 205.67,160.32 208.25,160.32 208.96,159.6 208.96,153.06 206.28,150.37 204.64,150.37 204.03,149.76 203.86,149.76 203.65,149.56 203.65,148.29 204.03,147.91 204.44,147.91 205.05,147.3 205.05,146.64 205.46,146.23 205.46,145.14 205.3,144.99 203.56,144.99 203.4,145.15 203.4,145.48 203.56,145.65 204.38,145.65 204.54,145.81 204.54,146.21 204.38,146.38 v2(204.13,146.38)
  BOTTOM w0.178: GPU1.C19 201.85,146.66 202.1,146.4 203.57,146.4 203.75,146.23 203.99,146.23 v2(204.13,146.38) ; v2(202.43,164.81) 202.96,164.81 203.32,165.17 203.32,165.55 202.95,165.92 VRAM1.G2
FBA_D24: length 42.7
  BOTTOM w0.178: VRAM1.A2 208.12,166.12 208.38,165.87 208.38,164.57 208.2,164.39 207.46,164.39 207.3,164.23 207.3,163.92 206.57,163.2 206.57,155.58 206.75,155.4 207.18,155.4 207.36,155.58 207.36,162.79 207.54,162.97 208.15,162.97 208.33,162.79 208.33,159.47 208.5,159.29 209.93,159.29 210.05,159.16 210.05,158.63 209.93,158.51 208.4,158.51 208.22,158.33 208.22,157.97 208.4,157.79 209.9,157.79 210.08,157.62 210.08,157.13 209.9,156.95 208.81,156.95 208.55,156.7 v1(208.55,156.26) 208.55,155.6 206.88,153.93 206.88,153.73 206.52,153.37 206.04,153.37 204.03,151.36 203.46,151.36 203.45,151.35 203.03,151.35 GPU1.B24
FBA_D25: length 44.9
  BOTTOM w0.102: 203.88,150.65 203.63,150.65 203.45,150.47 202.31,150.47 202.23,150.4 202.13,150.4 GPU1.C23
  BOTTOM w0.178: 203.88,150.65 203.91,150.68 204.46,150.68 206.04,152.25 206.47,152.25 v1(207.69,153.47) 214.22,160 214.22,161.61 214.12,161.71 210.87,161.71 210.69,161.89 210.69,162.24 210.87,162.42 214.12,162.42 214.29,162.6 214.29,162.95 214.12,163.13 210.87,163.13 210.69,163.31 210.69,163.66 210.87,163.84 214.12,163.84 214.29,164.02 214.29,164.34 214.04,164.6 210.69,164.6 210.56,164.72 210.56,165.18 210.56,165.18 210.56,165.43 210.56,165.43 210.56,165.84 210.38,166.02 209.04,166.02 208.63,166.43 208.63,167.11 208.45,167.29 206.52,167.29 VRAM1.C3
FBA_D26: length 42.3
  BOTTOM w0.178: VRAM1.C2 206.27,166.12 206.55,165.84 206.55,163.76 205.94,163.15 205.94,159.16 205.94,159.16 v1(205.94,157.85) 205.94,155.05 206.12,154.87 206.55,154.87 206.73,154.7 206.73,154.34 206.55,154.16 206.12,154.16 205.94,153.99 205.94,153.83 205.77,153.65 205.41,153.65 205.23,153.83 205.23,157.33 205.05,157.51 204.7,157.51 204.52,157.33 204.52,155.25 204.34,155.07 203.99,155.07 203.81,155.25 203.81,157.33 203.63,157.51 199.38,157.51 199.21,157.33 199.21,156.98 199.38,156.8 202.92,156.8 202.92,156.79 203.1,156.62 203.1,156.21 202.92,156.04 201.95,156.04 201.77,155.86 201.77,155.2 201.95,155.02 202.92,155.02 203.1,154.84 203.1,154.54 203.28,154.36 204.34,154.36 204.52,154.18 204.52,153.8 204.62,153.7 204.62,152.67 203.71,151.77 GPU1.A25
FBA_D27: length 42.7
  BOTTOM w0.178: GPU1.A24 203.51,151.03 204.34,151.03 206.12,152.81 206.37,152.81 208.18,154.62 v1(208.18,154.63) 208.19,154.63 211.45,157.89 211.45,158.32 211.32,158.45 210.64,158.45 210.46,158.63 210.46,159.08 210.64,159.26 212.72,159.26 212.9,159.44 212.9,159.79 212.72,159.97 210.48,159.97 210.31,160.15 210.31,160.5 210.48,160.68 213.53,160.68 213.71,160.86 213.71,161.12 213.53,161.29 210.41,161.29 210.23,161.47 210.23,164.14 210.05,164.32 209.7,164.32 209.52,164.14 209.52,159.87 209.34,159.69 208.99,159.69 208.81,159.87 208.81,165.84 208.23,166.42 208.23,166.8 208.11,166.92 VRAM1.A3
FBA_D28: length 43.8
  BOTTOM w0.178: GPU1.A21 204.14,148.47 205.99,150.32 207.28,150.32 v1(208.66,151.71) 213.3,156.35 213.3,156.37 216.17,159.24 216.17,169.19 215.97,169.4 215.8,169.4 215.63,169.57 215.63,171 215.45,171.18 215.09,171.18 214.92,171 214.92,169.57 214.74,169.4 214.38,169.4 214.2,169.57 214.2,171.05 214.03,171.23 213.67,171.23 213.49,171.05 213.49,169.57 213.32,169.4 208.96,169.4 208.61,169.75 207.6,169.75 207.32,170.03 207.32,170.27 206.95,170.64 VRAM1.B8
FBA_D29: length 44.9
  BOTTOM w0.127: 206.05,149.91 204.35,148.21 203.73,148.21 203.64,148.11 203.3,148.11 202.95,148.47 GPU1.B21
  BOTTOM w0.178: 206.05,149.91 207.44,149.91 v1(210.65,153.12) 216.78,159.25 216.78,170.67 215.74,171.71 212.09,171.71 211.91,171.53 211.91,171.18 212.09,171 212.87,171 213.05,170.82 213.05,170.46 212.87,170.29 211.38,170.29 211.2,170.46 211.2,171.53 211.02,171.71 210.61,171.71 209.65,170.74 208.76,170.74 208.13,170.12 VRAM1.A7
FBA_D30: length 47.9
  BOTTOM w0.102: GPU1.C20 202.16,147.63 202.66,147.13 203.59,147.13 203.63,147.1 204.06,147.1 204.49,147.53
  BOTTOM w0.178: VRAM1.D7 205.35,170.25 205.76,170.67 205.76,171.06 206.05,171.35 206.3,171.35 206.55,171.59 206.55,172.13 207.16,172.75 216,172.75 217.83,170.92 217.83,159.15 209.57,150.89 v1(209.57,150.89) 209.57,150.89 207.6,148.92 205.81,148.92 204.49,147.6 204.49,147.53
FBA_D31: length 44.8
  BOTTOM w0.102: GPU1.C21 202.16,148.47 202.51,148.13 202.98,148.13 203.21,147.9 203.74,147.9 203.82,147.98 204.48,147.98 204.72,148.22
  BOTTOM w0.178: 204.72,148.22 205.9,149.41 207.51,149.41 v1(210.12,152.01) 217.22,159.11 217.22,170.9 216,172.11 210.43,172.11 209.37,171.05 208.46,171.05 207.96,170.55 207.6,170.55 207.33,170.82 207.33,171.06 207.1,171.29 206.78,171.29 206.41,170.92 VRAM1.C8
FBA_D32: length 47.7
  TOP w0.178: v1(191.76,148.39) 191.52,148.63 v2(191.52,148.94)
  L3 w0.165: v2(191.52,148.94) 191.52,148.88 191.4,148.75 191.19,148.75 191.07,148.88 191.07,149.94 190.55,150.45 190.55,150.87 189.87,151.54 189.52,151.54 189.44,151.47 189.44,151 189.31,150.87 187.24,150.87 186.47,151.64 186.47,151.87 186.58,151.97 187.24,151.97 187.34,152.07 187.34,152.8 187.18,152.97 186.64,152.97 186.47,153.13 186.47,153.37 186.64,153.54 187.34,153.54 187.47,153.66 187.47,153.98 187.34,154.11 186.64,154.11 186.47,154.27 186.47,154.52 186.64,154.68 187.34,154.68 187.47,154.81 187.47,155.12 187.34,155.25 186.64,155.25 186.47,155.42 186.47,155.66 186.64,155.82 187.18,155.82 187.34,155.99 187.34,156.62 187.19,156.77 184.32,156.77 183.98,157.11 183.75,157.11 183.65,157.01 183.41,157.01 183.24,157.18 183.24,157.41 183.34,157.52 183.34,157.75 183.17,157.92 182.94,157.92 182.84,157.82 182.6,157.82 182.43,157.99 182.43,158.23 182.71,158.51 182.71,158.69 182.49,158.92 182.31,158.92 181.99,158.6 181.76,158.6 181.59,158.77 181.59,159.01 181.69,159.11 181.69,159.47 181.38,159.78 177.03,159.78 174.83,161.98 174.45,161.98 173.87,162.56 173.87,164.13 174.27,164.53 174.27,170.21 174.61,170.55 v2(175.54,170.55)
  BOTTOM w0.178: v2(191.52,148.94) GPU1.R22 ; VRAM2.E3 175.78,170.29 175.78,170.3 v2(175.54,170.55)
FBA_D33: length 44.4
  TOP w0.178: v1(191.5,151.23) 191.51,151.22 v2(191.51,150.59)
  L3 w0.165: v2(177.19,170.52) 177.19,170.4 176.59,169.8 175.68,169.8 174.81,168.94 174.81,164.59 175.4,164 175.4,162.59 177.37,160.62 181.97,160.62 182.63,159.96 183.91,159.96 185.92,157.95 186.15,157.72 186.15,157.72 186.3,157.56 189.22,157.56 189.38,157.39 189.38,153.5 189.26,153.37 188.94,153.37 188.81,153.5 188.81,156.83 188.65,157 188.41,157 188.24,156.83 188.24,152.85 188.46,152.64 189.56,152.64 191.51,150.68 v2(191.51,150.59)
  BOTTOM w0.178: v2(177.19,170.52) 177.19,170.52 177.19,170.56 VRAM2.G2 ; GPU1.R24 191.89,150.97 v2(191.51,150.59)
FBA_D34: length 44
  TOP w0.178: v1(190.35,148.37) 190.61,148.62 v2(190.61,148.87)
  L3 w0.165: v2(190.61,148.87) 190.25,149.22 189.76,149.22 189.42,149.56 189.42,149.93 188.93,150.42 188.93,150.41 187.32,150.41 186.2,151.53 186.2,156.26 186.08,156.38 183.47,156.38 181.62,158.23 181.48,158.23 181.2,158.51 181.2,159.08 181,159.28 176.97,159.28 174.72,161.54 174.52,161.54 173.48,162.58 173.48,164.13 173.86,164.51 173.86,171.45 174.18,171.77 178.08,171.77 178.35,171.5 178.35,170.82 178.39,170.77 178.39,170.05 v2(177.96,169.61)
  BOTTOM w0.178: v2(190.61,148.87) 191.07,149.33 GPU1.T22 ; VRAM2.H3 178.35,170.01 v2(177.96,169.61)
FBA_D35: length 44.6
  L3 w0.165: v2(176.34,171.33) 176.76,170.92 176.76,170.34 176.49,170.08 174.8,170.08 174.54,169.83 174.54,164.4 175.02,163.92 175.02,163.61 174.85,163.44 174.31,163.44 174.18,163.31 174.18,163 174.31,162.87 174.85,162.87 175.02,162.7 175.02,162.35 177.17,160.2 181.83,160.2 182.47,159.56 183.75,159.56 185.17,158.14 185.17,157.96 184.95,157.73 184.77,157.73 183.53,158.97 183.35,158.97 183.12,158.75 183.12,158.57 184.52,157.17 187.6,157.17 187.74,157.03 187.74,152.37 187.73,152.36 187.73,151.94 187.97,151.71 188.36,151.71 188.9,152.25 189.55,152.25 190.91,150.88 190.91,150.56 191.51,149.96 v2(191.51,149.7)
  BOTTOM w0.178: VRAM2.F2 176.75,170.92 v2(176.34,171.33) ; v2(191.51,149.7) 191.91,150.11 GPU1.R23
FBA_D36: length 47.9
  L3 w0.165: v2(193.15,152.14) 193.22,152.22 193.22,153.54 193.35,153.66 193.66,153.66 193.82,153.5 193.82,152.25 193.95,152.13 194.27,152.13 194.4,152.25 194.4,153.5 194.56,153.66 195.91,153.66 196.21,153.36 196.6,153.36 196.86,153.61 196.86,153.66 196.86,153.66 196.86,154.86 197.34,155.35 197.34,159.71 197.22,159.83 196.9,159.83 196.77,159.71 196.77,155.7 196.64,155.57 196.33,155.57 196.2,155.7 196.2,159.47 195.72,159.95 190.72,159.95 190.63,160.04 186.96,160.04 184.48,162.51 182.59,162.51 182.07,163.03 178.76,163.03 177.68,164.11 177.25,164.11 v2(177.24,164.11)
  BOTTOM w0.178: GPU1.N25 193.52,151.77 v2(193.15,152.14) ; VRAM2.F8 176.35,165.72 176.35,164.4 176.64,164.11 v2(177.24,164.11)
FBA_D37: length 47.8
  TOP w0.178: v2(192.73,153.87) 192.73,154 v1(192.19,154.53)
  L3 w0.165: v2(192.73,153.87) 192.85,154 195.28,154 195.81,154.53 195.81,159.01 195.64,159.18 195.4,159.18 195.24,159.01 195.24,154.86 195.11,154.73 194.79,154.73 194.66,154.86 194.66,158.8 193.95,159.51 186.89,159.51 184.32,162.09 182.58,162.09 181.99,162.68 177.73,162.68 176.58,163.82 176.58,166.86 176.19,167.25 176.19,167.83 176.78,168.42 177.45,168.42 v2(177.64,168.24)
  BOTTOM w0.178: v2(192.73,153.87) 192.92,153.87 193.21,153.58 193.21,152.95 GPU1.N26 ; v2(177.64,168.24) 177.8,168.24 178.35,167.69 VRAM2.H7
FBA_D38: length 49.1
  TOP w0.178: v1(194,150.35) 193.39,150.35 v2(193.19,150.55)
  L3 w0.165: v2(193.19,150.55) 193.78,151.14 195.64,151.14 196.05,151.56 196.05,152.38 196.27,152.6 196.59,152.6 196.6,152.59 197.49,152.59 197.53,152.63 198.08,152.63 198.21,152.76 198.21,153.82 198.33,153.94 198.65,153.94 198.78,153.82 198.78,152.76 198.91,152.63 199.35,152.63 199.68,152.95 199.68,154.26 199.46,154.49 199.46,158.01 199.05,158.42 198.47,158.42 198.31,158.58 198.31,160.56 198.44,160.69 198.76,160.69 198.88,160.56 198.88,159.17 199.01,159.05 199.33,159.05 199.46,159.17 199.46,161.06 199.17,161.35 192.85,161.35 192.24,160.74 191.05,160.74 190.96,160.83 187.41,160.83 184.97,163.26 182.97,163.26 182.52,163.71 179.89,163.71 v2(179.23,164.38)
  BOTTOM w0.178: VRAM2.H8 178.78,165.69 178.78,165.17 179.23,164.72 v2(179.23,164.38) ; v2(193.19,150.55) 193.57,150.17 GPU1.N23
FBA_D39: length 48.2
  TOP w0.178: v2(193.2,151.36) 193.62,151.36 v1(193.83,151.57)
  L3 w0.165: v2(193.2,151.36) 193.45,151.61 194.75,151.61 195.18,152.03 195.18,153.13 195.39,153.34 195.39,153.34 195.45,153.39 195.8,153.39 196.15,153.04 196.7,153.04 197.28,153.62 197.28,154.91 197.55,155.17 197.91,155.17 198.16,154.93 198.66,154.93 198.92,155.19 198.92,155.55 198.9,155.57 198.9,157.66 198.77,157.79 198.46,157.79 198.33,157.66 198.33,155.9 198.2,155.78 197.88,155.78 197.76,155.9 197.76,159.98 196.78,160.95 196,160.95 195.83,160.79 195.83,160.51 195.67,160.34 195.43,160.34 195.26,160.51 195.26,160.79 195.1,160.95 194.85,160.95 194.69,160.79 194.69,160.51 194.52,160.34 194.28,160.34 194.12,160.51 194.12,160.79 193.95,160.95 193.01,160.95 192.4,160.34 190.88,160.34 190.79,160.43 187.24,160.43 185.88,161.79 185.88,161.79 184.77,162.9 182.74,162.9 182.26,163.38 178.89,163.38 177.57,164.7 177.57,164.92 177.55,164.93 177.55,166.57 v2(176.64,167.48)
  BOTTOM w0.178: v2(193.2,151.36) 193.59,150.98 GPU1.N24 ; v2(176.64,167.48) 176.64,167.03 VRAM2.F7
FBA_D40: length 47
  TOP w0.178: v1(189.79,151.17) 189.79,150.65 v2(189.86,150.57) ; v2(178.9,167.55) 178.75,167.71 178.28,167.71 178.16,167.59 178.16,167.11 VRAM4.H3
  L4 w0.165: v2(189.86,150.57) 189.76,150.68 189.76,152.61 185.73,156.64 176.74,156.64 176.1,157.28 176.1,160.14 176.87,160.91 176.87,161.19 176.67,161.39 176.39,161.39 175.44,160.44 175.44,157.98 175.24,157.78 174.97,157.78 174.78,157.98 174.78,160.72 176.12,162.06 178.53,162.06 180.55,164.08 180.55,165.11 180.36,165.3 179.29,165.3 179.29,165.3 178.79,165.3 178.55,165.53 178.55,165.9 178.76,166.1 179.27,166.1 179.56,166.39 179.56,166.62 179.09,167.1 178.55,167.1 178.42,167.23 178.42,167.42 178.55,167.55 v2(178.9,167.55)
  BOTTOM w0.178: v2(189.86,150.57) 189.46,150.17 GPU1.V23
FBA_D41: length 47.4
  TOP w0.178: v1(188.46,148.96) v2(189.03,148.96) ; VRAM4.E3 175.54,166.51 v2(175.54,166.49)
  L4 w0.165: v2(175.54,166.49) 175.54,166.36 175.36,166.18 175.1,166.18 174.92,166.36 174.92,167.92 174.73,168.11 174.45,168.11 174.26,167.92 174.26,166.45 174.06,166.25 173.79,166.25 173.59,166.45 173.59,166.78 173.33,167.04 172.96,167.04 172.7,166.78 172.7,165.81 172.51,165.62 172.23,165.62 172.04,165.81 172.04,166.17 171.87,166.33 171.54,166.33 171.38,166.17 171.38,165.68 171.21,165.52 170.41,165.52 170.23,165.33 170.23,164.95 170.57,164.6 170.57,164.34 170.39,164.16 170.13,164.16 169.76,164.52 169.62,164.52 169.53,164.43 169.53,159.11 177.07,151.57 184.94,151.57 185.31,151.95 185.31,152.35 185.57,152.61 185.93,152.61 186.4,152.14 186.4,151.42 187.83,150 187.83,148.88 188.05,148.66 188.87,148.66 189.03,148.82 v2(189.03,148.96)
  BOTTOM w0.178: v2(189.03,148.96) 189.41,149.33 GPU1.V22
FBA_D42: length 47
  TOP w0.178: v1(190.67,150.32) 190.67,149.8 v2(190.63,149.76) ; VRAM4.G2 177.65,166.02 177.69,166.02 v2(177.99,165.72)
  L4 w0.089: v2(190.63,149.76) 190.25,150.14 189.68,150.14 189.44,150.38
  L4 w0.165: v2(177.99,165.72) 177.99,165.53 178.49,165.03 179.19,165.03 179.66,164.56 179.66,164.55 179.67,164.54 179.67,164.15 179.8,164.02 179.8,163.74 179.6,163.54 179.32,163.54 178.94,163.93 178.7,163.93 178.47,163.69 178.47,163.46 178.88,163.05 178.88,162.82 178.61,162.55 174.01,162.55 173.04,161.57 173.04,160.16 173.23,159.97 173.5,159.97 173.7,160.16 173.7,161.29 174.28,161.88 174.56,161.88 174.75,161.68 174.75,161.41 174.36,161.02 174.36,157.84 175.03,157.17 175.26,157.17 175.33,157.23 175.56,157.23 175.79,157 175.79,156.77 175.73,156.7 175.73,156.47 176.47,155.73 176.8,155.73 176.96,155.89 176.96,156.05 177.13,156.21 177.46,156.21 177.62,156.05 177.62,155.89 177.79,155.73 178.12,155.73 178.28,155.89 178.28,156.05 178.45,156.21 178.78,156.21 178.94,156.05 178.94,155.89 179.11,155.73 179.44,155.73 179.6,155.89 179.6,156.05 179.77,156.21 180.1,156.21 180.26,156.05 180.26,155.89 180.43,155.73 180.76,155.73 180.92,155.89 180.92,156.05 181.09,156.21 181.42,156.21 181.58,156.05 181.58,155.89 181.75,155.73 182.68,155.73 183.15,156.19 185.79,156.19 189.47,152.52 189.47,151.17 189.33,151.04 189.33,150.49 189.44,150.38
  BOTTOM w0.178: GPU1.T23 191.04,150.17 v2(190.63,149.76)
FBA_D43: length 48.4
  TOP w0.178: VRAM4.F2 176.36,165.73 176.36,164.21 177.05,163.52 v2(177.51,163.52) 177.51,163.08 v1(177.16,162.74)
  L4 w0.165: v2(177.51,163.52) 177.51,163.32 177.36,163.17 176.99,163.17 176.83,163.33 176.83,163.84 176.66,164.01 176.33,164.01 176.17,163.84 176.17,163.33 176,163.17 175.61,163.17 175.51,163.27 175.51,163.41 175.31,163.6 175.04,163.6 174.84,163.41 174.84,163.28 174.73,163.17 173.61,163.17 173.16,162.72 171.52,162.72 171.33,162.52 171.33,162.25 171.52,162.06 172.08,162.06 172.25,161.89 172.25,161.56 172.08,161.4 171.46,161.4 171.26,161.2 171.26,160.93 171.46,160.74 172.04,160.74 172.24,160.54 172.24,160.27 172.04,160.08 171.67,160.08 171.48,159.88 171.48,159.61 171.67,159.42 172.13,159.42 172.24,159.3 172.24,158.84 177.1,153.98 179.87,153.98 180.33,154.45 184.66,154.45 185.18,154.97 186,154.97 188.61,152.36 188.61,151.6 188.43,151.42 188.43,150.92 189.45,149.9 189.45,149.37 189.55,149.27 190.14,149.27 190.19,149.31 190.89,149.31 191.05,149.16 191.05,148.17 190.84,147.96 190.54,147.96 190.33,148.17 190.33,148.37 v2(189.92,148.79)
  BOTTOM w0.178: GPU1.U22 189.92,148.98 v2(189.92,148.79)
FBA_D44: length 47.1
  TOP w0.178: VRAM4.H7 178.46,170 178.46,169.38 v2(178.07,168.99) ; v2(189,151.37) v1(189,152.11)
  L4 w0.165: v2(189,151.37) 189,152.34 186.07,155.28 183.99,155.28 183.83,155.11 183.83,154.9 183.66,154.73 183.33,154.73 183.17,154.9 183.17,155.11 183,155.28 182.67,155.28 182.51,155.11 182.51,154.9 182.34,154.73 182.01,154.73 181.85,154.9 181.85,155.19 181.7,155.33 180.09,155.33 179.93,155.17 179.93,154.72 179.73,154.53 179.46,154.53 179.27,154.72 179.27,155.17 179.1,155.33 178.77,155.33 178.61,155.17 178.61,154.64 178.41,154.45 178.14,154.45 177.95,154.64 177.95,155.17 177.78,155.33 177.45,155.33 177.28,155.17 177.28,155.02 177.09,154.83 176.82,154.83 176.62,155.02 176.62,155.17 176.46,155.33 176.3,155.33 173.96,157.67 173.96,159.35 173.77,159.54 173.5,159.54 173.3,159.35 173.3,159.04 173.11,158.85 172.84,158.85 172.64,159.04 172.64,161.74 173.77,162.86 177.73,162.86 178.17,163.29 178.17,164.1 177.63,164.64 177.63,164.93 177.55,165.01 177.55,166.7 178.15,167.3 178.15,168.29 178.69,168.83 178.69,169.02 178.86,169.19 178.86,169.55 178.73,169.69 178.53,169.69 178.4,169.55 178.4,169.32 v2(178.07,168.99)
  BOTTOM w0.178: GPU1.Y24 188.19,151.37 v2(189,151.37)
FBA_D45: length 47
  TOP w0.178: VRAM4.F7 176.72,170.12 v2(176.32,170.52) ; v1(185.19,151.11) 185.44,151.11 v2(185.72,151.39)
  L4 w0.165: v2(176.32,170.52) 176.57,170.52 176.79,170.31 176.79,169.99 176.62,169.82 175.75,169.82 173.83,167.9 173.55,167.9 173.36,168.09 173.36,168.37 175.11,170.12 175.11,170.39 174.92,170.59 174.65,170.59 172.7,168.64 172.7,167.58 172.37,167.24 171.36,167.24 169.13,165.02 169.13,158.95 176.9,151.18 183.04,151.18 183.21,151.01 183.21,150.59 183.37,150.43 183.7,150.43 183.87,150.59 183.87,151.01 184.03,151.18 185.51,151.18 v2(185.72,151.39)
  BOTTOM w0.178: v2(185.72,151.39) 185.81,151.39 185.81,151.39 186.53,151.39 GPU1.AA24
FBA_D46: length 46.8
  TOP w0.178: v2(178.79,171.32) 178.39,170.92 VRAM4.H8 ; v1(186.71,149.36) 187.11,148.95 v2(187.39,148.95)
  L4 w0.165: v2(187.39,148.95) 187.26,148.83 185.39,148.83 184.57,149.64 177.33,149.64 168.34,158.62 168.34,165.44 170.61,167.7 170.61,168.27 174.09,171.74 174.09,172.47 174.38,172.76 177.35,172.76 v2(178.79,171.32)
  BOTTOM w0.178: GPU1.Y22 187.45,148.99 187.43,148.99 v2(187.39,148.95)
FBA_D47: length 47.3
  TOP w0.178: v2(177.12,171.33) 176.75,170.96 VRAM4.F8 ; v1(187.09,150.56) 187.09,150.56 v2(186.53,150.56)
  L4 w0.165: v2(177.12,171.33) 176.61,171.84 174.56,171.84 173.98,171.25 173.98,171.02 174.11,170.89 174.11,170.62 173.91,170.43 173.64,170.43 173.51,170.55 173.28,170.55 172.68,169.96 172.68,169.51 172.78,169.41 172.78,169.14 172.59,168.95 172.32,168.95 172.24,169.03 171.96,169.03 171.77,168.84 171.77,168.56 171.87,168.47 171.87,168.23 171.27,167.63 171.13,167.63 168.74,165.24 168.74,158.78 176.76,150.76 177.48,150.76 177.64,150.6 177.64,150.21 177.81,150.05 178.14,150.05 178.3,150.21 178.3,150.6 178.47,150.76 178.8,150.76 178.96,150.6 178.96,150.21 179.13,150.05 179.46,150.05 179.62,150.21 179.62,150.6 179.79,150.76 180.12,150.76 180.28,150.6 180.28,150.21 180.45,150.05 180.78,150.05 180.94,150.21 180.94,150.6 181.11,150.76 182.26,150.76 182.91,150.11 184.54,150.11 185.47,149.19 186.1,149.19 186.53,149.62 v2(186.53,150.56)
  BOTTOM w0.178: v2(186.53,150.56) 186.56,150.56 GPU1.AA23
FBA_D48: length 40.9
  TOP w0.178: v1(180.67,153.29) 180.83,153.45 v2(181.46,153.45) ; v2(172.15,171.65) 172.3,171.5 172.43,171.5 172.59,171.34 172.73,171.34 173.13,171.34 VRAM4.B8
  L3 w0.165: v2(172.15,171.65) 171.77,171.65 171.21,171.09 171.21,170.4 170.87,170.07 170.33,170.07 168.47,168.21 168.47,156.28 173.9,150.86 174.71,150.86 174.89,151.05 174.89,152.2 175.3,152.6 177.68,152.6 177.85,152.77 177.85,153.24 178.06,153.45 v2(181.46,153.45)
  BOTTOM w0.178: GPU1.AD27 184.45,153.55 183.9,154.1 182.12,154.1 v2(181.46,153.45)
FBA_D49: length 44.1
  TOP w0.178: VRAM4.D7 174.75,170.52 172.03,170.52 171.99,170.56 170.83,170.56 v2(170.45,170.93)
  L3 w0.165: v2(170.45,170.93) 168.08,168.56 168.08,156.45 168.08,156.12 173.73,150.46 174.87,150.46 176.54,152.13 176.55,152.13 176.62,152.2 180.32,152.2 180.39,152.13 184.2,152.13 184.67,152.61 185.31,152.61 v2(185.75,152.17)
  BOTTOM w0.178: v2(170.45,170.93) 169.67,170.93 v1(169.1,170.36) ; v2(185.75,152.17) GPU1.AB25
FBA_D50: length 40.6
  TOP w0.178: v2(182.1,153.42) 182.1,154.18 v1(182.21,154.29) ; v2(171.81,170.11) 171.82,170.12 VRAM4.A7
  L3 w0.165: v2(171.81,170.11) 171.95,170.11 172.08,169.98 172.08,169.36 171.95,169.23 170.05,169.23 168.9,168.08 168.9,157.72 172.75,153.87 173.33,153.87 173.49,153.7 173.49,153.12 173.62,152.99 173.94,152.99 174.06,153.12 174.06,153.7 174.23,153.87 174.47,153.87 174.63,153.7 174.63,153.25 174.79,153.09 175.04,153.09 175.21,153.26 175.21,153.7 175.37,153.87 175.61,153.87 175.78,153.7 175.78,153.25 175.94,153.09 176.18,153.09 176.35,153.26 176.35,153.7 176.51,153.87 176.75,153.87 176.92,153.7 176.92,153.43 177.08,153.27 177.33,153.27 177.49,153.43 177.49,153.7 177.66,153.87 180.6,153.87 180.81,154.08 180.81,154.25 180.98,154.41 181.22,154.41 181.38,154.25 181.38,154.08 181.55,153.91 181.97,153.91 182.1,153.79 v2(182.1,153.42)
  BOTTOM w0.178: v2(182.1,153.42) 182.5,153.82 183.78,153.82 184.07,153.54 184.07,152.95 GPU1.AD26
FBA_D51: length 44.5
  TOP w0.178: VRAM4.C8 173.95,171.32 173.95,172.34 173.54,172.74 171.46,172.74 170.68,171.96 v2(170.68,171.96) ; v2(184.87,152.13) 184.15,152.13 v1(184.09,152.19)
  L3 w0.165: v2(184.87,152.13) 184.55,151.8 176.78,151.8 175.04,150.06 173.46,150.06 167.67,155.84 167.67,159.98 167.67,159.99 167.67,168.95 v2(170.68,171.96)
  BOTTOM w0.178: GPU1.AC25 185.23,151.77 v2(184.87,152.13)
FBA_D52: length 41.4
  TOP w0.178: VRAM4.A3 172.11,166.92 v2(171.95,166.76) ; v2(183.36,155.76) v1(183.36,154.95)
  L3 w0.165: v2(183.36,155.76) 181.27,157.85 181.09,157.85 180.8,158.14 180.8,158.63 180.54,158.89 180.1,158.89 179.94,158.72 179.94,158.23 179.77,158.07 179.53,158.07 179.37,158.23 179.37,158.72 179.2,158.89 178.96,158.89 178.79,158.72 178.79,158.23 178.63,158.07 178.39,158.07 178.22,158.23 178.22,158.72 178.06,158.89 177.82,158.89 177.65,158.72 177.65,158.23 177.49,158.07 177.24,158.07 177.08,158.23 177.08,158.72 176.91,158.89 176.52,158.89 173.53,161.88 173.35,161.88 173.12,161.66 173.12,161.48 175.72,158.88 175.72,158.65 175.55,158.48 175.32,158.48 172.49,161.31 172.49,163.19 173.05,163.75 173.05,164.42 172.92,164.55 172.75,164.55 172.63,164.68 172.63,165.27 172.75,165.4 173.5,165.4 173.59,165.49 173.59,166.01 173.5,166.09 172.97,166.09 172.71,166.35 172.71,167.34 172.58,167.47 172.03,167.47 171.95,167.4 v2(171.95,166.76)
  BOTTOM w0.178: v2(183.36,155.76) 184.21,154.91 184.46,154.91 184.98,154.39 186.11,154.39 186.95,153.56 GPU1.AA27
FBA_D53: length 42.1
  TOP w0.178: VRAM4.C3 174.35,167.4 173.62,168.13 172.4,168.13 v2(172.19,167.92) ; v2(184.1,155.76) 184.1,156.56 v1(184.1,156.56)
  L3 w0.165: v2(184.1,155.76) 184.26,155.76 184.39,155.63 184.39,155.26 184.27,155.14 183.23,155.14 180.73,157.63 176.72,157.63 176.58,157.78 176.58,158.24 176.45,158.36 176.13,158.36 176,158.24 176,157.78 175.86,157.63 175.54,157.63 172.09,161.08 172.09,164.34 171.45,164.98 171.45,167.81 172.04,168.4 172.34,168.4 172.43,168.49 172.43,170.92 172.56,171.04 173.46,171.04 173.59,170.92 173.59,168.1 173.41,167.92 173.22,167.92 173.21,167.92 v2(172.19,167.92)
  BOTTOM w0.178: v2(184.1,155.76) 185.13,154.73 186.25,154.73 187.33,153.65 187.33,153.05 186.95,152.67 GPU1.AA26
